# Allegro board 17859-1.0710WZS1337.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ37: length 54.8
  L4 w0.089: v1(86.86,24.34) 87.21,24.34 87.3,24.43 87.3,29.19 87.21,29.28 86.37,29.28 86.28,29.37 86.28,29.55 86.37,29.64 87.21,29.64 87.3,29.73 87.3,29.99 87.21,30.08 86.4,30.08 86.28,30.2 86.28,30.52 86.37,30.61 86.77,30.61 86.86,30.7 86.86,30.88 86.77,30.97 86.37,30.97 86.28,31.05 86.28,35.16 80,41.43 80,54.15 83.53,57.69 85.71,57.69 v1(86.4,58.38)
  BOTTOM w0.076: v1(86.4,58.38) 86.95,58.92 87.55,58.92 89.59,60.97 89.59,61.74 89.57,61.8 89.57,62.13 89.59,62.2 89.59,62.41 89.58,62.45 89.34,62.69 89.34,62.7 CPU1.H35
  BOTTOM w0.089: v1(86.86,24.34) 87.38,24.87 DM1.215
M_A_DQ38: length 55.4
  L4 w0.089: v1(86.42,55.63) 84.34,55.63 81.38,52.67 81.38,41.79 87.51,35.67 87.51,32.07 88.65,30.94 88.65,28.7 89.91,27.44 89.91,23.71 90,23.62 90.63,23.62 90.72,23.54 90.72,23.36 90.63,23.27 89.95,23.27 89.86,23.18 89.86,23 89.95,22.91 90.63,22.91 90.72,22.82 90.72,22.04 90.63,21.95 v1(89.2,21.95)
  BOTTOM w0.076: v1(86.42,55.63) 86.73,55.93 87.19,55.93 87.93,56.67 87.93,57.59 90.67,60.33 90.67,61.17 90.68,61.23 90.9,61.45 90.9,61.77 90.8,61.95 90.64,62.23 CPU1.K36
  BOTTOM w0.089: v1(89.2,21.95) 89.64,21.51 DM1.224
M_A_DQ39: length 54.2
  L4 w0.089: v1(86.4,56.26) 84.53,56.26 84.39,56.13 84.26,56.13 83.84,56.55 83.72,56.55 83.59,56.42 83.59,56.3 84.01,55.87 84.01,55.75 81.06,52.8 81.06,41.66 87.19,35.54 87.19,31.94 88.33,30.81 88.33,28.71 89.62,27.42 89.62,23.33 89.52,23.23 v1(89.16,23.23)
  BOTTOM w0.076: CPU1.K37 90.61,61.62 90.52,61.33 90.51,61.22 90.5,61.12 90.5,60.42 90.47,60.38 87.61,57.52 87.61,56.67 87.17,56.23 86.44,56.23 v1(86.4,56.26)
  BOTTOM w0.089: v1(89.16,23.23) 89.89,23.96 DM1.225
M_A_DQ40: length 54.5
  L4 w0.089: v1(88.83,57) 87.98,56.14 87.98,54.87 86.36,53.26 86.24,53.26 85.57,53.93 85.44,53.93 85.31,53.8 85.31,53.68 85.99,53.01 85.99,52.88 85.86,52.75 85.73,52.75 85.07,53.42 84.95,53.42 82.68,51.15 82.68,42.29 88.78,36.19 88.78,33.34 92.2,29.92 92.2,23.2 v1(91.17,22.18)
  BOTTOM w0.076: v1(88.83,57) 89.45,57.62 89.45,58.38 91.8,60.74 91.8,60.74 91.81,60.74 91.81,61.27 91.61,61.47 91.61,61.48 91.6,61.49 91.6,61.77 91.86,62.24 CPU1.N36
  BOTTOM w0.089: DM1.232 91.64,21.72 v1(91.17,22.18)
M_A_DQ41: length 54.5
  L4 w0.089: v1(88.79,57.63) 88,57.63 87.73,57.36 87.73,55.02 86.94,54.23 85.31,54.23 82.37,51.29 82.37,42.16 88.46,36.06 88.46,33.12 91.88,29.71 91.88,23.56 91.79,23.47 v1(91.2,23.47)
  BOTTOM w0.076: CPU1.N34 91.86,63.35 91.56,63.06 91.56,62.03 91.44,61.81 91.44,61.42 91.44,61.41 91.44,61.4 91.64,61.2 91.64,60.81 89.22,58.39 89.22,58.06 v1(88.79,57.63)
  BOTTOM w0.089: DM1.236 92.64,22.06 91.23,23.47 v1(91.2,23.47)
M_A_DQ42: length 54.8
  L4 w0.089: v1(96.15,22.81) 96.22,22.81 97.17,23.76 97.17,26.09 95.52,27.74 95.52,27.87 96.02,28.37 96.02,28.49 95.89,28.62 95.76,28.62 95.27,28.12 95.14,28.12 95.02,28.25 95.02,28.37 95.51,28.87 95.51,29 95.39,29.12 95.26,29.12 94.76,28.62 94.64,28.62 94.38,28.88 94.38,30.85 90.96,34.26 90.96,37.1 84.9,43.16 84.9,47.13 90.83,53.05 90.83,54.38 v1(90.38,54.82)
  BOTTOM w0.076: v1(90.38,54.82) 91.24,55.67 91.24,57.19 91.24,57.19 91.24,58.46 93.04,60.25 93.04,61.51 CPU1.R37
  BOTTOM w0.089: v1(96.15,22.81) 95.09,21.75 95.09,20.81 95.13,20.76 DM1.246
M_A_DQ43: length 54.4
  L4 w0.089: v1(96.21,21.42) 97.53,22.73 97.53,28.25 91.28,34.5 91.28,37.23 85.22,43.3 85.22,47 91.03,52.81 91.03,55.35 90.86,55.52 v1(90.43,55.52)
  BOTTOM w0.076: CPU1.R34 92.41,63.59 92.23,63.41 92.23,63.38 92.23,62.57 92.28,62.43 92.28,62.13 92.25,62.08 92.25,61.85 92.31,61.7 92.31,61.65 92.31,61.65 92.31,60.54 90.02,58.25 90.02,55.92 v1(90.43,55.52)
  BOTTOM w0.089: DM1.250 96.13,21.34 v1(96.21,21.42)
M_A_DQ44: length 54
  L4 w0.089: v1(88.84,55.73) 88.26,55.15 88.26,54.71 85.68,52.12 85.55,52.12 84.9,52.78 84.77,52.78 83,51.01 83,50.72 83.09,50.63 84.08,50.63 84.17,50.55 84.17,50.37 84.08,50.28 83.09,50.28 83,50.19 83,42.42 89.1,36.33 89.1,33.47 92.51,30.06 92.51,24.37 92.68,24.21 93.42,24.21 v1(93.51,24.3)
  BOTTOM w0.076: v1(88.84,55.73) 89.62,56.51 89.62,57.55 89.62,58.32 91.98,60.68 91.98,61.51 CPU1.N37
  BOTTOM w0.089: DM1.233 91.89,25.92 v1(93.51,24.3)
M_A_DQ45: length 54
  L4 w0.089: v1(93.54,25.62) 92.97,25.62 92.83,25.76 92.83,30.2 89.41,33.62 89.41,36.46 83.35,42.52 83.35,48.97 84.82,50.44 84.82,50.57 83.99,51.41 83.99,51.53 84.11,51.66 84.24,51.66 85.2,50.69 85.33,50.69 85.45,50.82 85.45,50.95 84.49,51.91 84.49,52.04 84.61,52.16 84.74,52.16 85.58,51.32 85.7,51.32 86.09,51.71 86.09,51.84 86,51.93 86,52.05 86.13,52.18 86.26,52.18 86.34,52.09 86.47,52.09 v1(88.84,54.46)
  BOTTOM w0.076: CPU1.N35 91.86,62.71 92.08,62.48 92.11,62.41 92.11,62.16 92.09,62.12 92.09,61.81 92.09,61.8 92.11,61.76 92.11,61.73 92.12,61.72 92.14,61.67 92.14,61.58 92.14,61.58 92.14,60.61 89.85,58.32 89.85,55.47 v1(88.84,54.46)
  BOTTOM w0.089: DM1.237 92.89,26.28 v1(93.54,25.62)
M_A_DQ46: length 55.1
  L4 w0.089: v1(96.23,25.51) 96.23,25.53 94.06,27.7 94.06,30.71 90.65,34.13 90.65,36.97 84.58,43.03 84.58,47.38 84.94,47.74 84.94,47.86 84.71,48.09 84.71,48.22 84.83,48.34 84.96,48.34 85.19,48.11 85.32,48.11 85.44,48.24 85.44,48.36 85.21,48.59 85.21,48.72 85.34,48.85 85.46,48.85 85.69,48.62 85.82,48.62 85.94,48.74 85.94,48.87 85.71,49.1 85.71,49.22 85.84,49.35 85.97,49.35 86.2,49.12 86.32,49.12 86.45,49.24 86.45,49.37 86.22,49.6 86.22,49.73 86.34,49.85 86.47,49.85 86.7,49.62 86.82,49.62 86.95,49.75 86.95,49.87 86.72,50.1 86.72,50.23 86.85,50.35 86.97,50.35 87.2,50.12 87.33,50.12 87.45,50.25 87.45,50.38 87.22,50.61 87.22,50.73 87.35,50.86 87.47,50.86 87.7,50.63 87.83,50.63 87.96,50.75 87.96,50.88 87.73,51.11 87.73,51.23 87.85,51.36 87.98,51.36 88.21,51.13 88.33,51.13 88.46,51.26 88.46,51.38 88.23,51.61 88.23,51.74 88.35,51.86 88.48,51.86 88.71,51.63 88.84,51.63 88.96,51.76 88.96,51.89 88.72,52.13 88.72,52.25 88.85,52.38 88.97,52.38 89.21,52.14 89.34,52.14 90.38,53.18 v1(90.38,53.55)
  BOTTOM w0.076: v1(90.38,53.55) 91.41,54.58 91.41,58.37 93.21,60.17 93.21,61.27 93.42,61.48 93.42,61.76 93.29,61.99 93.29,62 93.16,62.23 CPU1.R36
  BOTTOM w0.089: DM1.249 95.89,25.85 v1(96.23,25.51)
M_A_DQ47: length 54.4
  L4 w0.089: v1(89.74,53.39) 89.37,53.39 84.26,48.28 84.26,42.9 90.33,36.84 90.33,34 93.75,30.58 93.75,27.71 95.19,26.27 95.19,25.47 95.28,25.38 95.64,25.38 95.73,25.29 95.73,25.11 95.64,25.02 95.28,25.02 95.19,24.93 95.19,24.62 95.73,24.08 v1(96.28,24.08)
  BOTTOM w0.076: CPU1.R35 93.45,62.38 93.45,62.03 93.59,61.78 93.59,61.42 93.37,61.2 93.37,60.07 91.69,58.39 91.69,54.31 90.54,53.16 89.97,53.16 v1(89.74,53.39)
  BOTTOM w0.089: v1(96.28,24.08) 95.04,25.32 95.04,26.45 94.89,26.6 DM1.245
M_A_DQ48: length 70.8
  L4 w0.089: v1(78.65,23.12) 78.95,23.42 78.95,26.56 78.25,27.26 78.25,34.17 71.65,40.78 71.65,45.37 71.9,45.62 71.9,47.94 70.05,49.79 70.05,61.76 71.57,63.28 71.57,63.41 71.2,63.78 71.2,63.9 71.33,64.03 71.45,64.03 71.58,63.9 71.71,63.9 71.84,64.02 71.84,64.15 71.71,64.28 71.71,64.4 73.3,66 85.62,66 86.62,65 v1(88.93,65)
  BOTTOM w0.089: DM1.183 79.38,26.87 79.04,26.52 79.04,23.51 v1(78.65,23.12) ; v1(88.93,65) 88.9,64.97 88.78,64.97 CPU1.G31
M_A_DQ49: length 73
  L4 w0.089: v1(87.99,64.46) 87.98,64.45 86.71,64.45 85.48,65.68 75.98,65.68 75.89,65.6 75.89,64.62 75.8,64.53 75.62,64.53 75.53,64.62 75.53,65.6 75.45,65.68 75.27,65.68 75.18,65.6 75.18,64.62 75.09,64.53 74.91,64.53 74.82,64.62 74.82,65.6 74.73,65.68 74.42,65.68 73.93,65.19 73.8,65.19 73.43,65.56 73.31,65.56 73.18,65.43 73.18,65.31 73.55,64.94 73.55,64.82 70.36,61.63 70.36,49.92 72.21,48.07 72.21,45.42 71.98,45.19 71.98,40.9 78.57,34.31 78.57,27.4 79.17,26.8 79.17,22.25 79.37,22.05 v1(80.64,22.05)
  BOTTOM w0.089: CPU1.G32 88.2,64.46 v1(87.99,64.46) ; v1(80.64,22.05) 80.13,21.54 DM1.186
M_A_DQ50: length 71.4
  L4 w0.089: v1(88.93,66.29) 88.49,66.73 86.42,66.73 84.45,68.69 74.25,68.69 68.8,63.24 68.8,41.69 75.94,34.55 75.94,26.98 76.71,26.21 76.71,23.37 v1(76.05,22.71)
  BOTTOM w0.089: CPU1.H29 v1(88.93,66.29) ; DM1.174 77.13,21.62 v1(76.05,22.71)
M_A_DQ51: length 71.9
  L4 w0.089: v1(88.93,66.94) 87.59,66.94 84.37,70.16 77.59,70.16 77.54,70.11 75.22,70.11 68.48,63.37 68.48,41.45 74.97,34.96 74.97,27.54 76.49,26.02 76.49,24.65 v1(76.05,24.2)
  BOTTOM w0.089: DM1.173 76.89,25.04 v1(76.05,24.2) ; CPU1.H28 v1(88.93,66.94)
M_A_DQ52: length 70.6
  L4 w0.089: v1(88.94,67.57) 88.53,67.17 87.64,67.17 84.39,70.42 76.65,70.42 76.56,70.51 76.56,70.83 76.47,70.92 76.29,70.92 76.2,70.83 76.2,70.51 76.11,70.42 75.93,70.42 75.85,70.51 75.85,70.83 75.76,70.92 75.58,70.92 75.49,70.83 75.49,70.51 75.4,70.42 75.08,70.42 68.16,63.5 68.16,41.21 74.66,34.71 74.66,27.14 v1(76.04,25.76)
  BOTTOM w0.089: v1(88.94,67.57) 88.59,67.23 CPU1.G28 ; DM1.169 75.89,25.96 76.04,25.81 v1(76.04,25.76)
M_A_DQ53: length 72.3
  L4 w0.089: v1(88.01,66.29) 86.55,66.29 84.43,68.4 77.3,68.4 77.27,68.37 76.65,68.37 76.56,68.28 76.56,67.93 76.48,67.84 76.3,67.84 76.21,67.93 76.21,68.28 76.12,68.37 75.94,68.37 75.85,68.28 75.85,67.93 75.76,67.84 75.59,67.84 75.5,67.93 75.5,68.28 75.41,68.37 75.23,68.37 75.14,68.28 75.14,67.95 75.03,67.84 74.88,67.84 74.79,67.93 74.79,68.28 74.7,68.37 74.38,68.37 69.13,63.13 69.13,49.41 70.96,47.58 70.96,46.26 70.68,45.98 70.68,40.43 76.98,34.13 76.98,22.26 v1(76.13,21.41)
  BOTTOM w0.089: v1(76.13,21.41) 76.13,21.4 DM1.170 ; CPU1.G29 v1(88.01,66.29)
M_A_DQ54: length 72.3
  L4 w0.089: v1(89.82,65.67) 89.82,65.33 89.49,64.99 89.49,64.81 89.28,64.59 89.09,64.59 88.52,64.02 86.11,64.02 85.85,64.29 85.85,65.03 85.51,65.37 77.43,65.37 77.34,65.28 77.34,64.3 77.25,64.21 76.85,64.21 76.76,64.3 76.76,65.28 76.67,65.37 76.49,65.37 76.4,65.28 76.4,64.3 76.31,64.21 73.39,64.21 70.68,61.5 70.68,50.05 72.53,48.2 72.53,45.28 72.31,45.06 72.31,41.02 78.89,34.44 78.89,27.56 79.52,26.93 79.52,23.1 79.61,23.02 v1(79.95,23.02)
  BOTTOM w0.089: DM1.182 79.13,22.2 v1(79.95,23.02) ; CPU1.H31 89.71,65.61 89.76,65.61 v1(89.82,65.67)
M_A_DQ55: length 73.2
  L4 w0.089: v1(80,25.99) 79.88,26.11 79.88,27 79.2,27.68 79.2,34.57 72.64,41.14 72.64,44.94 72.85,45.15 72.85,48.33 71,50.18 71,59.1 71.09,59.19 71.81,59.19 71.9,59.27 71.9,59.45 71.81,59.54 71.09,59.54 71,59.63 71,59.81 71.09,59.9 71.81,59.9 71.9,59.99 71.9,60.16 71.81,60.25 71.09,60.25 71,60.34 71,60.52 71.09,60.61 71.81,60.61 71.9,60.7 71.9,60.87 71.81,60.96 71.09,60.96 71,61.05 71,61.37 71.12,61.49 71.79,61.49 71.95,61.65 71.95,62.32 73.52,63.89 77.85,63.89 77.94,63.98 77.94,64.97 78.03,65.06 78.2,65.06 78.29,64.97 78.29,63.98 78.38,63.89 78.56,63.89 78.65,63.98 78.65,64.97 78.74,65.06 78.91,65.06 79,64.97 79,63.98 79.09,63.89 79.27,63.89 79.36,63.98 79.36,64.97 79.45,65.06 79.63,65.06 79.71,64.97 79.71,63.98 79.84,63.86 80.9,63.86 81.16,64.11 85.76,64.11 86.07,63.8 88.92,63.8 v1(89.25,64.13)
  BOTTOM w0.089: DM1.187 80.38,26.38 v1(80,25.99) ; CPU1.H32 89.38,64.26 v1(89.25,64.13)
M_A_DQ56: length 63.4
  L4 w0.089: v1(80.64,23.32) 81.32,23.32 81.7,23.71 81.7,26.5 80.28,27.92 80.28,31.25 80.37,31.34 80.86,31.34 80.94,31.43 80.94,31.61 80.86,31.7 80.37,31.7 80.28,31.78 80.28,31.96 80.37,32.05 80.86,32.05 80.94,32.14 80.94,32.32 80.86,32.41 80.37,32.41 80.28,32.5 80.28,32.67 80.37,32.76 81.03,32.76 81.12,32.85 81.12,34.52 74.65,40.99 74.65,54.27 81.34,60.97 84.13,60.97 86.06,62.89 89.16,62.89 90.07,63.81 90.07,64.64 90.39,64.96 v1(90.79,64.96)
  BOTTOM w0.089: DM1.190 81.13,22.83 v1(80.64,23.32) ; CPU1.L31 90.88,64.96 v1(90.79,64.96)
M_A_DQ57: length 64.3
  L4 w0.089: v1(82.92,22.18) 82.01,23.09 82.01,26.67 80.6,28.08 80.6,28.65 80.69,28.74 81.35,28.74 81.44,28.83 81.44,29 81.35,29.09 80.69,29.09 80.6,29.18 80.6,29.36 80.69,29.45 81.35,29.45 81.44,29.54 81.44,29.72 81.35,29.8 80.69,29.8 80.6,29.89 80.6,30.07 80.69,30.16 81.35,30.16 81.44,30.25 81.44,30.43 81.35,30.52 80.69,30.52 80.6,30.6 80.6,30.78 80.69,30.87 81.35,30.87 81.44,30.96 81.44,34.65 74.97,41.12 74.97,54.14 81.45,60.63 84.08,60.63 86.04,62.59 89.35,62.59 90.38,63.61 90.38,64.03 v1(90.51,64.16)
  BOTTOM w0.089: v1(82.92,22.18) 82.13,21.39 DM1.194 ; CPU1.L32 91.16,64.64 90.78,64.43 v1(90.51,64.16)
M_A_DQ58: length 62.5
  L4 w0.089: v1(91.66,66.33) 91.99,66 91.99,65.77 92,65.76 92,64.93 91.38,64.31 91.38,63.74 91.65,63.47 91.65,63.14 90.21,61.7 86.36,61.7 84.35,59.69 81.84,59.69 75.96,53.81 75.96,41.65 82.42,35.18 82.42,29.64 83.55,28.51 83.55,22.62 84.07,22.1 v1(85.13,22.1)
  BOTTOM w0.089: v1(85.13,22.1) 84.64,21.6 DM1.204 ; CPU1.N29 v1(91.66,66.33)
M_A_DQ59: length 62.7
  L4 w0.089: v1(85.13,23.45) 84.3,23.45 83.84,23.9 83.84,28.68 82.73,29.78 82.73,35.31 76.28,41.78 76.28,53.68 82.06,59.46 84.63,59.46 86.66,61.5 90.26,61.5 91.83,63.07 91.83,63.59 91.56,63.86 91.56,64.24 92.18,64.85 92.18,65.84 92.17,65.84 92.17,66.47 v1(91.66,66.98)
  BOTTOM w0.089: v1(85.13,23.45) 85.64,22.95 DM1.208 ; CPU1.N28 v1(91.66,66.98)
M_A_DQ60: length 60
  L4 w0.089: v1(90.75,66.98) 90.24,66.47 90.24,66.07 90.23,66.07 90.23,65.37 89.71,64.85 89.71,63.94 89.26,63.5 86.09,63.5 84.19,61.6 81.08,61.6 74.02,54.54 74.02,40.69 79.65,35.05 79.65,27.87 80.42,27.09 80.42,25.14 v1(80,24.72)
  BOTTOM w0.089: v1(80,24.72) 81.38,26.11 DM1.191 ; CPU1.L28 v1(90.75,66.98)
M_A_DQ61: length 61.6
  L4 w0.089: v1(90.75,66.33) 90.41,66 90.41,65.3 89.88,64.77 89.88,63.87 89.19,63.17 86.05,63.17 84.24,61.36 81.29,61.36 74.33,54.41 74.33,40.82 80.77,34.39 80.77,34.07 80.68,33.98 80.05,33.98 79.97,33.89 79.97,33.71 80.05,33.62 80.58,33.62 80.66,33.54 80.66,33.36 80.58,33.27 80.05,33.27 79.97,33.18 79.97,27.85 80.64,27.18 80.64,25.12 v1(81.19,24.56)
  BOTTOM w0.089: DM1.195 82.38,26.8 82.24,26.65 82.24,25.61 v1(81.19,24.56) ; CPU1.L29 v1(90.75,66.33)
M_A_DQ62: length 62.5
  L4 w0.089: v1(84.37,24.69) 84.81,25.13 84.81,33.23 84.72,33.32 83.85,33.32 83.76,33.41 83.76,33.58 83.85,33.67 84.72,33.67 84.81,33.76 84.81,33.94 84.72,34.03 83.85,34.03 83.76,34.12 83.76,34.3 83.85,34.38 84.54,34.38 84.63,34.47 84.63,34.81 84.54,34.9 84.06,34.9 76.91,42.05 76.91,53.36 82.51,58.96 84.89,58.96 87.02,61.09 90.75,61.09 92.51,62.85 92.51,65.5 v1(92.6,65.59)
  BOTTOM w0.089: DM1.207 85.38,25.71 84.77,25.09 v1(84.37,24.69) ; v1(92.6,65.59) 92.57,65.59 92.56,65.6 92.43,65.6 CPU1.N31
M_A_DQ63: length 64
  L4 w0.089: v1(84.33,26.16) 84.33,29.61 84.14,29.8 83.17,29.8 83.05,29.92 83.05,30.23 83.14,30.32 84.31,30.32 84.42,30.44 84.42,30.59 84.33,30.68 83.14,30.68 83.05,30.77 83.05,30.94 83.14,31.03 84.31,31.03 84.42,31.15 84.42,31.3 84.33,31.39 83.14,31.39 83.05,31.48 83.05,31.66 83.14,31.74 84.31,31.74 84.42,31.86 84.42,32.01 84.33,32.1 83.14,32.1 83.05,32.19 83.05,32.37 83.14,32.46 84.31,32.46 84.42,32.57 84.42,32.72 84.33,32.81 83.14,32.81 83.05,32.9 83.05,35.46 76.59,41.92 76.59,53.49 82.33,59.22 84.79,59.22 86.86,61.29 90.3,61.29 92.02,63.01 v1(92.02,64.07)
  BOTTOM w0.089: v1(84.33,26.16) 84.38,26.22 DM1.203 ; CPU1.N32 92.12,64.17 92.02,64.08 v1(92.02,64.07)
M_A_DQS_DN0: length 85.3
  L6 w0.102: v1(80.02,66.66) 80.23,66.45 80.23,66.32 79.65,65.74 77.98,65.74 77.88,65.84 77.88,66.37 77.65,66.6 77.32,66.6 77.09,66.37 77.09,65.84 76.99,65.74 76.12,65.74 70.73,60.34 70.73,56.16 64.88,50.31 64.65,50.31 64.33,49.99 62.92,49.99 62.82,50.09 62.82,50.62 62.59,50.85 62.26,50.85 62.03,50.62 62.03,50.09 61.93,49.99 60.45,49.99 58.24,47.78 57.68,47.78 55.42,45.52 53.92,45.52 53.66,45.27 53.13,45.27 52.43,44.57 52.43,43.88 51.7,43.15 51.34,43.15 50.77,43.72 50.44,43.72 50.2,43.48 50.2,43.15 50.77,42.59 50.77,42.44 49.24,40.92 49.24,39.59 45.18,35.52 41.07,35.52 39.46,33.91 39.46,27 38.67,26.2 38.67,22.78 v1(39.39,22.05)
  BOTTOM w0.076: CPU1.C27 86.27,67.77 86.19,67.69 85.85,67.69 85.72,67.65 85.52,67.65 85.43,67.68 84.11,67.68 83.94,67.52 82.61,67.52 82.59,67.5
  BOTTOM w0.089: 82.59,67.5 80.66,67.5 80.32,67.17 80.32,66.87 80.11,66.66 v1(80.02,66.66) ; DM1.32 39.63,20.76 39.76,20.88 39.87,20.88 39.94,20.95 39.94,21.9 39.8,22.05 v1(39.39,22.05)
M_A_DQS_DN1: length 74.2
  L6 w0.102: v1(44.69,25.31) 44.38,24.97 44.24,24.96 44.14,25.06 44.14,26.39 44.44,26.7 45.69,26.7 46.46,27.47 46.46,27.8 46.22,28.05 46.22,28.19 46.32,28.3 46.47,28.3 46.72,28.05 47.04,28.05 49.32,30.33 49.32,31.98 49.75,32.41 50.57,32.41 51.25,33.1 51.25,33.5 54.73,36.98 54.73,37.98 54.98,38.23 55.7,38.23 60.24,42.78 60.31,42.78 61.6,44.07 63.23,44.07 66.13,46.96 67.44,46.96 71.23,50.75 71.37,50.75 71.84,50.28 72.17,50.28 72.4,50.51 72.4,50.84 71.93,51.31 71.93,51.45 72.04,51.56 72.18,51.56 72.65,51.09 72.98,51.09 73.21,51.32 73.21,51.65 72.74,52.12 72.74,52.26 72.99,52.52 75.98,52.52 81.88,58.42 81.88,61.22 82.78,62.11 82.78,62.45 82.77,62.59 v1(82.96,62.81)
  BOTTOM w0.076: CPU1.D31 86.1,65 85.88,65 85.75,64.95 85.49,64.95 85.27,65.03 84.91,65.03 84.67,64.8 84.67,64.79 84.66,64.78
  BOTTOM w0.089: DM1.53 44.88,27.05 45.37,26.56 45.37,24.97 45.24,24.85 44.87,24.85 44.69,25.03 v1(44.69,25.31) ; v1(82.96,62.81) 82.62,63.16 82.62,63.88 83.01,64.27 84.16,64.27 84.66,64.78
M_A_DQS_DN2: length 74.1
  L6 w0.102: v1(89.5,69.35) 89.29,69.56 89.29,69.79 89.06,70.02 87.74,70.02 86.87,69.16 86.87,62.35 84.54,60.01 84.54,56.66 75.08,47.2 73.88,47.2 69.97,43.28 68.72,43.28 65.22,39.79 65.11,39.68 64.15,39.68 61.59,37.12 61.59,36.16 52.68,27.25 52.53,27.25 52.33,27.45 52,27.45 51.77,27.22 51.77,26.89 51.97,26.69 51.97,26.54 51.72,26.29 51.72,24.43 51.47,24.17 49.74,24.17 49.21,23.64 49.21,22.35 49.43,22.12 49.93,22.12 v1(50.06,22.01)
  BOTTOM w0.089: v1(89.5,69.35) 89.5,69.46 CPU1.H24 ; v1(50.06,22.01) 50.44,22.01 50.58,21.87 50.58,21.32 50.24,20.97 50.24,20.65 50.14,20.55 DM1.74
M_A_DQS_DN3: length 85.9
  L6 w0.102: v1(79.49,69.65) 79.72,69.65 79.82,69.76 79.82,69.91 79.49,70.23 77.47,70.23 77.26,70.03 76.28,70.03 67.67,61.41 67.67,58.38 66.73,57.44 63.7,57.44 62.35,56.09 59.53,56.09 58.24,54.8 54.97,54.8 42.58,42.41 42.43,42.41 41.23,41.21 41.23,41.06 38.95,38.78 38.95,37.85 35.81,34.71 35.81,33.89 35,33.07 35,31.4 34.4,30.81 34.4,28.97 34.51,28.87 34.88,28.87 35.12,28.64 35.12,28.06 34.86,27.8 34.4,27.8 34.3,27.7 34.3,27.24 33.66,26.61 33.66,25.64 33.76,25.54 34.02,25.54 34.12,25.63 v1(34.12,25.73)
  BOTTOM w0.076: 82.19,70.41 82.21,70.41 82.22,70.41 82.95,70.41 83.04,70.32 84.28,70.32 84.5,70.29 84.5,70.29 84.52,70.29
  BOTTOM w0.083: 84.52,70.29 84.97,70.19 85.4,70.19 85.55,70.16 85.71,70.16 85.76,70.18 CPU1.C23 ; 82.19,70.41 80.25,70.41 79.96,70.12 79.96,69.63 79.87,69.55 79.6,69.55 v1(79.49,69.65)
  BOTTOM w0.089: v1(34.12,25.73) 34.12,25.9 34.22,25.99 34.52,25.99 34.61,25.91 34.61,25.62 34.53,25.54 34.53,25.38 34.62,25.29 34.88,25.29 35.08,25.49 35.08,26.43 34.86,26.65 34.52,26.65 34.38,26.79 DM1.11
M_A_DQS_DN4: length 54.9
  L4 w0.102: v1(89.04,24.57) 88.71,24.9 87.79,24.9 87.56,25.13 87.56,26.74 87.99,27.17 88.78,27.17 88.88,27.27 88.88,27.43 88.78,27.53 87.99,27.53 87.76,27.76 87.76,30.57 86.63,31.71 86.63,35.3 80.5,41.43 80.5,54.07 80.88,54.45 81.2,54.45 81.45,54.2 81.59,54.2 81.74,54.34 81.74,54.48 81.49,54.73 81.49,55.06 83.79,57.36 86.01,57.36 86.15,57.36 v1(86.39,57.61)
  BOTTOM w0.076: CPU1.J35 90,62.6 90.22,62.14 90.24,62.04 90.24,61.89 90.22,61.76 90.16,61.18 90.16,61.18 90.16,61.13 90.16,60.56 87.26,57.66 87.26,57.65 86.97,57.36 86.64,57.36 v1(86.39,57.61)
  BOTTOM w0.089: DM1.219 88.38,25.22 v1(89.04,24.57)
M_A_DQS_DN5: length 54.5
  L4 w0.102: v1(94.88,23.38) 94.54,23.07 94.39,23.08 94.29,23.18 94.29,23.74 94.8,24.25 94.8,26.05 93.4,27.45 93.4,30.44 89.98,33.85 89.98,36.69 83.92,42.76 83.92,48.44 89.66,54.18 89.66,56.64 90.01,57 90.23,57 v1(90.44,56.79)
  BOTTOM w0.076: v1(90.44,56.79) 90.65,57 90.81,57 91.07,57.26 91.07,58.52 92.86,60.31 92.86,61.5 92.91,61.72 92.93,61.89 92.93,62.1 92.82,62.37 92.8,62.56 92.75,62.74 92.72,62.8 CPU1.P34
  BOTTOM w0.089: DM1.240 93.64,22.75 94.06,23.17 94.68,23.17 v1(94.88,23.38)
M_A_DQS_DN6: length 72.1
  L4 w0.102: v1(77.75,25.21) 78.01,25.21 78.07,25.15 78.07,24.75 78.15,24.68 78.41,24.68 78.51,24.78 78.51,25.51 78.41,25.61 77.99,25.61 77.62,25.99 77.62,33.99 71.06,40.54 71.06,45.67 71.33,45.94 71.33,47.7 69.48,49.55 69.48,62.98 69.86,63.36 70.18,63.36 70.44,63.1 70.58,63.1 70.69,63.21 70.69,63.35 70.44,63.61 70.44,63.93 73.81,67.31 85.06,67.31 86.94,65.43 87.91,65.43 88.01,65.53 v1(88.01,65.64)
  BOTTOM w0.089: DM1.177 77.89,27.11 78.05,26.95 78.05,26.79 77.79,26.53 77.79,25.92 78.07,25.65 78.48,25.65 78.63,25.49 78.63,24.74 78.54,24.66 78.16,24.66 78.07,24.74 78.07,25.15 78.01,25.21 v1(77.75,25.21) ; v1(88.01,65.64) 88.38,65.56 88.49,65.63 88.53,65.83 CPU1.G30
M_A_DQS_DN7: length 62.1
  L4 w0.102: v1(83.1,23.52) 82.77,23.84 82.54,23.84 82.31,24.07 82.31,26.95 81.82,27.45 81.82,28.08 82.05,28.31 82.53,28.31 82.63,28.41 82.63,28.56 82.53,28.66 82.05,28.66 81.82,28.89 81.82,34.94 75.39,41.37 75.39,54.07 81.6,60.28 84.22,60.28 86.16,62.22 90.02,62.22 90.58,62.78 90.58,63.59 90.95,63.96 90.95,64.49 91.24,64.79 91.24,65.18 v1(90.81,65.61)
  BOTTOM w0.089: DM1.198 83.13,20.89 83.44,21.2 83.44,23.5 83.33,23.62 83.2,23.62 v1(83.1,23.52) ; CPU1.L30 91.17,65.8 90.82,65.61 v1(90.81,65.61)
M_A_DQS_DP0: length 85.3
  L6 w0.102: v1(80.66,66.64) 80.45,66.43 80.45,66.23 79.74,65.52 77.89,65.52 77.66,65.75 77.66,66.28 77.56,66.39 77.41,66.39 77.31,66.28 77.31,65.75 77.08,65.52 76.21,65.52 70.94,60.25 70.94,56.07 64.97,50.1 64.74,50.1 64.42,49.77 62.83,49.77 62.6,50 62.6,50.53 62.5,50.64 62.35,50.64 62.25,50.53 62.25,50 62.02,49.77 60.54,49.77 58.33,47.56 57.77,47.56 55.51,45.3 54.01,45.3 53.75,45.05 53.22,45.05 52.65,44.48 52.65,43.79 51.79,42.93 51.25,42.93 50.68,43.5 50.53,43.5 50.42,43.39 50.42,43.24 50.98,42.68 50.98,42.35 49.46,40.83 49.46,39.5 45.27,35.31 41.16,35.31 39.68,33.82 39.68,26.91 38.88,26.11 38.88,22.87 39.01,22.74 v1(39.37,22.74)
  BOTTOM w0.076: CPU1.D27 86.54,67.52 85.88,67.52 85.75,67.47 85.49,67.47 85.39,67.5 84.18,67.5 84.02,67.34 82.68,67.34 82.66,67.31 82.59,67.31
  BOTTOM w0.089: 82.59,67.31 80.74,67.31 80.51,67.09 80.51,66.79 v1(80.66,66.64) ; v1(39.37,22.74) 40.14,21.98 DM1.34
M_A_DQS_DP1: length 74
  L6 w0.102: v1(82.33,62.77) 82.55,62.58 82.56,62.44 82.56,62.2 81.67,61.31 81.67,58.51 75.89,52.73 72.9,52.73 72.53,52.35 72.53,52.03 72.99,51.56 72.99,51.41 72.89,51.31 72.74,51.31 72.27,51.77 71.95,51.77 71.72,51.54 71.72,51.22 72.18,50.75 72.18,50.6 72.08,50.5 71.93,50.5 71.46,50.97 71.14,50.97 67.35,47.17 66.04,47.17 63.14,44.28 61.51,44.28 60.22,42.99 60.15,42.99 55.61,38.45 54.89,38.45 54.52,38.07 54.52,37.07 51.04,33.59 51.04,33.19 50.48,32.63 49.66,32.63 49.11,32.07 49.11,30.42 46.95,28.27 46.81,28.27 46.56,28.51 46.23,28.51 46,28.28 46,27.96 46.25,27.71 46.25,27.56 45.6,26.91 44.35,26.91 43.92,26.48 43.92,24.97 44.15,24.75 44.25,24.75 44.39,24.75 44.39,24.75 v1(44.73,24.44)
  BOTTOM w0.076: 84.53,64.91 84.54,64.92 84.55,64.92 84.83,65.21 85.31,65.21 85.52,65.13 85.72,65.13 85.85,65.18 CPU1.C31
  BOTTOM w0.089: v1(44.73,24.44) 44.95,24.66 45.32,24.66 45.56,24.9 45.56,26.64 45.38,26.82 DM1.55 ; v1(82.33,62.77) 82.43,62.87 82.43,63.96 82.93,64.46 84.08,64.46 84.53,64.91
M_A_DQS_DP2: length 74.1
  L6 w0.102: v1(50.02,22.7) 50.02,22.58 49.78,22.34 49.52,22.34 49.42,22.44 49.42,23.55 49.83,23.95 51.56,23.95 51.94,24.34 51.94,26.2 52.19,26.45 52.19,26.78 51.99,26.98 51.99,27.13 52.09,27.23 52.24,27.23 52.44,27.03 52.77,27.03 61.81,36.07 61.81,37.03 64.24,39.46 65.2,39.46 65.31,39.58 68.81,43.07 70.06,43.07 73.97,46.98 75.17,46.98 84.75,56.57 84.75,59.92 87.09,62.26 87.09,69.07 87.83,69.81 88.97,69.81 89.07,69.7 89.07,69.45 88.97,69.35 v1(88.86,69.35)
  BOTTOM w0.089: v1(88.86,69.35) 88.91,69.4 88.91,69.71 88.8,69.82 88.6,69.82 CPU1.G24 ; v1(50.02,22.7) 50.02,22.69 50.77,21.95 50.77,21.24 50.43,20.89 50.43,20.77 50.64,20.56 50.64,19.75 DM1.76
M_A_DQS_DP3: length 85.8
  L6 w0.102: v1(80.35,69.68) 79.58,70.45 77.38,70.45 77.17,70.25 76.19,70.25 67.45,61.5 67.45,58.47 66.64,57.66 63.61,57.66 62.26,56.31 59.44,56.31 58.15,55.02 54.88,55.02 42.49,42.62 42.34,42.62 41.02,41.3 41.02,41.15 38.73,38.87 38.73,37.94 35.59,34.8 35.59,33.98 34.78,33.16 34.78,31.49 34.19,30.9 34.19,28.88 34.42,28.65 34.8,28.65 34.9,28.55 34.9,28.15 34.77,28.02 34.31,28.02 34.08,27.79 34.08,27.33 33.45,26.7 33.45,25.55 33.67,25.32 33.89,25.32 33.9,25.32 v1(34.1,25.1)
  BOTTOM w0.076: 84.5,70.12 84.48,70.12 84.48,70.12 84.26,70.14 82.97,70.14 82.88,70.23 82.22,70.23 82.21,70.23 82.19,70.23
  BOTTOM w0.083: 82.19,70.23 80.33,70.23 80.14,70.04 80.14,69.89 v1(80.35,69.68) ; 84.5,70.12 84.96,70.02 85.37,70.02 85.53,69.99 85.74,69.99 85.83,70.02 86.04,70.12 86.39,70.17 CPU1.D23
  BOTTOM w0.089: v1(34.1,25.1) 34.96,25.1 35.27,25.41 35.27,26.5 34.89,26.89 34.89,27.95 DM1.13
M_A_DQS_DP4: length 55.1
  L4 w0.102: v1(89.06,25.44) 88.73,25.11 87.88,25.11 87.78,25.21 87.78,26.65 88.08,26.96 88.87,26.96 89.1,27.18 89.1,27.52 88.87,27.74 88.08,27.74 87.98,27.85 87.98,30.66 86.84,31.8 86.84,35.39 80.72,41.52 80.72,53.98 80.97,54.23 81.11,54.23 81.36,53.98 81.68,53.98 81.95,54.25 81.95,54.57 81.7,54.82 81.7,54.97 83.88,57.14 86.01,57.14 86.15,57.14 v1(86.4,56.9)
  BOTTOM w0.076: v1(86.4,56.9) 86.67,57.18 87.04,57.18 87.44,57.58 87.44,57.58 90.34,60.48 90.34,61.12 90.35,61.22 90.39,61.72 90.4,61.75 90.42,61.85 90.42,61.87 90.42,62.06 90.41,62.12 90.39,62.19 90.23,62.73 90.23,62.75 CPU1.J34
  BOTTOM w0.089: DM1.221 88.89,27.1 88.58,26.79 88.58,25.3 88.74,25.14 88.97,25.14 89.06,25.23 v1(89.06,25.44)
M_A_DQS_DP5: length 54.4
  L4 w0.102: v1(90.44,57.42) 90.23,57.21 89.92,57.21 89.44,56.73 89.44,54.27 83.7,48.53 83.7,42.67 89.76,36.6 89.76,33.76 93.18,30.35 93.18,27.37 93.8,26.75 94.58,25.96 94.58,24.34 94.08,23.83 94.08,23.09 94.3,22.87 94.52,22.85 v1(94.83,22.51)
  BOTTOM w0.076: CPU1.P35 92.75,62.08 92.76,62.04 92.76,61.9 92.74,61.75 92.71,61.6 92.68,61.57 92.68,60.38 90.9,58.6 90.9,57.33 90.74,57.18 90.54,57.18 90.44,57.28 v1(90.44,57.42)
  BOTTOM w0.089: DM1.242 94.13,20.62 93.83,20.93 93.83,22.67 94.13,22.98 94.68,22.98 94.83,22.83 v1(94.83,22.51)
M_A_DQS_DP6: length 72.1
  L4 w0.102: v1(77.75,24.46) 78.5,24.46 78.73,24.69 78.73,25.6 78.5,25.83 78.08,25.83 77.83,26.08 77.83,34.08 71.28,40.63 71.28,45.58 71.55,45.85 71.55,47.79 69.7,49.64 69.7,62.89 69.95,63.14 70.09,63.14 70.35,62.88 70.67,62.88 70.91,63.12 70.91,63.44 70.65,63.7 70.65,63.84 73.9,67.1 84.97,67.1 86.85,65.22 88.5,65.22 v1(88.93,65.64)
  BOTTOM w0.089: v1(77.75,24.46) 78.62,24.46 78.82,24.67 78.82,25.57 78.56,25.84 78.15,25.84 77.98,26 77.98,26.45 78.24,26.71 78.24,27.04 78.38,27.19 DM1.179 ; CPU1.H30 v1(88.93,65.64)
M_A_DQS_DP7: length 62.2
  L4 w0.102: v1(83.1,24.38) 82.77,24.06 82.63,24.06 82.53,24.16 82.53,27.04 82.04,27.54 82.04,27.99 82.14,28.09 82.62,28.09 82.85,28.32 82.85,28.65 82.62,28.88 82.14,28.88 82.04,28.98 82.04,35.03 75.61,41.46 75.61,53.98 81.69,60.06 84.31,60.06 86.25,62 90.11,62 90.8,62.69 90.8,63.5 91.17,63.87 91.17,64.4 91.46,64.7 91.46,65.46 v1(91.6,65.61)
  BOTTOM w0.089: v1(83.1,24.38) 83.1,24.12 83.64,23.58 DM1.200 ; v1(91.6,65.61) 92.1,65.88 CPU1.N30
M_A_PARITY: length 67.9
  L6 w0.142: v1(69.23,26.06) 69.23,26.47 73.55,30.79 85.25,30.79 96.82,42.35 96.82,50.4 97.44,51.03 97.44,59.43 96.54,60.33 96.54,60.58 96.87,60.91 96.87,61.26 96.16,61.96 95.93,61.96 95.56,61.6 95.32,61.6 95.16,61.76 95.16,62 95.52,62.37 95.52,62.6 94.86,63.26 94.86,65.22 v1(95.31,65.67)
  BOTTOM w0.14: v1(69.23,26.06) 69.51,25.78 69.51,24.87 69.31,24.67 68.29,24.67 67.66,25.3 67.66,26.67 67.38,26.95 DM1.143 ; CPU1.W31 95.7,65.28 v1(95.31,65.67)
M_B_A0: length 88.9
  L4 w0.142: v1(146.76,22.41) 146.3,22.86 146.3,27.15 142.31,31.14 142.08,31.14 141.49,30.56 141.26,30.56 141.09,30.73 141.09,30.96 141.67,31.54 141.67,31.78 141.51,31.95 141.27,31.95 140.69,31.36 140.45,31.36 140.29,31.53 140.29,31.77 140.87,32.35 140.87,32.58 140.54,32.91 140.34,32.91 139.73,32.29 139.52,32.29 137.61,34.21 112.04,34.21 111.39,34.86 108.96,34.86 101.29,42.54 101.29,49.92 101.07,50.14 101.07,55.51 v1(100.63,55.95)
  BOTTOM w0.076: CPU1.AG36 100.71,62.23 100.94,61.81 100.95,61.8 100.96,61.77 100.96,61.49 100.73,61.25 100.73,60.28 100.65,60.19 100.65,59.98 100.06,59.39 100.06,56.52 v1(100.63,55.95)
  BOTTOM w0.14: DM2.144 144.63,21.39 144.77,21.53 145.73,21.53 145.89,21.69 145.89,21.92 145.73,22.09 144.77,22.09 144.63,22.23 144.63,22.55 144.91,22.82 146.62,22.82 146.76,22.68 v1(146.76,22.41)
M_B_A1: length 92.7
  L4 w0.142: v1(142.12,26.12) 136.1,32.13 136.1,32.13 136.08,32.15 111.15,32.15 110.5,32.8 107.94,32.8 99.21,41.53 99.21,43.13 99.04,43.3 97.44,43.3 97.19,43.55 97.19,43.99 97.36,44.16 99.04,44.16 99.21,44.33 99.21,44.56 99.04,44.73 97.36,44.73 97.19,44.9 97.19,45.13 97.36,45.3 99.04,45.3 99.21,45.46 99.21,45.7 99.04,45.87 97.36,45.87 97.19,46.03 97.19,46.27 97.36,46.44 99.04,46.44 99.21,46.6 99.21,46.84 99.04,47.01 97.36,47.01 97.19,47.17 97.19,47.64 97.34,47.78 99,47.78 99.18,47.96 99.18,48.41 99.01,48.57 98.05,48.57 97.89,48.74 97.89,48.97 98.05,49.14 99.01,49.14 99.18,49.31 99.18,50.59 99.4,50.81 99.4,53.9 v1(98.46,54.84)
  BOTTOM w0.076: CPU1.AG35 100.46,62.68 100.46,62.18 100.5,62.05 100.5,61.88 100.4,61.61 100.4,60.41 100.32,60.33 100.32,60.12 99.71,59.51 99.71,54.26 99.63,54.18 98.6,54.18 98.46,54.32 v1(98.46,54.84)
  BOTTOM w0.14: DM2.133 141.89,26.35 v1(142.12,26.12)
M_B_A2: length 91
  L4 w0.142: v1(98.72,57.13) 97.94,56.35 97.94,55.94 97.77,55.78 97.57,55.78 97.4,55.61 97.4,55.37 97.57,55.21 97.77,55.21 97.94,55.04 97.94,54.8 97.77,54.64 97.57,54.64 97.4,54.47 97.4,54.24 97.57,54.07 97.77,54.07 97.94,53.9 97.94,53.03 93.15,48.24 93.15,41.99 99.74,35.4 99.74,35.16 99.31,34.73 99.31,34.5 99.48,34.33 99.71,34.33 100.14,34.76 100.38,34.76 100.54,34.59 100.54,34.36 100.11,33.93 100.11,33.69 100.28,33.52 100.52,33.52 100.95,33.95 101.18,33.95 101.35,33.79 101.35,33.55 100.92,33.12 100.92,32.89 101.08,32.72 101.32,32.72 101.75,33.15 101.99,33.15 104.57,30.56 109.57,30.56 110.25,29.89 134.22,29.89 138.86,25.25 138.86,24.11 139.54,23.42 140.7,23.42 v1(141,23.73)
  BOTTOM w0.076: v1(98.72,57.13) 98.32,57.53 98.32,58.82 99.82,60.32 99.82,60.53 99.89,60.6 99.89,61.7 99.84,61.75 99.8,61.84 99.8,62.08 99.83,62.14 99.83,62.14 99.83,62.44 99.8,62.51 99.8,62.69 99.82,62.78 99.84,62.82 99.84,63.04 CPU1.AF34
  BOTTOM w0.14: v1(141,23.73) 141.15,23.73 141.63,23.25 DM2.132
M_B_A3: length 92.3
  L4 w0.142: v1(142.12,23.48) 142.7,23.48 142.84,23.62 142.84,24.74 142.62,24.97 141.88,24.97 141.57,25.28 141.57,26.02 135.9,31.7 110.97,31.7 110.32,32.35 107.76,32.35 100.6,39.51 100.37,39.51 99.42,38.56 99.18,38.56 99.01,38.72 99.01,38.96 99.96,39.91 99.96,40.14 99.8,40.31 99.56,40.31 98.61,39.36 98.37,39.36 98.21,39.53 98.21,39.76 99.16,40.71 99.16,40.95 98.99,41.12 98.76,41.12 97.81,40.16 97.57,40.16 97.4,40.33 97.4,40.57 98.35,41.52 98.35,41.75 98.04,42.07 97.8,42.07 97.4,41.67 97.16,41.67 97,41.84 97,42.07 97.4,42.47 97.4,42.71 96.69,43.42 96.69,48.75 99.12,51.19 99.12,53.16 98.68,53.6 v1(98.67,53.6)
  BOTTOM w0.076: v1(98.67,53.6) 99.67,53.6 99.87,53.81 99.87,59.44 100.48,60.05 100.48,60.26 100.57,60.35 100.57,61.49 CPU1.AG37
  BOTTOM w0.14: DM2.131 141.39,24.01 141.92,23.48 v1(142.12,23.48)
M_B_A4: length 92.2
  L4 w0.142: v1(98.64,51.57) 96.18,49.11 96.18,40.92 99.81,37.29 100.04,37.29 100.69,37.94 100.89,37.94 101.09,37.74 101.09,37.54 100.44,36.89 100.44,36.66 100.61,36.49 100.85,36.49 101.48,37.12 101.68,37.12 101.88,36.92 101.88,36.72 101.25,36.09 101.25,35.85 101.79,35.31 104.15,35.31 107.56,31.91 110.13,31.91 110.81,31.23 135.65,31.23 140.28,26.6 140.28,25.95 140.44,25.79 141,25.79 141.17,25.62 141.17,25.39 141,25.22 140.44,25.22 140.28,25.05 140.28,24.61 140.55,24.34 141.24,24.34 141.62,23.95 141.62,22.57 141.48,22.43 v1(141.08,22.43)
  BOTTOM w0.076: CPU1.AE35 99.09,62.29 99.09,62.28 99.09,61.99 99.03,61.89 99.03,61.89 98.98,61.8 98.98,61.43 98.99,61.42 98.99,61.42 99.2,61.21 99.2,60.89 99.16,60.85 99.16,60.66 97.41,58.91 97.41,58.91 97.32,58.82 97.32,55.73
  BOTTOM w0.14: v1(98.64,51.57) 96.45,51.57 96.31,51.71 96.31,52.02 96.47,52.18 97.11,52.18 97.28,52.35 97.28,52.58 97.11,52.74 96.47,52.74 96.31,52.9 96.31,54.02 97.32,55.03 97.32,55.73 ; DM2.128 140.63,21.99 v1(141.08,22.43)
M_B_A5: length 88.9
  L4 w0.142: v1(98.71,57.77) 98.71,57.77 96.98,56.04 96.98,52.71 92.7,48.42 92.7,41.69 95.83,38.56 95.83,38.31 95.41,37.88 95.41,37.67 95.72,37.35 95.96,37.35 96.44,37.83 96.67,37.83 96.84,37.66 96.84,37.43 96.36,36.95 96.36,36.71 96.53,36.55 96.76,36.55 97.24,37.02 97.48,37.02 97.64,36.86 97.64,36.62 97.16,36.14 97.16,35.91 97.33,35.74 97.57,35.74 98.05,36.22 98.28,36.22 98.45,36.05 98.45,35.82 97.97,35.34 97.97,35.1 101.04,32.04 102.47,32.04 104.39,30.12 109.39,30.12 110.07,29.44 133.98,29.44 137.3,26.12 137.48,26.12 138.53,25.07 138.53,23.95 139.41,23.07 139.41,22.74 140.07,22.09 v1(140.14,22.09)
  BOTTOM w0.076: v1(98.71,57.77) 99.54,58.6 99.54,59.58 100.15,60.19 100.15,60.4 100.22,60.47 100.22,61.62 100.32,61.9 100.32,62.05 100.16,62.51 CPU1.AF35
  BOTTOM w0.14: DM2.126 v1(140.14,22.09)
M_B_A6: length 90.8
  L4 w0.142: v1(139.76,24.57) 139.4,24.57 139.26,24.71 139.26,25.48 138.53,26.21 138.53,26.45 138.79,26.71 138.79,26.95 138.62,27.11 138.38,27.11 138.12,26.85 137.89,26.85 134.41,30.33 134.41,30.33 134.4,30.34 110.44,30.34 109.76,31.01 104.83,31.01 95.22,40.61 95.22,43.26 95.06,43.43 93.76,43.43 93.59,43.59 93.59,43.83 93.76,44 95.06,44 95.22,44.16 95.22,44.4 95.06,44.56 93.76,44.56 93.59,44.73 93.59,44.97 93.76,45.13 95.06,45.13 95.22,45.3 95.22,45.54 95.06,45.7 93.76,45.7 93.59,45.87 93.59,46.1 93.76,46.27 95.06,46.27 95.22,46.44 95.22,46.67 95.06,46.84 93.76,46.84 93.59,47.01 93.59,47.89 v1(98.67,52.97)
  BOTTOM w0.076: CPU1.AE37 99.53,61.52 99.53,61.35 99.53,61.34 99.53,60.75 99.49,60.71 99.49,60.46 97.81,58.78 97.81,53.37 98.21,52.97 v1(98.67,52.97)
  BOTTOM w0.14: v1(139.76,24.57) 140.39,25.19 DM2.127
M_B_A7: length 88.7
  L4 w0.142: v1(98.04,66.32) 98.05,66.32 98.51,65.86 98.51,64.17 97.91,63.57 97.91,58.43 96.42,56.94 96.42,53.41 91.8,48.79 91.8,41.27 94.51,38.57 94.51,37.3 100.67,31.14 102.1,31.14 104.01,29.22 109.02,29.22 109.46,28.78 133.37,28.78 136.57,25.58 137.25,25.58 137.87,24.97 137.87,23.57 137.95,23.49 137.95,21.4 138.1,21.26 138.97,21.26 v1(139.13,21.42)
  BOTTOM w0.14: CPU1.AC29 v1(98.04,66.32) ; DM2.122 139.14,21.41 v1(139.13,21.42)
M_B_A8: length 91.3
  L4 w0.142: v1(98.67,52.26) 95.67,49.26 95.67,48.19 95.48,48 94.39,48 94.23,47.83 94.23,47.59 94.39,47.43 95.53,47.43 95.67,47.29 95.67,40.8 102.09,34.38 102.33,34.38 102.82,34.87 103.13,34.87 103.28,34.72 103.28,34.52 102.73,33.97 102.73,33.74 103.05,33.42 103.28,33.42 104.23,34.37 104.47,34.37 104.63,34.2 104.63,33.97 103.69,33.02 103.69,32.78 103.85,32.62 104.09,32.62 105.04,33.56 105.27,33.56 105.44,33.4 105.44,33.16 104.49,32.21 104.49,31.98 104.81,31.66 105.11,31.66 106.01,32.57 106.27,32.57 107.38,31.46 109.95,31.46 110.62,30.78 134.59,30.78 134.59,30.78 134.6,30.78 134.93,30.45 135.16,30.45 135.32,30.6 135.56,30.6 135.72,30.44 135.72,30.2 135.57,30.04 135.57,29.81 135.73,29.64 135.97,29.64 136.13,29.8 136.36,29.8 136.53,29.63 136.53,29.4 136.37,29.24 136.37,29 136.54,28.84 136.77,28.84 136.93,28.99 137.17,28.99 137.33,28.83 137.33,28.59 137.17,28.43 137.17,28.2 137.34,28.03 137.58,28.03 137.89,28.35 138.09,28.35 139.81,26.64 v1(139.81,26.06)
  BOTTOM w0.076: CPU1.AE36 99.41,62.23 99.19,61.83 99.15,61.73 99.15,61.49 99.37,61.27 99.37,60.82 99.33,60.78 99.33,60.6 97.58,58.84 97.58,55.28
  BOTTOM w0.14: 97.58,55.28 97.58,54.09 97.41,53.93 97.06,53.93 96.9,53.77 96.9,53.54 97.06,53.37 97.41,53.37 97.58,53.21 97.58,52.64 97.96,52.26 v1(98.67,52.26) ; v1(139.81,26.06) 139.89,26.14 DM2.125
M_B_A9: length 87.6
  L4 w0.142: v1(136.47,24.34) 136.09,24.72 136.09,25.53 133.22,28.4 109.39,28.4 109.02,28.78 103.83,28.78 101.91,30.69 100.48,30.69 94.06,37.11 94.06,38.38 91.36,41.09 91.36,49 95.36,53 95.36,59.34 97.59,61.57 97.59,66.46 v1(97.12,66.94)
  BOTTOM w0.14: CPU1.AB29 97.47,66.58 v1(97.12,66.94) ; DM2.121 138.89,25.91 137.31,24.34 v1(136.47,24.34)
M_B_A10: length 91.9
  L4 w0.089: 101.38,52.01 101.3,52.1 101.3,56.48 101.19,56.59 v1(100.62,56.59)
  L4 w0.142: v1(147.66,22.36) 146.76,23.26 146.76,27.33 140.41,33.68 140.17,33.68 139.59,33.1 139.35,33.1 139.19,33.26 139.19,33.5 139.77,34.08 139.77,34.32 139.6,34.48 139.37,34.48 138.78,33.9 138.55,33.9 138.38,34.07 138.38,34.3 138.96,34.89 138.96,35.12 138.76,35.32 138.56,35.32 137.96,34.72 137.51,34.72 137.34,34.88 137.34,35.75 137.18,35.92 136.94,35.92 136.77,35.75 136.77,34.88 136.61,34.72 136.37,34.72 136.21,34.88 136.21,35.75 136.04,35.92 135.8,35.92 135.64,35.75 135.64,34.88 135.47,34.72 112.2,34.72 111.61,35.31 109.15,35.31 101.74,42.72 101.74,50 101.45,50.29 101.45,51.95 101.38,52.01
  BOTTOM w0.076: v1(100.62,56.59) 100.35,56.59 100.23,56.72 100.23,59.31 100.81,59.9 100.81,60.12 100.91,60.22 100.91,61.18 101.13,61.39 101.13,61.82 101.08,61.9 101.07,61.91 101.02,62 101.02,62.94 CPU1.AG34
  BOTTOM w0.14: v1(147.66,22.36) 147.66,22.25 147.11,21.69 146.39,21.69 146.25,21.55 146.25,21.12 146.39,20.98 146.98,20.98 147.14,20.83 DM2.146
M_B_A11: length 89.6
  L4 w0.142: v1(138.47,22.43) 138.78,22.43 139,22.66 139,23 138.2,23.8 138.2,25.02 137.36,25.85 136.94,25.85 133.74,29.05 109.82,29.05 109.2,29.67 104.2,29.67 102.28,31.59 100.85,31.59 94.96,37.48 94.96,38.75 92.25,41.46 92.25,48.61 96.7,53.06 96.7,56.16 98.2,57.66 98.2,63.45 98.88,64.13 98.88,67.17 98.73,67.32 98.4,67.32 v1(98.04,66.95)
  BOTTOM w0.14: v1(138.47,22.43) 138.63,22.27 DM2.120 ; CPU1.AC28 v1(98.04,66.95)
M_B_A12: length 90.2
  L6 w0.142: v1(97.17,67.57) 97.61,68.02 100.97,68.02 101.26,67.72 101.26,65.85 101.21,65.8 101.21,65.06 101.9,64.37 101.9,64.33 103.94,62.28 104.99,62.28 105.16,62.12 105.16,60.88 105.33,60.71 105.56,60.71 105.73,60.88 105.73,62.12 105.9,62.28 106.13,62.28 106.29,62.12 106.29,61.66 106.46,61.5 106.7,61.5 106.86,61.66 106.86,62.12 107.03,62.28 107.53,62.28 107.7,62.12 107.7,60.9 107.87,60.73 108.1,60.73 108.27,60.9 108.27,62.12 108.44,62.28 108.75,62.28 108.91,62.12 108.91,61.71 109.08,61.55 109.31,61.55 109.48,61.71 109.48,62.12 109.65,62.28 110.06,62.28 110.22,62.12 110.22,60.82 110.39,60.66 110.63,60.66 110.79,60.82 110.79,62.12 110.96,62.28 111.48,62.28 111.81,61.95 111.81,60.96 111.97,60.8 112.96,60.8 116.05,57.71 117.09,57.71 121.33,53.47 121.99,53.47 124.13,51.33 124.13,49.5 124.73,48.9 124.73,41.66 135.49,30.9 135.49,29.51 135.63,29.37 137.03,29.37 137.23,29.16 137.23,28.71 137.06,28.55 135.54,28.55 135.38,28.38 135.38,28.15 135.54,27.98 137.06,27.98 137.23,27.81 137.23,27.58 137.06,27.41 135.54,27.41 135.38,27.24 135.38,27.01 135.54,26.84 137.06,26.84 137.23,26.67 v1(137.23,24.92)
  BOTTOM w0.14: v1(137.23,24.92) 138.39,26.07 DM2.119 ; v1(97.17,67.57) 97.51,67.23 CPU1.AB28
M_B_A13: length 90.9
  L4 w0.142: v1(150.22,23.76) 150.22,24.52 150.05,24.69 149.44,24.69 149.27,24.86 149.27,25.09 149.44,25.26 150.19,25.26 150.34,25.4 150.34,27.45 149.57,28.22 149.57,28.74 139.37,38.94 112.53,38.94 112.37,38.77 112.37,38.16 112.2,37.99 111.96,37.99 111.8,38.16 111.8,38.77 111.63,38.94 111.4,38.94 111.23,38.77 111.23,38.16 111.06,37.99 110.83,37.99 110.66,38.16 110.66,38.77 110.49,38.94 109.31,38.94 105.38,42.87 105.38,43.56 105.27,43.68 104.58,43.68 104.46,43.79 104.46,44.24 104.63,44.4 105.31,44.4 105.48,44.57 105.48,44.8 105.31,44.97 104.63,44.97 104.46,45.14 104.46,45.37 104.63,45.54 105.31,45.54 105.48,45.71 105.48,45.94 105.31,46.11 104.63,46.11 104.46,46.28 104.46,51.32 103.12,52.67 103.12,53.32 102.92,53.52 102.92,54.27 102.78,54.41 v1(102.32,54.41)
  BOTTOM w0.076: CPU1.AK35 102.37,62.28 102.32,62.05 102.32,61.88 102.34,61.78 102.39,61.67 102.39,60.61 102.36,60.58 102.36,60.57 102.2,60.42 102.2,60 101.9,59.71 101.9,54.53 102.02,54.41 v1(102.32,54.41)
  BOTTOM w0.14: DM2.158 150.14,21.8 150.3,21.97 150.69,21.97 150.83,22.11 150.83,22.39 150.69,22.53 150.12,22.53 149.98,22.67 149.98,23.62 150.12,23.76 v1(150.22,23.76)
M_B_A14: length 91.5
  L4 w0.089: 102.17,51.96 101.68,52.44 101.68,58.41 101.58,58.51 v1(100.63,58.51)
  L4 w0.142: v1(147.72,22.99) 147.24,23.47 147.24,24.51 147.78,25.06 147.78,27.83 138.79,36.82 135.17,36.82 134.55,36.2 134.1,36.2 133.93,36.37 133.93,36.78 133.77,36.94 133.53,36.94 133.36,36.78 133.36,36.37 133.2,36.2 132.96,36.2 132.79,36.37 132.79,36.78 132.63,36.94 132.39,36.94 132.23,36.78 132.23,36.37 132.06,36.2 131.82,36.2 131.66,36.37 131.66,36.78 131.49,36.94 131.25,36.94 131.09,36.78 131.09,36.37 130.92,36.2 130.68,36.2 130.52,36.37 130.52,36.78 130.35,36.94 130.12,36.94 129.95,36.78 129.95,36.37 129.78,36.2 129.55,36.2 129.38,36.37 129.38,36.78 129.21,36.94 128.98,36.94 128.81,36.78 128.81,36.37 128.64,36.2 128.41,36.2 128.24,36.37 128.24,36.78 128.08,36.94 127.84,36.94 127.67,36.78 127.67,36.37 127.51,36.2 115.87,36.2 115.28,35.61 112.78,35.61 112.18,36.2 109.52,36.2 102.63,43.09 102.63,49.94 102.29,50.28 102.29,51.83 102.17,51.96
  BOTTOM w0.076: v1(100.63,58.51) 101.19,59.08 101.19,59.96 101.4,60.17 101.4,60.55 101.7,60.85 101.7,61.23 101.51,61.42 101.51,61.82 101.55,61.9 101.56,61.91 101.61,61.99 101.61,62.62 CPU1.AJ35
  BOTTOM w0.14: v1(147.72,22.99) 148.46,23.73 148.46,26.95 148.39,27.02 DM2.151
M_B_A15: length 91.7
  L4 w0.142: v1(102.3,53.78) 102.75,53.33 102.75,52.5 104,51.26 104,43.62 110.08,37.54 112.86,37.54 113.03,37.71 113.03,38.33 113.2,38.49 113.43,38.49 113.6,38.33 113.6,37.71 113.77,37.54 114,37.54 114.17,37.71 114.17,38.33 114.33,38.49 114.57,38.49 114.74,38.33 114.74,37.71 114.9,37.54 115.14,37.54 115.31,37.71 115.31,38.33 115.47,38.49 115.71,38.49 115.88,38.33 115.88,37.71 116.04,37.54 116.28,37.54 116.44,37.71 116.44,38.33 116.61,38.49 116.85,38.49 117.01,38.33 117.01,37.71 117.18,37.54 117.42,37.54 117.58,37.71 117.58,38.33 117.75,38.49 117.98,38.49 118.15,38.33 118.15,37.71 118.32,37.54 118.76,37.54 118.93,37.71 118.93,38.29 119.07,38.43 139.25,38.43 148.93,28.75 148.93,27.5 149.07,27.36 149.81,27.36 149.95,27.22 149.95,26.02 149.81,25.88 v1(149.12,25.88)
  BOTTOM w0.076: v1(102.3,53.78) 101.97,53.78 101.74,54.01 101.74,59.78 102.02,60.06 102.02,60.47 102.19,60.64 102.19,60.65 102.22,60.68 102.22,61.58 102.16,61.83 102.16,62.07 102.18,62.19 102.18,62.82 102.21,62.89 CPU1.AK34
  BOTTOM w0.14: DM2.156 149.63,24.38 149.12,24.89 v1(149.12,25.88)
M_B_A16: length 90.1
  L4 w0.142: v1(149.09,22.09) 149.26,22.09 149.85,22.68 151.52,22.68 152.03,23.19 152.03,28.11 151.63,28.5 151.63,29.72 140.44,40.91 139.68,40.91 139.51,41.08 139.51,41.47 139.34,41.64 139.11,41.64 138.94,41.47 138.94,41.08 138.78,40.91 138.54,40.91 138.37,41.08 138.37,41.47 138.21,41.64 137.97,41.64 137.8,41.47 137.8,41.08 137.64,40.91 136.51,40.91 136.34,41.08 136.34,41.47 136.17,41.63 135.94,41.63 135.77,41.47 135.77,41.08 135.61,40.91 112.22,40.91 107.72,45.42 107.72,50.02 104.82,52.91 104.82,58.93 104.21,59.54 103.84,59.54 103.7,59.68 103.7,60.05 103.56,60.19 103.21,60.19 103.04,60.02 103.04,59.58 102.9,59.44 v1(102.41,59.44)
  BOTTOM w0.076: CPU1.AJ34 102.65,63.59 102.86,63.38 102.86,63.14 102.85,63.14 102.83,62.62 102.83,62.6 102.83,62.51 102.81,62.44 102.81,62.13 102.83,62.05 102.83,61.84 102.76,61.69 102.76,60.45 103,60.21 103,59.76 102.69,59.44 v1(102.41,59.44)
  BOTTOM w0.14: DM2.152 148.63,21.62 148.65,21.63 148.65,21.64 149.09,22.09 v1(149.09,22.09)
M_B_ACT_N: length 89.5
  L4 w0.142: v1(95.33,67.57) 95.05,67.57 94.81,67.34 94.81,66.8 94.85,66.77 94.85,61.29 92.73,59.17 92.73,52.43 90.02,49.72 90.02,40.53 92.72,37.83 92.72,35.23 98.6,29.35 101.35,29.35 103.27,27.43 132.87,27.43 134.36,25.94 134.36,23.7 135.76,22.31 v1(135.86,22.31)
  BOTTOM w0.14: v1(95.33,67.57) 95.33,67.56 95.66,67.23 CPU1.W28 ; DM2.114 137.14,21.39 136.21,22.31 v1(135.86,22.31)
M_B_ALERT_N: length 77.6
  L6 w0.142: v1(136.85,22.74) 136.74,22.84 136.74,23.53 137.68,24.47 137.68,29.35 125.19,41.84 125.19,50.03 124.57,50.65 124.57,51.73 120.37,55.94 120.14,55.94 119.89,56.19 119.89,57.15 118.16,58.88 115.21,58.88 111.55,62.54 104.02,62.54 102.13,64.43 102.13,67.34 101.15,68.31 97.71,68.31 97.64,68.38 97.37,68.38 96.67,67.67 96.67,66.77 v1(96.22,66.32)
  BOTTOM w0.14: v1(96.22,66.32) 96.53,66.5 CPU1.Y29 ; v1(136.85,22.74) 136.85,22.07 137.63,21.28 DM2.116
M_B_BA0: length 90.4
  L4 w0.142: v1(102.28,53.14) 102.28,52.57 103.55,51.3 103.55,43.44 109.89,37.1 113.7,37.1 113.84,36.95 113.84,36.69 114,36.53 114.24,36.53 114.41,36.69 114.41,36.95 114.55,37.1 118.98,37.1 119.79,37.91 139.14,37.91 148.56,28.49 148.56,23.96 149.12,23.4 v1(149.14,23.4)
  BOTTOM w0.076: 101.52,56.67 101.52,58.54 101.57,58.58 101.57,59.84 101.86,60.13 101.86,60.54 102.03,60.71 102.03,60.72 102.06,60.75 102.06,61.51 CPU1.AJ37
  BOTTOM w0.14: DM2.150 148.14,22.54 148.99,23.4 v1(149.14,23.4) ; v1(102.28,53.14) 102.28,52.03 102.09,51.84 100.41,51.84 100.27,51.98 100.27,52.32 100.46,52.51 101.18,52.51 101.34,52.68 101.34,52.91 101.18,53.07 100.46,53.07 100.27,53.26 100.27,53.69 100.44,53.85 101.38,53.85 101.52,53.99 101.52,54.27 101.36,54.43 100.49,54.43 100.35,54.57 100.35,54.85 100.49,54.99 101.36,54.99 101.52,55.15 101.52,56.67
M_B_BA1: length 90.2
  L4 w0.089: 101.91,51.59 101.91,51.96 101.49,52.38 101.49,57.79 101.4,57.88 v1(100.63,57.88)
  L4 w0.142: v1(147.27,26.01) 147.27,27.62 138.51,36.38 135.35,36.38 134.73,35.76 134.28,35.76 134.12,35.59 134.12,35.33 133.95,35.16 133.71,35.16 133.55,35.33 133.55,35.59 133.38,35.76 133.15,35.76 132.98,35.59 132.98,35.33 132.81,35.16 132.58,35.16 132.41,35.33 132.41,35.59 132.24,35.76 132.01,35.76 131.84,35.59 131.84,35.33 131.67,35.16 131.44,35.16 131.27,35.33 131.27,35.59 131.11,35.76 130.87,35.76 130.7,35.59 130.7,35.33 130.54,35.16 130.3,35.16 130.13,35.33 130.13,35.59 129.97,35.76 129.73,35.76 129.57,35.59 129.57,35.33 129.4,35.16 129.16,35.16 129,35.33 129,35.59 128.83,35.76 128.59,35.76 128.43,35.59 128.43,35.33 128.26,35.16 128.03,35.16 127.86,35.33 127.86,35.59 127.69,35.76 127.46,35.76 127.29,35.59 127.29,35.33 127.12,35.16 126.89,35.16 126.72,35.33 126.72,35.59 126.55,35.76 126.32,35.76 126.15,35.59 126.15,35.33 125.99,35.16 125.75,35.16 125.58,35.33 125.58,35.59 125.42,35.76 125.18,35.76 125.01,35.59 125.01,35.33 124.85,35.16 124.61,35.16 124.45,35.33 124.45,35.59 124.28,35.76 124.04,35.76 123.88,35.59 123.88,35.33 123.71,35.16 123.47,35.16 123.31,35.33 123.31,35.59 123.14,35.76 122.9,35.76 122.74,35.59 122.74,35.33 122.57,35.16 122.34,35.16 122.17,35.33 122.17,35.59 122,35.76 121.77,35.76 121.6,35.59 121.6,35.33 121.43,35.16 121.2,35.16 121.03,35.33 121.03,35.59 120.86,35.76 120.63,35.76 120.46,35.59 120.46,35.33 120.3,35.16 120.06,35.16 119.89,35.33 119.89,35.59 119.73,35.76 119.49,35.76 119.32,35.59 119.32,35.33 119.16,35.16 118.92,35.16 118.76,35.33 118.76,35.59 118.59,35.76 118.35,35.76 118.19,35.59 118.19,35.33 118.02,35.16 117.78,35.16 117.62,35.33 117.62,35.59 117.45,35.76 117.22,35.76 117.05,35.59 117.05,35.33 116.88,35.16 116.65,35.16 116.48,35.33 116.48,35.59 116.31,35.76 116.08,35.76 115.91,35.59 115.91,35.33 115.74,35.16 112.43,35.16 111.84,35.76 109.34,35.76 102.18,42.91 102.18,49.94 101.91,50.21 101.91,51.59
  BOTTOM w0.076: CPU1.AJ36 101.93,62.23 101.69,61.81 101.68,61.8 101.67,61.77 101.67,61.49 101.86,61.29 101.86,60.78 101.56,60.48 101.56,60.09 101.4,59.93 101.4,58.65 v1(100.63,57.88)
  BOTTOM w0.14: DM2.145 146.89,26.44 147.27,26.06 v1(147.27,26.01)
M_B_BG0: length 89
  L4 w0.142: v1(135.6,23.73) 135.12,23.73 134.72,24.13 134.72,26.05 133.01,27.76 109.14,27.76 109.02,27.88 103.46,27.88 101.54,29.8 98.79,29.8 93.17,35.42 93.17,38.01 90.46,40.72 90.46,49.45 93.24,52.23 93.24,59 95.78,61.54 95.78,66.07 95.73,66.12 95.73,66.5 v1(95.29,66.94)
  BOTTOM w0.14: DM2.115 137.39,26.52 136.01,25.15 136.01,24.14 v1(135.6,23.73) ; v1(95.29,66.94) 95.4,66.94 CPU1.W29
M_B_BG1: length 89.3
  L4 w0.142: v1(135.46,24.97) 135.46,25.78 133.17,28.07 109.28,28.07 109.02,28.33 103.64,28.33 101.72,30.25 98.97,30.25 95.38,33.84 95.38,34.08 95.8,34.51 95.8,34.74 95.63,34.91 95.4,34.91 94.97,34.48 94.74,34.48 94.57,34.65 94.57,34.89 95,35.31 95,35.55 94.83,35.71 94.59,35.71 94.17,35.29 93.93,35.29 93.68,35.55 93.68,35.75 94.13,36.2 94.13,36.4 93.62,36.91 93.62,38.2 90.91,40.9 90.91,49.24 94.9,53.23 94.9,60.25 96.74,62.09 96.74,63.52 96.69,63.57 96.69,66.48 v1(96.22,66.95)
  BOTTOM w0.14: CPU1.Y28 v1(96.22,66.95) ; DM2.113 136.89,26.51 135.46,25.08 v1(135.46,24.97)
M_B_CKE0: length 86.7
  L4 w0.142: v1(133.04,25.2) 132.46,25.78 132.46,26.37 132.01,26.82 109.39,26.82 108.83,26.27 100.43,26.27 91.83,34.86 91.83,37.46 89.12,40.16 89.12,50.19 91.38,52.45 91.38,60.39 92.84,61.85 92.84,63.21 93.47,63.83 93.47,64.26 93.02,64.71 93.02,66.48 v1(93.5,66.95)
  BOTTOM w0.14: DM2.109 135.89,26.65 134.43,25.2 v1(133.04,25.2) ; CPU1.T28 93.67,66.96 93.51,66.96 v1(93.5,66.95)
M_B_CKE1: length 88
  L4 w0.142: v1(93.45,66.25) 93.95,65.75 93.95,63.73 94.19,63.48 94.19,62.83 91.61,60.25 91.61,51.97 89.57,49.93 89.57,40.35 92.28,37.64 92.28,35.05 98.42,28.91 100.42,28.91 102.62,26.71 108.8,26.71 109.17,27.09 132.7,27.09 133.83,25.97 133.83,23.43 v1(134.15,23.11)
  BOTTOM w0.14: CPU1.T29 93.6,66.25 v1(93.45,66.25) ; v1(134.15,23.11) 135.35,21.91 135.35,21.41 136.14,20.63 DM2.110
M_B_CLK0: length 93
  L4 w0.089: v1(144.03,25.04) 145.3,25.04 145.5,25.25 145.5,26.43 144.52,27.41 144.07,27.41 143.59,26.93 143.47,26.93 143.28,27.12 143.28,27.28 143.82,27.82 143.82,28.11 143.56,28.37 143.28,28.37 142.73,27.83 142.57,27.83 137.19,33.21 111.59,33.21 110.94,33.86 108.55,33.86 100.29,42.12 100.29,54.54 99.52,55.3 99.52,60.82 100.25,61.55 100.25,62.26 100.05,62.46 99.16,62.46 99.07,62.55 99.07,62.73 99.16,62.82 99.9,62.82 100.1,63.02 100.1,63.35 99.9,63.55 99.46,63.55 99.36,63.66 99.36,68.16 99.46,68.27 99.99,68.27 100.08,68.17 100.08,67.36 100.3,67.14 100.3,66.79 v1(100.77,66.32)
  BOTTOM w0.102: DM2.137 142.89,27.05 142.96,26.98 142.96,25.45 143.33,25.08 143.52,25.07 143.62,25.06 v1(144.03,25.04) ; CPU1.AF29 100.51,66.58 v1(100.77,66.32)
M_B_CLK1: length 92.1
  L4 w0.089: v1(99.86,66.32) 100.08,66.32 100.16,66.24 100.16,66.08 100.53,65.71 101.4,64.84 101.4,64.09 100.86,63.55 100.86,61.57 99.92,60.62 99.92,55.46 100.68,54.7 100.68,42.28 108.71,34.25 111.1,34.25 111.75,33.6 137.35,33.6 141.45,29.5 141.74,29.5 142.22,29.99 142.35,29.99 142.57,29.77 142.57,29.64 142.14,29.21 142.14,28.93 142.39,28.68 142.71,28.68 143.1,29.07 143.26,29.07 145.74,26.6 145.74,24.83 145.62,24.71 144.7,24.71 144.47,24.49 144.47,24.17 144.7,23.94 145.74,23.94 145.83,23.85 145.83,22.43 145.65,22.25 144.51,22.25 144.39,22.36 144.39,22.71 144.3,22.81 v1(143.95,22.81)
  BOTTOM w0.102: v1(99.86,66.32) CPU1.AE29 ; DM2.138 143.14,20.77 143.26,20.89 143.26,21.59 143.22,21.64 143.22,22.25 143.45,22.48 143.85,22.48 143.95,22.58 v1(143.95,22.81)
