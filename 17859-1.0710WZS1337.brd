# Allegro board 17859-1.0710WZS1337.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SYS_LED_MASK#: length 19.6
  TOP w0.089: 39.05,55.74 37.18,53.88 v2(37.18,53.57) 37.18,52.45 36.78,52.05 U2401.55 36.78,50.51 35.7,49.43 34.64,49.43 34.52,49.55 33.61,49.55 32.76,50.4 28.19,50.4 28.03,50.55 v1(27.99,50.55)
  TOP w0.102: 39.05,55.74 39.36,56.06 R2431.1
  BOTTOM w0.102: R2403.2 R2404.1 28.7,52.02 C2430.1 28.7,51.26 v1(27.99,50.55)
SYS_LED_MASK#_R: length 19.4
  TOP w0.102: v2(41.29,57.53) 41.39,57.53 v1(41.95,56.97) 41.95,56.36 R2497.1 41.65,56.06 R2431.2 ; v1(30.22,58.85) 30.42,59.06 U6402.2 30.42,59.82 30.8,60.2 31.67,60.2 32.02,59.85 R6419.1
  BOTTOM w0.102: v1(30.22,58.85) 30.87,58.21 34.37,58.21 34.56,58.4 41.8,58.4 42.41,57.79 42.41,57.43 42.39,57.41 v1(41.95,56.97)
SYS_PEX_RST_MON#: length 10.5
  BOTTOM w0.102: D7601.2 160.09,77.32 R7943.1 160.09,78.34 R7974.2 161.48,79.72 U7601.4 162.47,81.03 162.48,81.03 R7606.1 R7604.2 163.77,81.94 164.05,81.66 v2(164.05,80.85) 164.61,80.85 164.71,80.95 R7613.1
SYS_PEX_RST_MON_GPU#: length 57.5
  L6 w0.102: v1(185.85,76.28) 187.64,76.28 188.02,75.91 188.02,72.45 187.7,72.14 187.7,71.64 184.34,68.28 179.48,68.28 177.9,66.7 177.9,66.7 176.93,65.74 176.93,65.23 176.47,64.77 175.51,64.77 174.01,63.27 174.01,62.26 172.16,60.41 169.26,60.41 167,62.66 167,64.19 162.27,68.91 162.27,69.83 157.32,74.78 v1(157.32,75.95)
  BOTTOM w0.102: GPU1.E9 v1(185.85,76.28) ; v1(157.32,75.95) 157.32,75.94 157.49,75.77 v2(158.01,75.77) 159.14,75.77 159.53,76.16 159.53,78.64 R7974.1
SYS_PRES1#: length 10.7
  TOP w0.102: R4301.2 109.72,13.92 AFTP4315.1 111.26,14.43 113.35,14.43 113.46,14.53 v1(113.46,14.56)
  BOTTOM w0.102: v1(113.46,14.56) 114.06,15.16 117.11,15.16 117.64,15.69 BATT1.7
SYS_PWROK: length 213.5
  TOP w0.102: v1(46.06,51.03) 46.06,50.54 45.71,50.19 45.71,49.43 45.51,49.23 45.51,48.75 45.74,48.52 45.87,48.52 46.27,48.11 U2401.28 ; v2(164.36,47.32) 164.36,47.91 v1(164.41,47.96)
  L3 w0.102: v1(164.41,47.96) 164.1,47.96 162.6,49.45 162.6,50.4 162.43,50.57 162.43,52.61 158.27,56.77 156.1,56.77 155.47,57.41 155.47,68.96 153.84,70.59 153.84,71.2 151.53,73.51 148.53,73.51 148.15,73.89 145.26,73.89 144.93,73.56 139.11,73.56 v1(138.58,74.1)
  BOTTOM w0.102: v1(46.06,51.03) 46.16,50.93 49.42,50.93 50.26,51.77 51.68,51.77 53.26,53.34 53.92,53.34 54.25,53.01 54.93,53.01 55.09,53.16 56.53,53.16 57.86,51.84 58.8,51.84 59.3,51.34 59.4,51.34 60.98,49.76 60.98,49.66 62.17,48.47 62.45,48.47 62.48,48.49 67.96,48.49 68.19,48.72 71.76,48.72 78.33,42.15 78.33,42.14 78.56,41.91 107.97,41.91 108.66,41.23 112.03,41.23 116.83,36.43 148.23,36.43 149.45,37.65 162.08,37.65 165.2,40.76 165.2,41.73 165.86,42.4 165.86,44.94 164.46,46.33 164.46,47.91 v1(164.41,47.96) ; CPU1.CR10 132.31,78.64 133.36,77.6 133.62,77.6 134.31,76.92 135.37,76.92 135.73,76.56 136.27,76.56 137.38,75.44 137.48,75.44 138.58,74.35 v1(138.58,74.1) 138.53,74.04 R1717.1 138.53,73.34 139.22,72.65 139.46,72.65 140.35,71.76 142.52,71.76 142.84,71.43 142.84,70.56 143.43,69.98 143.43,67.21 142.26,66.04 142.26,64.87 143.18,63.95 ED1702.1
SYSPWR_PRES: length 6.3
  TOP w0.102: U2401.120 42.38,35.09 42.08,34.79 42.08,34.47 41.8,34.19 41.8,31.96 v2(42.06,31.7) 42.06,30.8 R2453.2 42.02,30.76 R2455.1
T_CRIT#: length 3.7
  TOP w0.102: v2(168.83,103.58) 168.83,104.45 R2601.1 R2604.2 167.99,104.92 v1(167.68,105.22)
  BOTTOM w0.102: THM261.4 v1(167.68,105.22)
TBTA_SENSEN: length 3.6
  TOP w0.102: 74,94.73 74.47,95.2 74.47,95.93 75.01,96.47 U7204.A10 ; 74,94.73 v2(73.86,94.87) ; 74,94.73 73.81,94.53 73.81,94.21 R7235.2
TBTA_SENSEP: length 4
  TOP w0.089: U7204.B10 75.25,97.02 75.25,96.4 74.76,95.9
  TOP w0.102: 74.76,95.9 74.7,95.84 74.7,95.1 74.04,94.44 74.04,94.19 R7234.2
TESTMODE: length 7.7
  TOP w0.102: R7602.1 173.93,91.26 v2(174.03,91.26) 175.17,91.26 v1(175.38,91.47)
  BOTTOM w0.102: GPU1.AD9 175.31,88 174.94,88.37 174.94,88.74 175.13,88.93 175.13,89.33 174.17,90.29 174.17,90.62 174.47,90.91 174.82,90.91 v1(175.38,91.47)
THERM_SYS_SHDN#: length 254.9
  TOP w0.102: R2601.2 169.67,104.15 v1(170.24,103.58) ; R2602.1 24.66,38.64 23.16,40.13 v1(23.16,40.21) 23.09,40.28 Q2602.S 21.37,40.28 v2(21.33,40.24)
  L6 w0.102: v1(170.24,103.58) 169.32,104.5 166.8,104.5 166.01,105.29 163.06,105.29 160.06,102.29 160.06,100.46 159.55,99.94 159.55,86.17 161.77,83.95 162.83,83.95 173.48,73.3 173.48,71.38 172.23,70.13 172.23,69.93 171.47,69.17 171.47,67.92 171.44,67.9 v1(171.44,67.72)
  BOTTOM w0.102: v1(23.16,40.21) 24.85,40.21 26.74,42.1 26.74,45.42 29.25,47.93 29.25,49.53 29.53,49.81 31.08,49.81 31.93,48.97 33.32,48.97 34.42,50.07 34.42,50.08 35.27,50.93 45.17,50.93 45.53,50.57 49.56,50.57 50.38,51.39 52.86,51.39 53.83,52.35 55.01,52.35 55.06,52.3 56.79,52.3 57.6,51.49 58.64,51.49 59.15,50.98 59.17,50.98 60.62,49.53 60.62,49.51 62.03,48.11 68.14,48.11 68.4,48.36 71.6,48.36 78.4,41.56 107.82,41.56 108.5,40.87 111.88,40.87 116.68,36.07 116.68,36.07 116.71,36.05 116.99,36.05 117.01,36.07 148.41,36.07 149.63,37.29 162.23,37.29 165.58,40.64 165.58,41.61 166.21,42.24 166.21,45.14 165.02,46.33 165.02,49.2 169.11,53.29 172.69,53.29 174.29,54.89 174.29,59.29 171.67,61.9 171.67,64.54 171.14,65.08 171.14,67.34 171.44,67.64 v1(171.44,67.72)
THERMTRIP#_CPU: length 19.7
  TOP w0.102: v1(108.34,92.27) 108.52,92.27 v2(108.91,92.66) 108.9,92.67 108.9,95.42 109.19,95.71 ED301.1 110.53,95.71 R308.2
  L4 w0.102: v1(108.34,92.27) 108.68,91.93 108.68,85.05 109.81,83.92 111.15,83.92 112.12,84.89 112.54,84.89 112.84,85.19 113.23,85.19 113.7,84.73 v1(113.7,84.56)
  BOTTOM w0.102: CPU1.BJ1 113.99,84.27 v1(113.7,84.56)
THM_SML1_CLK: length 208.1
  TOP w0.089: v1(60.22,41.25) 60.52,40.95 61.16,40.95 61.26,41.05 RN2602.4 ; C2608.1 165.2,102.64 165.25,102.59 v1(165.25,102.29) ; Q2601.4 57.79,40.58 v2(57.09,41.28) 57.09,41.94 v1(57.45,42.3)
  L6 w0.089: v1(165.25,102.29) 164.8,101.85 164.8,100.08 161.58,96.86 161.58,86.86 162.54,85.91 164.97,85.91 167.21,83.67 168.04,83.67 170.58,81.13 170.58,79.43 175.39,74.62 175.39,68.26 v1(173.37,66.25)
  BOTTOM w0.089: v1(57.45,42.3) 58.5,41.25 v1(60.22,41.25) 60.52,40.95 64.51,40.95 65.22,40.24 69.64,40.24 70.93,38.96 110.4,38.96 110.41,38.97 110.64,38.97 115.41,34.19 152.9,34.19 153.66,34.95 163.27,34.95 166.85,38.53 167.38,38.53 168.57,39.73 168.57,39.8 168.7,39.93 168.7,44.76 168.27,45.19 168.27,45.62 167.67,46.22 167.67,47.96 168.24,48.53 168.24,48.54 168.42,48.72 169.95,48.72 170.38,49.15 170.71,49.15 170.73,49.18 171.24,49.18 176.22,54.16 176.22,54.26 176.35,54.38 176.35,54.41 176.38,54.44 176.38,59.61 173.55,62.44 173.55,64.98 173.1,65.43 173.1,65.97 v1(173.37,66.25) ; THM261.8 165.64,107.18 166.11,106.71 166.11,103.69 165.25,102.82 v1(165.25,102.29)
THM_SML1_DATA: length 201.7
  TOP w0.089: Q2601.1 59.37,42.29 RN2602.3 60.59,41.73 v1(60.84,41.48) ; v2(164.42,101.77) v1(164.42,102.38) 164.41,102.39 C2609.1
  L6 w0.089: v1(172.94,66.73) 173.19,66.73 175.1,68.63 175.1,74.46 169.72,79.83 169.72,81.6 167.95,83.37 167.09,83.37 164.88,85.58 162.45,85.58 161.29,86.74 161.29,99.24 v1(164.42,102.38)
  BOTTOM w0.089: v1(60.84,41.48) 64.36,41.48 65.33,40.51 69.76,40.51 70.99,39.27 110.71,39.27 110.73,39.25 110.74,39.25 115.51,34.47 152.8,34.47 153.56,35.23 163.16,35.23 166.75,38.81 167.2,38.81 168.42,40.03 168.42,44.66 167.99,45.09 167.99,45.52 166.73,46.78 166.73,47.75 167.97,49 168.85,49 169.51,49.66 171.34,49.66 175.94,54.26 175.94,54.36 176.07,54.49 176.07,54.51 176.11,54.56 176.11,59.48 173.27,62.31 173.27,64.87 172.82,65.33 172.82,66.09 172.94,66.22 v1(172.94,66.73) ; THM261.7 165.66,106.53 165.83,106.35 165.83,103.79 v1(164.42,102.38)
TOP_MUX_N: length 14
  TOP w0.102: v1(16.4,87.86) 16.48,87.86 16.83,87.51 16.91,87.51 16.96,87.45 ED7304.2
  BOTTOM w0.102: 13.05,87.28 12.77,87.56 9.9,87.56 8.48,88.98 7.69,88.98 7.41,89.25 USB1.A7 ; 13.05,87.28 v2(13.18,87.4) ; 13.05,87.28 13.81,86.52 15.42,86.52 15.87,86.97 15.87,87.76 16.02,87.91 16.35,87.91 v1(16.4,87.86) 16.73,87.86 16.95,87.63 17.24,87.63 17.24,87.63 EL7301.2
TOP_MUX_N_L: length 77.7
  TOP w0.102: v1(75.94,108.41) 76.39,107.96 76.39,106.33 ; 76.39,106.33 v2(76.22,106.33) ; 76.39,106.33 76.39,106.12 76.55,105.96 76.55,102.9 76.8,102.64 76.8,102.38 77.03,102.16 77.03,101.94 77.03,101.79 U7204.L6
  L3 w0.102: v1(19.03,87.61) 19.11,87.53 19.65,87.53 19.98,87.87 19.98,91.48 24.22,95.71 27.47,95.71 28.97,97.21 35.06,97.21 38.16,100.31 61.76,100.31 69.07,107.62 69.08,107.62 69.14,107.68 75.01,107.68 75.36,107.33 76.25,107.33 76.5,107.58 76.5,107.85 v1(75.94,108.41)
  BOTTOM w0.102: EL7301.1 18.1,87.63 18.1,87.63 18.21,87.63 18.36,87.48 18.91,87.48 v1(19.03,87.61)
TOP_MUX_P: length 13.1
  TOP w0.102: v1(16.4,87.18) 16.48,87.18 16.58,87.28 16.81,87.28 17.04,87.05 ED7304.1
  BOTTOM w0.102: USB1.A6 8.38,88.75 9.81,87.33 12.68,87.33 13.72,86.29 14.55,86.29 ; EL7301.3 17.24,86.87 17.24,86.87 17,86.87 16.7,87.18 v1(16.4,87.18) 15.51,86.29 14.55,86.29 ; v2(14.55,86.13) 14.55,86.29
TOP_MUX_P_L: length 78.5
  TOP w0.089: U7204.K6 77.26,101.52 77.26,101.93 77.26,101.93 77.26,102.04
  TOP w0.102: 76.62,107.57 76.62,108.3 v1(76.7,108.38) ; 76.62,107.57 76.62,106.21 76.78,106.05 76.78,102.99 77.03,102.74 77.03,102.48 77.26,102.25 77.26,102.04 ; 76.62,107.57 v2(76.8,107.57)
  L3 w0.102: v1(76.7,108.38) 76.7,107.5 76.33,107.13 75.28,107.13 74.93,107.48 69.22,107.48 69.17,107.42 69.16,107.42 61.84,100.1 38.25,100.1 35.15,97.01 29.05,97.01 27.55,95.51 24.3,95.51 20.19,91.39 20.19,87.79 19.73,87.33 19.37,87.33 v1(19.02,86.97)
  BOTTOM w0.102: v1(19.02,86.97) 18.74,87.25 18.51,87.25 18.13,86.87 18.1,86.87 EL7301.4
TOUCH_DETECT: length 6.9
  BOTTOM w0.102: CPU1.CN14 128.99,76.4 130.04,76.4 130.22,76.31 130.44,76.09 130.54,76.03 131.25,75.8 131.59,75.8 131.73,75.66 v2(133.11,75.66) 133.79,75.66 133.95,75.82 R2120.1 R2119.2
TOUCH_PAD_INTR#: length 30
  TOP w0.102: R319.2 v2(136.8,45.67) 136.8,46.74 R303.2 137.26,46.76 137.38,46.64 v1(137.38,46.18)
  BOTTOM w0.076: CPU1.CB34 122.34,62.88 122.32,62.84 122.32,62.19 122.31,62.15 122.31,62.15 122.29,62.11 122.29,61.81 122.31,61.77 122.31,61.77 122.32,61.72 122.32,61.61 122.34,61.6 122.34,61.59 122.41,61.52 122.41,60.47 122.14,60.21 122.14,58.73 122.39,58.48 122.39,57.94 123.9,56.43 123.9,56.33 123.93,56.3 123.93,56.15
  BOTTOM w0.102: v1(137.38,46.18) 136.62,46.94 132.03,46.94 129.15,49.81 128.31,49.81 125.71,52.41 125.71,52.75 123.93,54.53 123.93,56.15
TOUCH_PANEL_INTR#: length 117.9
  L4 w0.102: v1(131.24,82.4) 130.52,81.69 129.41,81.69 129.18,81.46 127.31,81.46 127.02,81.74 127.02,81.91 126.47,82.47 123.81,82.47 123.31,81.97 123.31,79.07 122.39,78.16 120.57,78.16 120.49,78.08 116.2,78.08 116.05,77.93 115.39,77.93 114.5,78.82 108.86,78.82 107.97,79.71 107.97,82.81 106.37,84.41 106.37,89.66 106.45,89.74 106.45,91 105.07,92.38 100.91,92.38 98.9,94.39 84.65,94.39 84.58,94.47 81.32,94.47 80.94,94.85 68.85,94.85 68.62,95.07 64.56,95.07 64.42,95.21 53.16,95.21 53.05,95.11 v1(53.05,95.1)
  BOTTOM w0.089: v1(131.24,82.4) 131.24,82.43 131.11,82.55 130.95,82.55 130.05,83.45 129.8,83.45 129.62,83.27 128.87,83.27 CPU1.CN3
  BOTTOM w0.102: v1(53.05,95.1) 53.16,95.2 56.69,95.2 59.75,92.13 59.75,89.45 60.03,89.18 v2(60.03,88.15) 59.86,87.98 59.29,87.98 R5553.2 58.74,87.15 R5551.2 56.86,85.27 55.49,85.27 R5537.1
TOUCH_PANEL_PD#: length 172.7
  TOP w0.102: v1(135.31,41.46) 135.31,39.22 v2(129.19,33.09) 128.07,31.97 60.46,31.97 58.82,33.61 v1(58.41,33.61)
  L3 w0.102: v1(47.62,68.86) 47.59,68.84 46.88,68.84 46.65,69.07 46.65,69.52 48.64,71.5 48.64,75.59 50.06,77.02 50.06,80.47 51.43,81.84 51.43,84.41 51.36,84.48 51.36,85.65 51.87,86.16 v1(52.24,86.16)
  L4 w0.102: v1(47.62,68.86) 47.02,68.27 47.02,63.72 51.61,59.13 52.43,59.13 56.81,54.75 56.81,53.06 55.98,52.23 55.98,50.09 56.78,49.29 56.78,45.06 58.08,43.76 58.08,33.94 v1(58.41,33.61)
  L6 w0.102: v1(135.31,41.46) 135.31,42.2 134.41,43.11 134.41,44.78 127.73,51.46 127.73,52.76 127.21,53.28 127.21,53.58 123.33,57.45 v1(123.33,59.2)
  BOTTOM w0.076: CPU1.CC35 123.36,62.86 123.22,62.71 123.19,62.62 123.19,62.6 123.14,62.49 123.14,62.47 123.14,62.47 123.11,62.38 123.11,62.19 123.14,62.1 123.14,62.1 123.14,61.84 123.07,61.64 123.07,60.14 122.9,59.97 122.9,59.65 123.33,59.22 v1(123.33,59.2)
  BOTTOM w0.102: R5538.1 52.24,86.69 v1(52.24,86.16)
TOUCH_REPORT_SW: length 101.2
  TOP w0.102: D2402.A 54.58,51.23 54.96,51.62 54.96,52.12 54.15,52.94 54.15,53.11 54.1,53.16 54.1,53.8 v2(54.23,53.94) 53.56,54.61 v1(52.01,54.61)
  L4 w0.102: v1(52.01,54.61) 51.14,53.74 48.51,53.74 48.27,53.5 48.24,53.5 48.03,53.29 48.03,52.99 48.05,52.96 48.05,52.6 47.8,52.35 45.08,52.35 44.55,52.88 43.56,52.88 42.09,51.42 36.23,51.42 34.41,53.23 33.15,53.23 v1(31.97,54.41)
  L6 w0.102: v1(31.97,54.41) 31.26,55.12 31.02,55.12 29.71,56.43 29.71,57.23 28.65,58.3 28.65,61.55 30.22,63.12 30.22,64.49 28.54,66.17 28.54,68.46 29.64,69.56 29.64,74.88 29.26,75.26 28.42,75.26 26.44,77.24 26.44,78.36 32.93,84.85 33.89,84.85 34.33,85.3 37.48,85.3 40.28,82.5 40.64,82.5 40.94,82.81 40.94,84.46 38.7,86.69 38.7,87.96 39.54,88.8 46.86,88.8 47.77,89.72 52.59,89.72 v1(53.33,90.46)
  BOTTOM w0.102: LCD1.34 54.56,91.5 53.97,90.91 53.79,90.91 v1(53.33,90.46)
TP_EN#: length 181.8
  TOP w0.102: v1(54.58,31.73) 52.88,31.73 51.51,33.1 51.51,35.11 51.78,35.38 RN2405.2 ; v1(178.45,16.28) 176.3,16.28 v2(175.78,15.76) 175.36,15.34 R6516.1 ; v1(39.52,47.81) 39.52,47.83 39.18,48.17 U2401.49
  L4 w0.102: v1(39.52,47.81) 39.75,48.03 40.63,48.03 41.83,46.84 43.15,46.84 43.89,46.1 44.19,46.1 44.52,45.77 46.76,45.77 47.09,46.1 48,46.1 48.61,45.49 48.61,45.29 49.07,44.83 49.27,44.83 52.8,41.3 52.8,39.47 54.03,38.24 54.04,38.24 55.18,37.11 55.18,32.83 54.58,32.24 v1(54.58,31.73) 54.86,31.45 54.86,22.86 56.2,21.52 56.2,20.73 57.5,19.43 63.42,19.43 64,18.85 69.72,18.85 70.05,18.52 70.05,18.49 70.96,17.58 72.94,17.58 74.82,15.7 77.68,15.7 80.17,18.19 80.18,18.19 80.21,18.21 80.46,18.21 80.49,18.19 95.14,18.19 95.76,17.57 99.52,17.57 101.62,19.66 103.19,19.66 104.23,20.7 171.03,20.7 175.45,16.28 v1(178.45,16.28)
TP_LOCK#: length 191.2
  TOP w0.102: D2405.A 26.21,42.04 v1(25.57,42.67) ; v1(178.21,14.4) 177.92,14.12 AFTP6526.1 177.92,13.54 178.51,12.96 178.51,12.52 177.72,11.74 177.72,10.29 177.97,10.04 R6509.1
  L4 w0.102: v1(178.21,14.4) 176.69,15.93 175.3,15.93 170.81,20.42 109.06,20.42 108.99,20.35 104.38,20.35 103.55,19.52 103.55,19.51 103.35,19.31 101.77,19.31 99.68,17.21 95.61,17.21 95.27,17.55 80.05,17.55 77.85,15.34 74.67,15.34 72.97,17.05 70.5,17.05 69.87,17.68 64.66,17.68 63.14,19.21 57.26,19.21 54.63,21.83 54.63,27.43 54.5,27.56 54.5,31.14 54.15,31.5 54.15,32.31 54.52,32.68 54.52,37.25 52.45,39.32 52.45,41.1 49.06,44.48 48.92,44.48 47.8,45.6 47.09,45.6 46.91,45.42 44.37,45.42 44.19,45.6 42.64,45.6 42.11,46.13 41.83,46.13 41.04,46.92 37.61,46.92 37.1,46.41 33.85,46.41 31.79,44.35 27.25,44.35 v1(25.57,42.67)
  BOTTOM w0.102: TPAD1.3 v1(178.21,14.4)
TP_ON#_GATE: length 23.1
  TOP w0.127: v1(171.24,6.84) 171.34,6.94 171.34,7 172.36,8.02 v2(172.36,9.79) v1(172.36,10.65) ; v1(171.47,15.75) 171.47,16.63 171.75,16.91 173.08,16.91 174.03,15.95 R6516.2 174.03,14.86 C6503.2
  BOTTOM w0.127: v1(171.47,15.75) 171.47,16.51 171.17,16.82 169.59,16.82 168.7,15.93 Q6504.G 170.21,15.33 171.14,14.4 171.14,12.7 171.11,12.68 171.11,11.53 171.14,11.51 171.14,11.46 171.95,10.65 v1(172.36,10.65) ; v1(171.24,6.84) 171.24,6.79 171.08,6.63 Q6505.G
TP_RESET: length 6.9
  BOTTOM w0.102: LCD1.35 55.06,90.66 55.06,90.66 55.06,90.1 54.86,89.89 v2(54.78,89.89) 54.78,89.23 54.29,88.74 EC5505.1 EC5505.10 53.62,87.5 C5540.1 53.26,87.86 R5538.2
TP_RS: length 8
  BOTTOM w0.102: LCD1.36 55.56,91.83 55.42,91.69 55.42,89.36 54.79,88.73 EC5505.2 EC5505.9 54.79,87.11 54.32,86.64 v2(54.32,86.41) 54.1,86.18 C5541.1 54.17,85.5 R5537.2
TP_WAKE_KBC#: length 216.3
  TOP w0.102: v1(57.39,32.62) 58.25,31.75 129.47,31.75 136.46,38.75 136.46,41.55 136.96,42.05 137.52,42.05 138.68,43.21 v1(138.68,43.53) 138.68,44.48 138.42,44.73 R319.1 ; U2401.33 45.58,51.68 45.74,51.84 45.96,51.84 46.26,52.14 47.88,52.14 48.46,52.72 v1(48.46,53.11) ; v1(179.06,17.35) 178.89,17.17 178.89,16.11 178.51,15.73 AFTP6525.1 176.27,15.73 174.21,13.67 174.21,12.55 174.47,12.3 174.47,11.74 R6502.1
  L3 w0.102: v1(41.75,52.66) 41.75,51.21 41.32,50.78 41.32,49.28 42.03,48.57 42.03,48.01 42.13,47.91 42.13,43.21 42.67,42.68 42.67,40.24 42.49,40.06 42.49,37.87 42.49,37.87 42.49,37.74 42.97,37.26 42.97,36.45 41.45,34.93 v1(41.45,34.78)
  L4 w0.102: v1(179.06,17.35) 178.76,17.05 175.38,17.05 174.11,18.31 174.11,21.36 174.54,21.8 174.54,31.7 174.59,31.75 174.59,32.12 175.09,32.62 175.28,32.62 175.54,32.88 175.54,33.65 170.66,38.53 167.99,38.53 167.89,38.64 167.19,38.64 164.82,41 164.81,41 162.22,43.59 162.22,43.94 162,44.17 161.97,44.17 161.51,44.63 160.73,44.63 v1(160.34,44.25)
  BOTTOM w0.102: v1(138.68,43.53) 149.95,43.53 151.11,44.68 157.08,44.68 157.83,43.93 160.05,43.93 160.34,44.22 v1(160.34,44.25) ; v1(179.06,17.35) 178.89,17.35 177.21,15.67 TPAD1.4 ; v1(41.75,52.66) 42.37,53.27 48.29,53.27 v1(48.46,53.11) ; v1(41.45,34.78) 41.45,34.93 42.34,35.82 47.42,35.82 47.47,35.87 48.64,35.87 48.71,35.79 49.47,35.79 51.91,33.35 53.23,33.35 53.31,33.28 53.94,33.28 55.24,31.98 55.6,31.98 56.23,32.62 v1(57.39,32.62)
TPCLK_C: length 3.8
  TOP w0.089: RN6503.4 180.01,13.31 AFTP6530.1 179.7,13.62 v1(179.7,13.92)
  BOTTOM w0.089: v1(179.7,13.92) 179.7,14.28 180.21,14.79 TPAD1.1
TPDATA_C: length 6.2
  TOP w0.089: RN6503.3 180.66,13.15 180.12,13.69 180.12,14.61 AFTP6524.1 179.5,16.21 v1(179.62,16.33)
  BOTTOM w0.089: v1(179.62,16.33) 179.21,15.92 TPAD1.2
TPM_GPIO0: length 8.7
  TOP w0.102: R9121.1 208.32,31.65 208.32,33.38 208.07,33.63 v2(207.54,33.63) 207.25,33.34 207.25,32.73 206.24,31.73 204.08,31.73 203.37,32.44 U9101.29
TPM_GPIO1: length 3.5
  TOP w0.089: U9101.30 203.87,32.29 203.96,32.21 206.16,32.21 TP9102.1
TPM_GPIO2: length 4.5
  TOP w0.102: U9101.3 205.82,34.38 206.95,35.51 207.84,35.51 208.22,35.89 v2(208.38,35.89) R9120.1
TPM_GPIO3: length 1.6
  TOP w0.089: TP9101.1 206.66,35.88 U9101.6
TPM_GPIO4: length 3.2
  TOP w0.102: R9122.1 204.72,39.02 v2(204.24,38.53) 203.88,38.18 202.97,38.18 202.87,38.08 U9101.13
TPM_ID: length 27.9
  TOP w0.102: v1(127.26,66.97) 127.26,66.97 127.92,66.31 127.92,65.67 128.42,65.18 128.42,63.66 130.6,61.47 130.6,59.78 133.14,57.24 133.14,56.59 135.3,54.44 135.3,52.63 134.77,52.1 134.77,51.3 134.33,50.87 v2(134.33,50.83) 134.3,50.83 134.07,50.6 132.94,50.6 R1910.2 132.2,49.96 131.77,49.53 131.77,49.35 131.77,49.35 131.77,48.99 131.77,48.99 131.77,48.8 132.02,48.55 132.02,47.88 R1911.1
  BOTTOM w0.089: v1(127.26,66.97) 127.26,67.77 126.9,68.14 126.9,68.59 CPU1.CK25
TPM_PP: length 2.9
  TOP w0.089: TP9104.1 207.59,37.24 207.23,36.88 206.55,36.88 206.04,36.38 U9101.7
TPM_SPI_IRQ#: length 95.1
  TOP w0.102: v1(195.45,36.72) 195.45,37.17 v2(195.63,37.35) 195.82,37.54 196.77,37.54 197.15,37.92 R9154.2
  L6 w0.102: v1(124.44,72.67) 124.44,71.72 125.07,71.1 127.16,71.1 128.9,69.36 128.9,68.26 130.74,66.42 133.64,66.42 134.39,67.17 135.04,67.17 135.41,66.8 135.41,66.67 136.83,65.26 139.95,65.26 141.19,64.01 141.19,59.62 142.01,58.81 142.01,57.5 154.62,44.88 159.05,44.88 159.46,45.29 160.5,45.29 160.65,45.14 163.21,45.14 163.71,44.64 175.47,44.64 180.16,39.96 182.92,39.96 183.46,39.42 193.24,39.42 195.45,37.22 v1(195.45,36.72)
  BOTTOM w0.102: v1(124.44,72.67) 124.45,72.66 124.45,72.59 124.72,72.32 CPU1.CF20
TS#_DIMM0_1: length 3.2
  TOP w0.127: v1(65.32,18.37) 65.12,18.57 v2(65.12,19.1) R1215.2
  BOTTOM w0.127: v1(65.32,18.37) 65.13,18.55 DM1.134
TS#_DIMM1_1: length 3.7
  TOP w0.127: R1312.2 142.69,20.98 v2(142.69,21.41) 142.41,21.69 v1(142.14,21.69)
  BOTTOM w0.127: DM2.134 v1(142.14,21.69)
TYPEC_DCIN_EN#: length 51.9
  TOP w0.102: U2401.63 33.58,50.47 34.13,49.91 34.83,49.91 v1(34.85,49.9) ; Q7406.2 30.73,81.82 30.42,81.51 30.42,80.9 30.32,80.8 v2(30.32,80.29) 30.8,80.29 v1(31.11,80.6)
  L4 w0.102: v1(31.11,80.6) 31.11,82.37 v1(31.79,83.06)
  L6 w0.102: v1(34.85,49.9) 34.85,50.44 32.4,52.89 32.4,54.59 31.67,55.32 31.4,55.32 29.92,56.81 29.92,57.33 29.05,58.19 29.05,61.65 30.42,63.02 30.42,64.67 28.75,66.35 28.75,68.28 29.85,69.38 29.85,74.96 29.34,75.47 28.82,75.47 26.66,77.62 26.66,78.29 28.26,79.89 29.22,79.89 29.93,80.6 v1(31.11,80.6)
  BOTTOM w0.102: Q7407.2 30.02,84.18 30.42,84.58 30.96,84.58 31.39,84.15 31.39,83.47 v1(31.79,83.06) ; R7428.1 30.65,81.05 v1(31.11,80.6)
TYPEC_SMBCLK: length 28.4
  TOP w0.089: U2401.91 33.21,39.31 33.42,39.53 33.42,39.63 v1(33.45,39.65) ; RN2413.4 25.88,53.49 25.67,53.7 v2(25.09,53.7) 25.09,51.89 25.97,51.02 v1(26.03,51.02)
  L3 w0.114: v1(32.16,50.84) 32.16,50.51 31.69,50.04 31.69,50.02 31.54,49.86 31.54,48.95 31.69,48.8 31.69,48.77 31.87,48.59 31.87,48.16 31.9,48.14 31.9,46 31.87,45.98 31.87,42.42 31.88,42.41 31.88,41.25 31.92,41.2 31.92,41.18 v1(33.45,39.65)
  L6 w0.089: v1(26.03,51.02) 26.05,51.04 26.05,51.34 26.59,51.87 29,51.87 30.33,50.54 31.86,50.54 v1(32.16,50.84)
  BOTTOM w0.089: v1(26.03,51.02) 25.53,51.02 R2468.1 25.05,50.16 Q2417.1
TYPEC_SMBCLK_Q: length 103.6
  TOP w0.089: v1(25.24,48.84) 24.86,48.46 v2(24.86,48.42) ; v1(77.61,95.79) 77.62,95.79 77.67,95.79 77.75,95.88 77.75,97.02 U7204.B5
  L3 w0.114: v1(77.61,95.79) 76.72,96.68 75.06,96.68 73.22,98.51 73.22,98.51 73.04,98.68 70.5,98.68 70.48,98.66 70.07,98.66 70.02,98.61 69.97,98.61 68.29,96.93 64.81,96.93 63.88,95.99 50.77,95.99 50.34,95.56 47.71,95.56 46.93,96.34 43.96,96.34 43.96,96.34 41.52,96.34 40.43,95.25 40.43,93.63 37.74,90.93 37.74,89.69 33.4,85.35 33.4,83.85 33.41,83.84 33.41,83.74 33.45,83.69 33.45,83.55 33.57,83.43 33.57,82.48 31.76,80.67 31.76,77.57 30.7,76.51 30.29,76.51 28.26,74.49 28.26,69.73 27.42,68.89 27.42,66.37 29,64.8 29.06,64.8 30.02,63.84 30.02,63.47 28.49,61.94 28.49,59.07 25.52,56.09 25.52,54.56 24.51,53.55 24.51,50.32 25.24,49.58 v1(25.24,48.84)
  BOTTOM w0.089: Q2417.6 25.61,48.5 25.29,48.19 24.89,48.19 24.76,48.31 24.76,49.38 R2468.2 25.04,49.48 25.24,49.28 v1(25.24,48.84) ; R7218.1 76.88,96.52 v1(77.61,95.79)
TYPEC_SMBDA: length 26.2
  TOP w0.089: U2401.89 30.82,40.11 v1(30.67,39.96) ; v1(31.07,50.96) 30.89,50.78 28.43,50.78 27.25,51.96 27.25,53.6 26.84,54 v2(26.69,54) 26.55,53.86 RN2413.3
  L3 w0.114: v1(31.07,50.96) 31.07,50.43 30.98,50.35 30.98,50.32 30.83,50.17 30.83,48.64 30.98,48.49 30.98,48.47 31.16,48.29 31.16,47.86 31.19,47.83 31.19,47.17 31.16,47.15 31.16,46.99 31.19,46.97 31.19,46.31 31.16,46.28 31.16,40.92 31.19,40.9 31.19,40.48 v1(30.67,39.96)
  BOTTOM w0.089: v1(31.07,50.96) 30.99,50.88 29.41,50.88 28.7,50.16 28.7,48.75 28.39,48.44 R2467.1 28.12,48.5 Q2417.4
TYPEC_SMBDA_Q: length 97.2
  TOP w0.089: v1(76.96,95.81) 76.96,95.84 77.49,96.37 77.49,96.75 U7204.A5
  L3 w0.114: v1(76.96,95.81) 76.47,96.29 74.9,96.29 73.01,98.18 70.08,98.18 68.32,96.42 66.19,96.42 65.75,95.99 64.48,95.99 64.1,95.61 50.92,95.61 50.51,95.2 47.55,95.2 46.8,95.94 41.96,95.94 40.81,94.8 40.81,93.47 38.12,90.78 38.12,89.54 33.77,85.2 33.77,84 33.94,83.84 33.94,82.31 32.97,81.34 32.97,78.16 31.74,76.94 31.74,76.36 29.98,74.59 29.98,70.41 28.37,68.8 28.37,67.39 28.23,67.26 28.23,66.09 28.89,65.43 28.95,65.43 30.58,63.8 30.58,61.48 28.87,59.77 28.87,58.91 27.9,57.93 27.9,56.52 28.14,56.28 28.14,55.61 26.69,54.16 26.69,51.01 v1(27.73,49.96)
  BOTTOM w0.089: Q2417.3 27.54,50.16 v1(27.73,49.96) 28.19,49.51 R2467.2 ; v1(76.96,95.81) v2(76.51,96.26) 76.3,96.47 R7219.1
U5503_OUT: length 10.6
  TOP w0.508: v1(62.27,90.45) 62.27,90.05 v2(62.02,89.79) 61.64,89.41 R5548.1 59.86,89.41 R5560.1
  BOTTOM w0.508: U5502.5 63.15,89.58 v1(62.27,90.45) 62.27,92.33 62.15,92.46 62.15,93.65 62.96,94.47 R5558.2 R5559.2
UART1_CTS#: length 1.2
  TOP w0.102: TP2002.1 125.32,75.54 v1(125.01,75.85)
  BOTTOM w0.102: v1(125.01,75.85) 125.37,76.21 CPU1.CG14
UART1_RTS#: length 1.4
  TOP w0.102: v1(124.3,76.78) 124.45,76.63 TP2001.1
  BOTTOM w0.102: v1(124.3,76.78) 124.3,76.84 124.4,76.94 124.4,77 CPU1.CF12
UART_2_CRXD_DTXD: length 229.4
  TOP w0.102: v1(31.57,52.2) 31.34,52.43 31.34,52.56 R6803.1 ; R2048.2 130.09,77.22 131.13,77.22 132.14,76.22 132.77,76.22 v1(133,76.44) ; v1(169.97,37.74) 169.97,37.29 v2(170.12,37.14)
  L3 w0.102: v1(133,76.44) 133,75.7 133.81,74.88 133.81,74.38 138.52,69.67 146.38,69.67 147.04,70.34 151.98,70.34 154.2,68.12 154.2,56.99 155.68,55.5 157.77,55.5 161.23,52.04 161.23,49.76 167.56,43.44 167.56,40.8 169.97,38.38 v1(169.97,37.74) ; v1(35.36,40.16) 34.18,41.33 34.18,43.18 34.23,43.23 34.23,43.62 33.96,43.89 32.96,43.89 32.7,44.15 32.7,48.9 32.48,49.13 32.48,49.69 33.12,50.32 33.12,51.49 33.14,51.51 33.14,51.87 32.89,52.12 32.86,52.12 32.43,52.56 31.92,52.56 v1(31.57,52.2)
  BOTTOM w0.102: v1(133,76.44) 132.77,76.22 132.12,76.22 131.3,76.92 130.45,77 129.95,77.25 CPU1.CR12 ; v1(169.97,37.74) 169.23,37.01 169.23,36.36 166.99,34.11 154.02,34.11 153.26,33.35 72.71,33.35 68.97,37.09 63.67,37.09 63.21,36.63 59.26,36.63 58.07,37.82 57.13,37.82 56.42,38.53 53.55,38.53 53.27,38.81 45.69,38.81 45.36,39.14 45.36,39.5 45.13,39.73 43.56,39.73 43.28,40.01 41.04,40.01 40.48,39.45 36.07,39.45 v1(35.36,40.16)
UART_2_CRXD_DTXD_CON: length 4.4
  TOP w0.102: R6803.2 30.75,54 30.24,54 v1(30.1,54.14) 30.1,54.16 30.91,54.97 v2(31.31,54.97)
  BOTTOM w0.102: DBG1.14 29.59,54.65 v1(30.1,54.14)
UART_2_CTXD_DRXD: length 230.9
  TOP w0.102: v1(170.61,37.97) v2(170.61,38.71) ; R2049.2 129.55,76.6 130.2,76.6 130.28,76.68 130.28,76.77 130.5,76.99 131.08,76.99 132.05,76.02 133.47,76.02 v1(133.52,76.08) ; v1(32.2,52.12) 32.2,52.25 31.79,52.66 R6802.1
  L3 w0.102: v1(170.61,37.97) 170.61,38.18 167.76,41.02 167.76,43.54 161.44,49.86 161.44,52.15 157.88,55.71 155.77,55.71 154.45,57.02 154.45,68.53 152.44,70.54 146.96,70.54 146.3,69.88 138.6,69.88 134.28,74.19 134.28,75.32 v1(133.52,76.08) ; v1(32.2,52.12) 32.2,51.49 32.61,51.08 32.61,50.42 32.07,49.89 32.07,49.86 31.92,49.71 31.92,49.1 32.07,48.95 32.07,48.92 32.25,48.75 32.25,48.31 32.28,48.29 32.28,45.85 32.25,45.82 32.25,42.57 34.73,40.09 v1(34.73,40.06)
  BOTTOM w0.102: v1(34.73,40.06) 34.84,40.06 35.17,39.73 35.33,39.73 35.81,39.25 40.56,39.25 41.12,39.8 43.15,39.8 44.14,38.81 45.03,38.81 45.13,38.71 45.49,38.71 45.59,38.61 53.13,38.61 53.41,38.33 53.44,38.33 53.46,38.31 53.64,38.31 53.66,38.33 56.33,38.33 57.04,37.62 57.98,37.62 59.18,36.43 64.97,36.43 65.42,36.88 68.89,36.88 72.62,33.15 153.34,33.15 154.1,33.91 167.07,33.91 169.64,36.48 169.64,36.68 170.61,37.65 v1(170.61,37.97) ; CPU1.CP12 129.89,77.04 130.2,76.88 130.67,76.71 131.21,76.71 131.9,76.02 133.47,76.02 v1(133.52,76.08)
UART_2_CTXD_DRXD_CON: length 4
  TOP w0.102: R6802.2 31.79,53.93 v1(31.34,54.38) 31.34,54.39 32.17,55.22 v2(32.53,55.22)
  BOTTOM w0.102: v1(31.34,54.38) 31.34,54.49 30.59,55.24 DBG1.13
UPD1_SMBINT#: length 96.6
  TOP w0.102: v1(46.5,51.49) 46.5,51.49 46.5,50.47 46.16,50.13 46.16,49.8 46.25,49.71 U2401.32 ; 77.08,93.3 77.03,93.25 v2(77.03,92.43) 77.03,91.62 78.32,90.33 81.99,90.33 v1(83.46,91.8) 84.22,92.56 R7239.2
  L3 w0.102: v1(46.5,51.49) 45.79,51.49 44.75,52.53 44.75,52.73 44.39,53.09 44.22,53.09 43.61,53.7 43.61,55.3 43.25,55.65 43.25,57.23 43.12,57.36 43.11,57.36 42.22,58.24 41.62,58.24 41.4,58.02 40.47,58.02 40,58.49 40,59.18 40.52,59.71 40.52,63.85 38.2,66.17 38.2,66.55 39.69,68.05 39.69,71.12 42.35,73.78 42.35,74.72 43.25,75.62 43.25,76.71 42.77,77.19 42.77,78.95 45.71,81.89 45.71,84.92 50.23,89.44 55.47,89.44 55.9,89.87 59.51,89.87 59.61,89.97 68.17,89.97 68.45,90.25 81.91,90.25 v1(83.46,91.8)
USB1_CC1: length 87.7
  TOP w0.102: U7204.L9 75.51,101.99 74.95,102.54 74.95,103.13 74.54,103.53
  TOP w0.203: v1(12.08,87.99) 11.45,87.35 10.81,87.35 10.71,87.25 10.56,87.25 10.36,87.05 ED7306.2
  TOP w0.305: 74.54,103.53 73.37,104.7 R7225.2 73.2,104.85 72.56,105.49 C7220.1 72.38,105.9 72.41,105.92 72.41,106.37 71.63,107.15 v2(71.1,107.15) v1(69.87,108.38)
  L6 w0.305: v1(69.87,108.38) 69.44,108.38 67.84,106.79 67.84,105.9 61.71,99.77 36.44,99.77 36.06,100.15 23.9,100.15 23.5,99.75 18.51,99.75 15.51,96.75 15.51,95.86 14.65,95 14.65,94.29 13.1,92.74 13.1,89.18 12.08,88.17 v1(12.08,87.99) 11.5,87.4 9.31,87.4 8.44,88.27 v1(8.27,88.27)
  BOTTOM w0.102: USB1.A5 7.32,88.25 7.51,88.45 8.1,88.45 v1(8.27,88.27)
USB1_CC2: length 87.8
  TOP w0.203: U7204.L10 75.01,101.85 74.44,102.42 ; v1(11.47,88.19) 11.22,88.19 10.59,87.56 10.33,87.56 9.95,87.18 ED7306.1
  TOP w0.305: v1(68.68,103.5) 69.15,103.5 v2(69.51,103.86) 69.51,103.96 70.28,104.73 C7221.1 70.78,103.99 R7224.2 70.73,103.86 71.22,103.38 73.48,103.38 74.44,102.42
  L4 w0.305: v1(68.68,103.5) 68.65,103.52 65.03,103.52 64.15,102.64 61.84,102.64 60.62,101.42 v1(60.62,100.74)
  L6 w0.102: USB1.B5 5.54,90.61 6.02,91.09
  L6 w0.305: 6.02,91.09 7.94,91.09 7.96,91.11 8.38,91.11 8.41,91.09 10.81,91.09 11.47,90.43 v1(11.47,88.19) 12.67,89.39 12.67,92.93 14.21,94.47 14.21,95.19 15.08,96.07 15.08,96.95 18.31,100.18 23.14,100.18 23.55,100.59 36.32,100.59 36.7,100.2 60.09,100.2 v1(60.62,100.74)
USB1_PN1_R: length 9.5
  TOP w0.102: v1(20.26,34.62) 19.4,33.76 R3608.1
  BOTTOM w0.102: 21.95,38.72 21.95,38.45 21.74,38.23 21.74,37.82 21.28,37.37 20.88,37.37 20.04,36.52 20.04,34.83 v1(20.26,34.62) 20.26,34.62 20.39,34.5 U3601.11 ; 21.95,38.72 v2(22.15,38.72) ; 21.95,38.72 21.95,39.65 EL3501.1
USB1_PP1_R: length 9.5
  TOP w0.102: R3607.1 18.64,33.45 19.6,34.42 v1(19.6,34.6)
  BOTTOM w0.102: 19.81,36.37 19.81,36.62 20.79,37.59 21.18,37.59 21.51,37.92 21.51,38.32 21.72,38.54 21.72,39.91 EL3501.4 ; 19.81,36.37 19.81,34.82 v1(19.6,34.6) 19.65,34.6 19.89,34.36 U3601.10 ; 19.81,36.37 v2(19.63,36.37)
USB1_SBU1: length 42.5
  TOP w0.203: 30.14,73.28 30.21,73.22 30.21,71.85 30.01,71.65 U7301.27
  TOP w0.254: ED7303.2 32.61,75.59 32.18,76.02 30.62,76.02 30.37,75.78 v1(30.37,75.64) 30.14,75.42 30.14,73.28 ; v1(12.11,90.99) 12.11,90.78 12.52,90.38 R7308.1 11.27,90.17 11.04,90.4 v2(9.59,90.4) 8.86,90.4 8.27,89.81 v1(8.27,89.69)
  L4 w0.254: v1(14.78,83.01) 14.07,83.72 14.07,84.25 12.87,85.45 12.87,90.22 v1(12.11,90.99)
  BOTTOM w0.178: v1(8.27,89.69) 8.1,89.51 7.51,89.51 7.27,89.75 USB1.A8
  BOTTOM w0.254: v1(14.78,83.01) 16.43,83.01 19.35,80.09 21.91,80.09 24.12,77.88 24.12,77.86 26.01,75.98 27.85,75.98 28.44,75.39 29.31,75.39 29.61,75.69 30.32,75.69 v1(30.37,75.64)
USB1_SBU2: length 63.6
  TOP w0.203: 30.52,73.56 30.54,73.55 30.54,71.71 30.07,71.24 U7301.26
  TOP w0.254: v1(31.95,75.52) 31.97,75.49 31.97,75.29 32.23,75.03 ED7303.1 32.61,74.35 R7309.1 32.11,74.25 31.75,74.6 30.78,74.6 30.52,74.35 30.52,73.56 ; v1(12.97,68.28) v2(13.7,69) 13.99,69.29 15.24,69.29 17.32,67.21 18.46,67.21 18.92,66.75 18.92,66.25 19.17,65.99 19.71,65.99 20.06,65.64 20.06,65.38 21.22,64.21 21.44,64.21 22.15,63.5 22.58,63.5 23.04,63.05 23.51,63.05 24.05,62.51 24.58,62.51 v1(24.64,62.45)
  L4 w0.254: v1(24.64,62.45) 25.15,62.45 27.05,64.34 27.05,67.9 32.05,72.9 32.05,75.42 v1(31.95,75.52)
  L6 w0.102: USB1.B8 5.81,87
  L6 w0.254: v1(12.97,68.28) 13,68.3 13,79.07 8.81,83.26 8.81,85.42 8.43,85.8 8.02,85.8 7.44,86.39 6.66,86.39 6.25,86.79 6.02,86.79 5.81,87
USB1_SSRX_C_N1: length 4.6
  TOP w0.102: C7332.1 27.43,76.62 27.73,76.32 27.73,76.02 28.32,75.43 28.32,73.25 28.12,73.06 U7301.31
USB1_SSRX_C_N2: length 3.7
  TOP w0.102: C7334.1 25.19,75.75 25.19,75.42 24.75,74.98 24.75,73.29 24.92,73.12 U7301.39
USB1_SSRX_C_P1: length 4.5
  TOP w0.102: 28.54,75.39 28.54,75.53 27.96,76.11 27.96,76.46 C7331.1 ; 28.54,75.39 v2(28.75,75.39) ; 28.54,75.39 28.54,73.16 28.52,73.14 U7301.30
USB1_SSRX_C_P2: length 4
  TOP w0.102: 24.52,73.59 24.52,75.07 24.96,75.51 24.96,75.85 24.86,75.95 C7333.1 ; 24.52,73.59 U7301.40 ; 24.52,73.59 v2(24.33,73.59)
USB1_SSRX_CMC_N1: length 17.2
  TOP w0.102: R7313.1 16.3,85.78 16.55,86.03 16.77,86.03 16.94,85.86 16.94,85.01 17.36,84.59 17.36,83.66 18.21,82.81 20.31,82.81 20.72,82.4 23.21,82.4 24.35,81.26 24.35,81.04 25.91,79.48 25.91,79.2 26.5,78.61 26.59,78.61 ; 26.59,78.61 27.23,78.61 27.55,78.29 27.55,78.17 27.63,78.09 27.63,77.83 C7332.2 ; 26.59,78.61 v2(26.59,78.44)
USB1_SSRX_CMC_N2: length 10.6
  TOP w0.102: C7334.2 25.36,76.86 21.55,80.67 17.85,80.67 17.7,80.83 17.16,80.83 17.01,80.98 R7315.1
USB1_SSRX_CMC_P1: length 17.6
  TOP w0.102: 20.26,83.04 20.41,83.04 20.82,82.63 23.3,82.63 24.58,81.35 24.58,81.13 26.14,79.57 26.14,79.29 26.59,78.84 27.33,78.84 27.78,78.39 27.78,78.26 27.86,78.18 27.86,77.78 C7331.2 ; 20.26,83.04 18.3,83.04 17.58,83.75 17.58,84.68 17.16,85.1 17.16,85.96 16.86,86.26 16.58,86.26 16.3,86.54 R7312.1 ; 20.26,83.04 v2(20.26,83.24)
USB1_SSRX_CMC_P2: length 10.2
  TOP w0.102: R7314.1 16.76,80.22 17.14,80.6 17.6,80.6 17.76,80.44 21.15,80.44 ; C7333.2 24.63,77.27 21.46,80.44 21.15,80.44 ; 21.15,80.44 v2(21.15,80.29)
USB1_SSRX_CON_N1: length 12.6
  TOP w0.102: v2(11.32,86.11) 11.44,86.22 ; 11.44,86.22 11.55,86.11 12.46,86.11 12.57,86 ED7301.2 ED7301.9 14.11,86 14.19,86.08 14.9,86.08 R7313.2 ; 11.44,86.22 11.32,86.35 11.32,86.53 v1(11,86.85)
  L4 w0.102: USB1.B10 5.29,87.02 7.03,87.02 8.07,85.98 10.89,85.98 11.32,86.41 11.32,86.53 v1(11,86.85)
USB1_SSRX_CON_N2: length 21
  TOP w0.102: v1(11.13,83.57) 10.84,83.28 10.84,82.07 11.08,81.83 ; 11.08,81.83 12.14,80.77 13.18,80.77 13.32,80.91 ED7302.4 ED7302.7 15.6,80.91 R7315.2 ; 11.08,81.83 v2(11.22,81.97)
  L3 w0.102: v1(11.13,83.57) 10.79,83.23 10.79,82.7 10.59,82.5 9.74,82.5 8.96,83.28 8.96,83.86 9.49,84.39 9.49,88.78 v1(9.15,89.12)
  BOTTOM w0.102: USB1.A10 7.16,90.75 7.29,90.88 7.72,90.88 7.92,91.09 8.76,91.09 9.49,90.35 9.49,89.46 v1(9.15,89.12)
USB1_SSRX_CON_P1: length 12.4
  TOP w0.102: v1(11.86,86.85) 11.54,86.53 11.54,86.44 11.65,86.34 12.36,86.34 12.53,86.5 ED7301.1 ED7301.10 14.08,86.5 14.24,86.34 14.88,86.34 15.08,86.54 R7312.2
  L4 w0.089: 11.53,86.52 v1(11.86,86.85) ; USB1.B11 5.34,86.82
  L4 w0.102: 11.53,86.52 11.53,86.33 10.98,85.78 7.99,85.78 6.95,86.82 5.34,86.82
USB1_SSRX_CON_P2: length 21.2
  TOP w0.102: R7314.2 15.47,80.41 ED7302.6 ED7302.5 13.32,80.41 13.18,80.55 12.04,80.55 10.61,81.98 10.61,83.44 10.48,83.57 v1(10.27,83.57)
  L3 w0.102: v1(10.27,83.57) 10.59,83.25 10.59,82.78 10.51,82.71 9.82,82.71 9.16,83.37 9.16,83.77 9.7,84.31 9.7,88.8 v1(10.01,89.12)
  BOTTOM w0.102: 9.23,90.94 9.72,90.45 9.72,89.41 v1(10.01,89.12) ; 9.23,90.94 v2(9.35,91.06) ; 9.23,90.94 8.85,91.32 7.82,91.32 7.62,91.11 7.36,91.11 7.32,91.16 7.22,91.25 USB1.A11
USB1_SSTX_C_N1: length 1.6
  TOP w0.102: C7323.1 27.12,73.81 27.02,73.71 27.02,73.16 26.92,73.06 U7301.34
USB1_SSTX_C_N2: length 1.7
  TOP w0.102: U7301.36 26.12,73.01 26.05,73.08 26.05,73.84 C7322.1
USB1_SSTX_C_P1: length 1.9
  TOP w0.102: C7324.1 27.78,74.15 27.25,73.61 27.25,73.14 27.32,73.06 U7301.33
USB1_SSTX_C_P2: length 1.7
  TOP w0.102: U7301.37 25.72,72.98 25.83,73.08 25.83,73.92 C7321.1
USB1_SSTX_CMC_N1: length 17.5
  TOP w0.102: R7311.1 16.33,84.48 16.56,84.48 16.71,84.34 16.71,83.4 17.93,82.17 18.66,82.17 ; 18.66,82.17 v2(18.66,81.99) ; 18.66,82.17 20.03,82.17 20.44,81.77 22.07,81.77 23.67,80.17 24.25,80.17 25.28,79.14 25.28,78.66 26.61,77.33 26.61,76.24 27.45,75.4 27.45,75.16 27.35,75.06 C7323.2
USB1_SSTX_CMC_N2: length 14.2
  TOP w0.102: 26.21,75.87 26.21,75.21 C7322.2 ; 26.21,75.87 26.21,77.14 25.22,78.13 25.01,78.13 21.83,81.31 18.12,81.31 16.88,82.55 R7317.1 ; 26.21,75.87 v2(26.36,75.87)
USB1_SSTX_CMC_P1: length 17.7
  TOP w0.102: v2(22.88,81.56) 22.74,81.42 ; 22.74,81.42 22.17,81.99 20.54,81.99 20.13,82.4 18.03,82.4 16.94,83.49 16.94,84.43 16.38,84.99 R7310.1 ; 22.74,81.42 23.77,80.39 24.35,80.39 25.51,79.24 25.51,78.76 26.84,77.42 26.84,76.33 27.68,75.49 27.68,75.26 C7324.2
USB1_SSTX_CMC_P2: length 13.9
  TOP w0.102: 17.75,81.36 17.14,81.97 16.71,81.97 R7316.1 ; 17.75,81.36 v2(17.65,81.26) ; 17.75,81.36 18.03,81.08 21.74,81.08 24.91,77.9 25.12,77.9 25.98,77.05 25.98,75.34 25.7,75.06 C7321.2
USB1_SSTX_CON_N1: length 12.3
  TOP w0.102: v1(11.02,85.3) 11.32,85.3 11.42,85.19 11.42,84.72 11.54,84.6 ; R7311.2 14.98,84.23 14.57,84.64 14.22,84.64 14.08,84.5 ED7301.6 ED7301.5 12.58,84.5 12.44,84.63 12.18,84.63 12.03,84.48 11.66,84.48 11.54,84.6 ; 11.54,84.6 v2(11.4,84.46)
  BOTTOM w0.102: v1(11.02,85.3) 11.35,84.97 11.35,84.41 11.17,84.23 10.03,84.23 8.86,85.4 8.86,85.74 7.5,87.1 7.31,87.1 7.16,87.25 USB1.A3
USB1_SSTX_CON_N2: length 21.5
  TOP w0.102: v1(12.55,83.57) 12.39,83.4 12.39,83.01 ; v2(12.54,83.01) 12.39,83.01 ; 12.39,83.01 12.39,82.55 12.72,82.22 13.13,82.22 13.32,82.41 ED7302.1 ED7302.10 15.52,82.41 R7317.2
  L3 w0.102: USB1.B3 5.31,91 6.7,91 7.64,90.06 7.64,86.76 8.78,85.62 8.78,84.36 8.35,83.93 8.35,83.03 9.54,81.84 11.66,81.84 12.28,82.46 12.28,83.3 v1(12.55,83.57)
USB1_SSTX_CON_P1: length 11.9
  TOP w0.102: v1(11.88,85.3) 11.75,85.3 11.65,85.19 11.65,84.81 11.75,84.71 11.93,84.71 12.08,84.86 12.47,84.86 12.6,85 ED7301.4 ED7301.7 14.08,85 14.22,84.86 15.08,84.86 R7310.2
  BOTTOM w0.102: 11.58,84.43 11.58,84.31 11.26,84 9.93,84 8.63,85.3 8.63,85.65 7.41,86.87 7.28,86.87 7.16,86.75 USB1.A2 ; 11.58,84.43 v2(11.73,84.43) ; 11.58,84.43 11.58,84.99 v1(11.88,85.3)
USB1_SSTX_CON_P2: length 21.7
  TOP w0.102: v2(12.82,81.82) 12.82,81.99 ; 12.82,81.99 12.62,81.99 12.16,82.46 12.16,83.34 11.93,83.57 v1(11.8,83.57) ; 12.82,81.99 13.23,81.99 13.32,81.91 ED7302.2 ED7302.9 15.55,81.91 R7316.2
  L3 w0.102: v1(11.8,83.57) 12.08,83.3 12.08,82.55 11.58,82.04 9.62,82.04 8.55,83.11 8.55,83.85 8.99,84.28 8.99,85.7 7.84,86.85 7.84,90.15 6.79,91.2 5.31,91.2 USB1.B2
USB1_USB20_CON_N: length 27.8
  BOTTOM w0.102: v2(22.17,42.37) 22.04,42.24 ; 22.04,42.24 22.27,42.01 22.27,40.85 22.35,40.77 EL3501.2 ; 22.04,42.24 21.88,42.4 21.34,42.4 21.28,42.34 19.75,42.34 19.53,42.56 18.83,42.56 18.26,41.99 17.29,41.99 16.73,41.43 16.73,40.62 16.85,40.51 ED3502.1 16.85,39.99 17.1,39.75 17.1,39.27 16.62,38.8 16.62,38.45 16.37,38.19 16.37,37.1 16.62,36.84 16.62,36 13.13,32.51 13.13,25.61 12.69,25.17 12.28,25.17 12.15,25.3 USB3.2
USB1_USB20_CON_P: length 27.2
  BOTTOM w0.102: 19.93,42.12 21.38,42.12 21.43,42.17 21.79,42.17 22.04,41.91 22.04,41.24 21.58,40.78 21.58,40.77 EL3501.3 ; 19.93,42.12 19.66,42.12 19.44,42.33 18.93,42.33 18.35,41.76 17.39,41.76 16.96,41.34 16.96,40.93 17.33,40.57 17.33,39.18 16.85,38.7 ED3502.6 16.85,35.91 13.35,32.41 13.35,25.51 12.79,24.95 12.25,24.95 12.15,24.84 USB3.3 ; 19.93,42.12 v2(19.93,41.94)
USB1_USB20_N: length 200.1
  TOP w0.102: v2(20.03,31.45) 19.9,31.32 ; 19.9,31.32 20.14,31.09 20.14,29.14 19.93,28.93 19.55,28.93 v1(19.35,28.73) ; 19.9,31.32 19.4,31.82 R3608.2
  L6 w0.089: v1(111.83,96.83) 111.57,96.57 110.62,96.57 110.32,96.27 107.92,96.27 107.44,96.75 104.4,96.75 103.95,96.31 94.58,96.31 94.02,95.75 81.89,95.75 80.59,97.04 74.39,97.04 73.21,98.22 68.41,98.22 67.73,98.91 64.37,98.91 62.52,97.07 41.04,97.07 39.46,95.49 32.1,95.49 30.73,94.12 28.74,94.12 22.79,88.17 22.79,83.58 19.91,80.7 16.98,80.7 14.79,78.52 14.79,70.1 16.48,68.41 16.48,66.72 15.36,65.6 15.36,57.08 17.41,55.03 17.41,46.56 19.5,44.46 19.5,40.9 17.98,39.37 17.98,38.1 17.22,37.34 17.22,36.12 18.63,34.71 18.63,32.97 18.04,32.39 18.04,29.72 18.81,28.95 19.13,28.95 v1(19.35,28.73)
  BOTTOM w0.076: 125.7,86.15 125.68,86.14 125.65,86.14 124.5,84.99 124.5,84.22 124.49,84.18 124.49,84.14 124.47,84.11 124.44,84.05 124.44,83.83 124.44,83.83 124.46,83.78 124.48,83.74 124.48,83.53 124.47,83.51 124.47,83.46 124.45,83.42 124.42,83.36 124.42,83.35 124.42,83.31 124.41,83.29 124.39,83.21 CPU1.CE3
  BOTTOM w0.102: U3601.2 20.39,30.53 20.26,30.41 20.26,29.42 19.58,28.73 v1(19.35,28.73) ; v1(111.83,96.83) 114.19,96.83 114.52,96.5 122.45,96.5 123.44,95.51 123.44,93.4 126.75,90.09 126.75,87.2 125.7,86.15
USB1_USB20_P: length 200.5
  TOP w0.102: v2(19.76,30.18) 19.91,30.18 ; 19.91,30.18 19.91,30.99 18.64,32.26 R3607.2 ; 19.91,30.18 19.91,29.23 19.84,29.16 19.69,29.16 19.35,29.5 v1(19.35,29.52)
  L6 w0.089: v1(19.35,29.52) 19.35,29.29 19.2,29.14 18.89,29.14 18.23,29.8 18.23,32.31 18.82,32.9 18.82,34.79 17.41,36.2 17.41,37.26 18.17,38.02 18.17,39.29 19.69,40.82 19.69,44.54 17.6,46.64 17.6,55.11 15.55,57.16 15.55,65.52 16.67,66.64 16.67,68.49 14.98,70.18 14.98,78.44 17.06,80.51 19.99,80.51 22.98,83.5 22.98,88.09 28.82,93.93 30.8,93.93 32.18,95.3 39.54,95.3 41.12,96.88 62.6,96.88 64.44,98.72 67.65,98.72 68.33,98.03 73.13,98.03 74.31,96.85 80.51,96.85 81.81,95.56 94.1,95.56 94.66,96.12 104.03,96.12 104.48,96.56 107.36,96.56 107.84,96.08 110.4,96.08 110.7,96.38 111.74,96.38 111.83,96.29 v1(111.83,96)
  BOTTOM w0.076: 125.54,86.31 125.52,86.3 125.52,86.26 124.33,85.07 124.33,84.25 124.31,84.21 124.31,84.21 124.26,84.08 124.26,83.81 124.27,83.78 124.29,83.73 124.29,83.72 124.3,83.7 124.3,83.56 124.29,83.53 124.29,83.51 124.29,83.51 124.26,83.43 124.25,83.42 124.23,83.37 124.1,83.31 123.92,83.29 123.79,83.19 123.74,82.86 CPU1.CE4
  BOTTOM w0.102: v1(19.35,29.52) 19.35,29.24 19.43,29.16 19.68,29.16 20.03,29.51 20.03,30.41 19.89,30.55 U3601.3 ; v1(111.83,96) 112.13,96 112.21,96.09 112.21,96.45 112.36,96.6 114.09,96.6 114.43,96.27 122.35,96.27 123.21,95.41 123.21,93.31 126.52,89.99 126.52,87.3 125.54,86.31
USB1_USB30_RX_CON_N: length 11
  TOP w0.102: R3504.2 19.16,25.27 ED3501.1 ED3501.10 16.76,25.27 16.62,25.4 16.45,25.4 16.11,25.06 ; USB3.5 10.65,21.61 11.73,22.68 13.74,22.68 16.11,25.06 ; 16.11,25.06 v2(16.25,24.92)
USB1_USB30_RX_CON_P: length 10.7
  TOP w0.102: 15.19,24.46 13.64,22.91 11.63,22.91 11.2,22.48 10.94,22.48 10.65,22.77 USB3.6 ; 15.19,24.46 v2(15.08,24.56) ; 15.19,24.46 16.36,25.63 16.61,25.63 16.74,25.77 ED3501.9 ED3501.2 19.23,25.77 R3503.2
USB1_USB30_RX_N: length 179
  TOP w0.102: v1(21.81,25.07) 21.51,25.38 20.47,25.38 R3504.1
  L6 w0.089: v1(121.9,81.24) 121.86,81.28 121.86,82.16 120.62,83.4 110.16,83.4 108.35,85.21 108.35,89.82 105.83,92.34 104.64,92.34 104.16,92.83 74.75,92.83 74.24,93.34 64,93.34 63.59,93.75 54,93.75 53.25,93 48.54,93 47.33,91.79 46.38,91.79 45.19,90.59 38.13,90.59 36.34,88.8 33.95,88.8 32.84,87.68 31.52,87.68 26.92,83.09 26.92,82.39 26.42,81.9 26.42,81.7 25.2,80.48 24.52,80.48 23.1,79.05 23.1,74.57 21.79,73.26 21.79,66.22 22.61,65.41 23.96,65.41 25.23,64.13 25.23,61.8 24.59,61.17 24.59,57.55 21.84,54.79 21.84,48.72 23.05,47.5 23.05,45.58 22.24,44.77 22.24,43.15 22.64,42.75 23.03,42.75 24.17,41.61 24.17,39.79 24,39.62 24,32.21 22.5,30.71 22.5,28.93 20.33,26.76 20.33,25.78 20.73,25.38 21.3,25.38 21.37,25.31 21.57,25.31 v1(21.81,25.07)
  BOTTOM w0.102: CPU1.CB5 122.06,81.24 121.92,81.24 121.91,81.24 v1(121.9,81.24)
USB1_USB30_RX_P: length 179.4
  TOP w0.102: v1(21.81,25.94) 21.48,25.61 20.44,25.61 R3503.1
  L6 w0.089: v1(121.93,80.6) 121.68,80.6 121.48,80.8 121.48,81.44 121.67,81.62 121.67,82.08 120.54,83.21 110.08,83.21 108.16,85.13 108.16,89.74 105.75,92.15 104.57,92.15 104.08,92.64 74.67,92.64 74.16,93.14 63.93,93.14 63.51,93.56 54.08,93.56 53.33,92.81 48.62,92.81 47.4,91.6 46.46,91.6 45.26,90.4 38.21,90.4 36.42,88.61 34.03,88.61 32.92,87.49 31.6,87.49 27.11,83.01 27.11,82.32 26.61,81.82 26.61,81.62 25.28,80.29 24.6,80.29 23.29,78.97 23.29,74.49 21.98,73.18 21.98,66.3 22.68,65.6 24.04,65.6 25.42,64.21 25.42,61.72 24.78,61.09 24.78,57.47 22.03,54.71 22.03,48.8 23.24,47.58 23.24,45.5 22.43,44.69 22.43,43.23 22.72,42.94 23.11,42.94 24.36,41.69 24.36,39.71 24.19,39.54 24.19,32.13 22.69,30.63 22.69,28.85 20.52,26.69 20.52,25.86 20.81,25.57 21.38,25.57 21.45,25.5 21.72,25.5 21.81,25.59 v1(21.81,25.94)
  BOTTOM w0.102: CPU1.CB6 122.39,80.83 122.16,80.6 v1(121.93,80.6)
USB1_USB30_TX_CMC_N: length 1.5
  TOP w0.102: R3502.1 20.39,27.05 21.25,27.05 C3511.2
USB1_USB30_TX_CMC_P: length 1.7
  TOP w0.102: C3512.2 21.46,27.38 21.36,27.28 20.47,27.28 R3501.1
USB1_USB30_TX_CON_N: length 9.2
  TOP w0.102: USB3.8 10.91,27.41 13.56,27.41 14.07,26.9 16.12,26.9 ; 16.12,26.9 v2(16.12,26.75) ; 16.12,26.9 16.58,26.9 16.72,26.77 ED3501.7 ED3501.4 18.35,26.77 18.45,26.87 19.26,26.87 R3502.2
USB1_USB30_TX_CON_P: length 10.1
  TOP w0.102: 15.01,27.13 16.58,27.13 16.72,27.27 ED3501.6 ED3501.5 18.98,27.27 R3501.2 ; 15.01,27.13 14.17,27.13 13.66,27.64 11.65,27.64 10.65,28.64 USB3.9 ; 15.01,27.13 v2(15.01,27.28)
USB1_USB30_TX_N: length 193.3
  TOP w0.102: 23.16,27.69 23.16,28.04 22.92,28.27 21.28,28.27 21.18,28.37 21.18,28.48 v1(21.48,28.78) ; 23.16,27.69 v2(23.34,27.69) ; 23.16,27.69 23.16,27.35 22.92,27.12 22.64,27.12 C3511.1
  L6 w0.089: v1(110.72,93.6) 110.72,94.46 109.57,95.61 107.68,95.61 107.17,96.12 104.63,96.12 104.23,95.72 94.83,95.72 94.28,95.16 75.79,95.16 74.5,96.46 74.15,96.46 73.63,96.98 71.09,96.98 70.73,96.62 67.44,96.62 66.4,97.67 63.95,97.67 62.77,96.48 41.36,96.48 39.79,94.91 32.34,94.91 30.96,93.53 28.99,93.53 23.39,87.93 23.39,83.35 20.16,80.12 17.28,80.12 15.42,78.26 15.42,70.86 17.86,68.42 17.86,67.86 17.06,67.06 17.06,56.21 18,55.27 18,47.1 20.12,44.98 20.12,40.3 19.22,39.4 19.22,36.89 20.82,35.29 20.82,31.16 20.78,31.12 20.78,30.76 20.5,30.49 20.5,30.21 19.97,29.67 19.97,28.19 20.18,27.98 20.89,27.98 21.22,28.31 21.22,28.51 v1(21.48,28.78)
  BOTTOM w0.076: CPU1.CA4 121.77,82.68 121.79,82.75 121.85,82.82 121.85,82.98 121.85,82.99 121.98,83.33 121.98,83.36 122.01,83.44 122.01,83.44 122.02,83.45 122.03,83.47 122.03,83.77 122.02,83.78 122,83.87 122,84.01 122.06,84.35 122.06,84.37 122.06,84.5 122.06,84.54 122.06,85.04 122.08,85.07 122.08,85.09
  BOTTOM w0.102: 122.08,85.09 122.08,86.4 122.56,86.88 122.56,91.48 120.37,93.68 113.38,93.68 112.47,92.76 110.82,92.76 110.72,92.87 v1(110.72,93.6)
USB1_USB30_TX_P: length 191.9
  TOP w0.102: v1(20.62,28.78) 20.95,28.45 20.95,28.28 21.18,28.04 22.83,28.04 22.93,27.94 22.93,27.45 22.83,27.35 22.64,27.35 C3512.1
  L6 w0.089: v1(20.62,28.78) 20.87,28.78 21.03,28.62 21.03,28.39 20.81,28.17 20.26,28.17 20.16,28.27 20.16,29.59 20.7,30.13 20.7,30.41 20.97,30.69 20.97,31.04 21.01,31.08 21.01,35.37 19.41,36.97 19.41,39.32 20.31,40.22 20.31,45.06 18.19,47.18 18.19,55.35 17.25,56.29 17.25,66.98 18.05,67.78 18.05,68.5 15.62,70.94 15.62,78.18 17.36,79.93 20.24,79.93 23.58,83.28 23.58,87.85 29.06,93.34 31.04,93.34 32.42,94.72 39.87,94.72 41.44,96.29 62.85,96.29 64.03,97.48 66.32,97.48 67.37,96.43 70.81,96.43 71.17,96.79 73.55,96.79 74.07,96.27 74.42,96.27 75.71,94.97 94.36,94.97 94.91,95.53 104.31,95.53 104.71,95.93 107.09,95.93 107.6,95.42 109.49,95.42 110.53,94.38 110.53,94.03 110.43,93.93 110.06,93.93 109.97,93.84 v1(109.97,93.6)
  BOTTOM w0.076: 121.85,85.09 121.85,85.08 121.88,85.05 121.88,84.54 121.88,84.5 121.88,84.44 121.88,84.37 121.82,84.02 121.82,83.86 121.85,83.69 121.85,83.69 121.85,83.51 CPU1.CA3
  BOTTOM w0.102: 121.85,85.09 121.85,86.5 122.33,86.98 122.33,91.39 120.27,93.45 113.47,93.45 112.56,92.53 110.72,92.53 110.49,92.77 110.49,93.12 110.39,93.22 110.05,93.22 109.97,93.31 v1(109.97,93.6)
USB2_ID: length 17
  L6 w0.102: v1(131.87,86.69) 131.46,86.29 129.64,86.29 128.92,87 126.77,87 124.64,84.87 124.64,80.9 123.8,80.05 v1(123.8,79.87)
  BOTTOM w0.102: v1(123.8,79.87) 123.8,79.87 124.05,79.62 CPU1.CE8 ; RN1602.2 132.43,88.15 132.05,87.76 131.77,87.76 v2(131.39,87.38) 131.39,87.18 v1(131.87,86.69)
USB2_USB20_CON_N: length 15.6
  TOP w0.102: 17.47,43.79 15.26,43.79 13.86,45.19 12.25,45.19 12.15,45.29 USB4.2 ; 17.47,43.79 AFTP3505.1 ; 17.47,43.79 17.54,43.79 17.77,43.56 17.77,42.23 18.34,41.66 18.63,41.66 18.99,41.3 v1(18.99,41.23)
  BOTTOM w0.102: v1(18.99,41.23) 18.76,41.23 18.54,41 18.54,40.35 ED3502.3 19.27,40.13 19.48,40.34 19.48,40.9 19.64,41.06 20.39,41.06 20.72,40.74 EL3506.2
USB2_USB20_CON_P: length 16.1
  TOP w0.102: 15.64,43.56 17.44,43.56 17.55,43.46 17.55,42.14 18.12,41.57 v1(18.12,41.19) ; 15.64,43.56 15.16,43.56 13.77,44.96 12.25,44.96 12.15,44.86 USB4.3 ; 15.64,43.56 AFTP3506.1
  BOTTOM w0.102: EL3506.3 19.84,39.82 19.32,39.3 19.32,37.92 19.09,37.7 ED3502.4 18.75,38.09 18.28,38.56 18.28,41.03 v1(18.12,41.19)
USB2_USB20_N: length 181.1
  L6 w0.089: v1(107.23,94.92) 107.23,94.71 107.04,94.52 106.91,94.52 106.83,94.61 104.9,94.61 104.38,95.13 95.38,95.13 94.83,94.58 75.54,94.58 74.89,95.23 68.02,95.23 66.16,97.08 64.33,97.08 63.14,95.89 44.6,95.89 41.15,92.45 32.91,92.45 29.48,89.02 25.42,89.02 24,87.6 24,83.13 20.4,79.54 17.52,79.54 16.14,78.15 16.14,73.96 18.51,71.59 18.51,67.64 17.65,66.78 17.65,56.47 19.88,54.23 19.88,46.39 21.65,44.63 21.65,42.51 21.98,42.17 21.98,40.25 21.33,39.6 21.33,37.58 21.24,37.5 20.76,37.5 20.47,37.79 20.47,37.99 20.56,38.08 v1(20.75,38.08)
  BOTTOM w0.102: 119.27,95.63 113.43,95.63 112.74,94.95 112.08,94.95 111.27,95.76 108.82,95.76 107.92,94.86 107.78,94.86 107.68,94.96 107.68,95.23 107.61,95.3 107.31,95.3 107.23,95.23 v1(107.23,94.92) ; 119.27,95.63 v2(119.27,95.79) ; 119.27,95.63 122.32,95.63 122.78,95.18 122.78,93.16 126.12,89.82 126.12,87.29 124,85.18 124,84.3 CPU1.CE1 ; v1(20.75,38.08) 20.54,38.08 20.44,38.18 20.44,38.85 20.72,39.06 EL3506.1
USB2_USB20_P: length 180.8
  L6 w0.089: v1(20.01,38.03) 20.01,37.98 20.68,37.31 21.32,37.31 21.52,37.51 21.52,39.52 22.17,40.17 22.17,42.25 21.84,42.59 21.84,44.71 20.07,46.47 20.07,54.31 17.84,56.55 17.84,66.7 18.7,67.56 18.7,71.67 16.33,74.04 16.33,78.07 17.6,79.35 20.48,79.35 24.19,83.06 24.19,87.52 25.5,88.83 29.56,88.83 32.99,92.26 41.23,92.26 44.68,95.7 63.22,95.7 64.41,96.89 66.08,96.89 67.94,95.04 74.81,95.04 75.46,94.39 94.91,94.39 95.46,94.94 104.3,94.94 104.82,94.41 106.75,94.41 106.84,94.33 107.04,94.33 v1(107.23,94.13)
  BOTTOM w0.102: 125.38,90.24 125.89,89.73 125.89,87.39 123.77,85.27 123.77,83.88 CPU1.CE2 ; 125.38,90.24 v2(125.27,90.12) ; 125.38,90.24 122.55,93.07 122.55,95.08 122.23,95.41 113.52,95.41 112.83,94.72 111.99,94.72 111.18,95.53 108.91,95.53 108.01,94.64 107.73,94.64 v1(107.23,94.13) ; EL3506.4 19.96,38.89 20.11,38.74 20.11,38.13 v1(20.01,38.03)
USB2_USB30_RX_CON_N: length 9.3
  BOTTOM w0.102: USB4.5 10.65,41.67 11.42,42.45 11.75,42.45 11.93,42.62 13.25,42.62 14.01,43.39 15.41,43.39 15.87,43.39 16.01,43.25 ED3504.1 ED3504.10 18.52,43.25 R3522.2
USB2_USB30_RX_CON_P: length 8.7
  BOTTOM w0.102: R3521.2 18.49,43.75 ED3504.9 ED3504.2 16.01,43.75 15.87,43.61 15.51,43.61 15.51,43.61 13.92,43.61 13.16,42.85 11.83,42.85 11.65,42.67 11.13,42.67 USB4.6
USB2_USB30_RX_N: length 161.7
  L6 w0.089: v1(121.9,79.27) 121.74,79.11 121.74,78.72 121.43,78.41 116.91,78.41 115.92,77.42 108.94,77.42 107.83,78.54 107.83,81.99 106.26,83.57 106.26,89.76 105.03,90.99 104.01,90.99 103.55,91.44 96.95,91.44 94.57,89.07 79.67,89.07 79.47,89.27 71.01,89.27 69.64,90.64 64.49,90.64 62.73,92.4 54.59,92.4 53.82,91.62 49.08,91.62 46.68,89.22 38.71,89.22 36.93,87.44 35.05,87.44 33.49,85.88 32.35,85.88 27.82,81.35 27.82,81.14 24.64,77.97 24.64,71.96 24.31,71.63 24.31,66.16 26.09,64.39 26.09,60.27 25.64,59.82 25.64,57.48 22.61,54.46 22.61,49.04 23.43,48.22 23.92,48.22 24.45,47.69 24.45,44.05 24.07,43.66 23.2,43.66 v1(22.98,43.44)
  BOTTOM w0.102: v2(21.38,43.34) 21.26,43.46 ; 21.26,43.46 21.49,43.69 22.73,43.69 v1(22.98,43.44) ; 21.26,43.46 21.04,43.24 20.42,43.24 20.31,43.13 R3522.1 ; CPU1.BY8 121.55,79.62 v1(121.9,79.27)
