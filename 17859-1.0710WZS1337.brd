# Allegro board 17859-1.0710WZS1337.brd (continued)
## Nets (continued)
1V_CPU_CORE: CPU1.AN9 CPU1.AN10 CPU1.AN24 CPU1.AN26 CPU1.AN27 CPU1.AP2 CPU1.AP9 CPU1.AP24 CPU1.AP26 CPU1.AR5 CPU1.AR6 CPU1.AR7 CPU1.AR8 CPU1.AR10 CPU1.AR25 CPU1.AR27 CPU1.AT9 CPU1.AT24 CPU1.AT26 CPU1.AU5 CPU1.AU6 CPU1.AU7 CPU1.AU8 CPU1.AU9 CPU1.AU24 CPU1.AU25 CPU1.AU26 CPU1.AU27 CPU1.AV2 CPU1.AV5 CPU1.AV7 CPU1.AV10 CPU1.AV27 CPU1.AW5 CPU1.AW6 CPU1.AW7 CPU1.AW8 CPU1.AW9 CPU1.AW10 CPU1.AW24 CPU1.AW25 CPU1.AW26 CPU1.AW27 CPU1.AY24 CPU1.AY26 CPU1.BA5 CPU1.BA7 CPU1.BA8 CPU1.BA25 CPU1.BA27 CPU1.BB2 CPU1.BB26 CPU1.BC5 CPU1.BC6 CPU1.BC7 CPU1.BC9 CPU1.BC10 CPU1.BC26 CPU1.BC27 CPU1.BD5 CPU1.BD8 CPU1.BD10 CPU1.BD25 CPU1.BD27 CPU1.BE9 CPU1.BE24 CPU1.BE25 CPU1.BE26 CPU1.BE27 CPU1.BF2 CPU1.BF9 CPU1.BF24 CPU1.BF26 CPU1.BG27 PC1002.1 PC1003.1 PC1004.1 PC1005.1 PC1006.1 PC1007.1 PC1008.1 PC1009.1 PC1010.1 PC1011.1 PC1012.1 PC1013.1 PC1014.1 PC1015.1 PC1016.1 PC1017.1 PC1018.1 PC1019.1 PC1020.1 PC1021.1 PC1022.1 PC1023.1 PC1024.1 PC1025.1 PC1026.1 PC1027.1 PC1028.1 PC1029.1 PC1030.1 PC1031.1 PC1032.1 PC1034.1 PC1036.1 PC1079.1 PC1080.1 PC1081.1 PC1082.1 PC1083.1 PC1084.1 PG4809.2 PG4815.2 PL4801.2 PL4802.2 PR4631.2 PT4801.1 PT4803.1 R719.1 R814.1 R815.1 R816.1
1V_GT_CORE: CPU1.AA9 CPU1.AB2 CPU1.AB8 CPU1.AB9 CPU1.AB10 CPU1.AC8 CPU1.AD9 CPU1.AE8 CPU1.AE9 CPU1.AE10 CPU1.AF2 CPU1.AF8 CPU1.AF10 CPU1.AG8 CPU1.AG9 CPU1.AH9 CPU1.AJ8 CPU1.AJ10 CPU1.AK2 CPU1.AK9 CPU1.AL8 CPU1.AL9 CPU1.AL10 CPU1.AM8 CPU1.V2 CPU1.Y8 CPU1.Y10 R812.1 R813.1 R814.2 R815.2 R816.2
1V_VCCGT: C1102.1 C1103.1 C1104.1 C1105.1 C1106.1 C1107.1 CPU1.A5 CPU1.A6 CPU1.A8 CPU1.A11 CPU1.A12 CPU1.A14 CPU1.A15 CPU1.A17 CPU1.A18 CPU1.A20 CPU1.B3 CPU1.B4 CPU1.B6 CPU1.B8 CPU1.B11 CPU1.B14 CPU1.B17 CPU1.B20 CPU1.C2 CPU1.C3 CPU1.C6 CPU1.C7 CPU1.C8 CPU1.C11 CPU1.C12 CPU1.C14 CPU1.C15 CPU1.C17 CPU1.C18 CPU1.C20 CPU1.D4 CPU1.D7 CPU1.D11 CPU1.D12 CPU1.D14 CPU1.D15 CPU1.D17 CPU1.D18 CPU1.D20 CPU1.E4 CPU1.F5 CPU1.F6 CPU1.F7 CPU1.F8 CPU1.F11 CPU1.F14 CPU1.F17 CPU1.F20 CPU1.G11 CPU1.G12 CPU1.G14 CPU1.G15 CPU1.G17 CPU1.G18 CPU1.G20 CPU1.H5 CPU1.H6 CPU1.H7 CPU1.H8 CPU1.H11 CPU1.H12 CPU1.H14 CPU1.H15 CPU1.H17 CPU1.H18 CPU1.H20 CPU1.J7 CPU1.J8 CPU1.J11 CPU1.J14 CPU1.J17 CPU1.J20 CPU1.K2 CPU1.K11 CPU1.L7 CPU1.L8 CPU1.L10 CPU1.M9 CPU1.N7 CPU1.N8 CPU1.N9 CPU1.N10 CPU1.P2 CPU1.P8 CPU1.R9 CPU1.T8 CPU1.T9 CPU1.T10 CPU1.U8 CPU1.U10 CPU1.V9 CPU1.W8 CPU1.W9 PC1001.1 PC1037.1 PC1038.1 PC1039.1 PC1040.1 PC1041.1 PC1042.1 PC1043.1 PC1044.1 PC1045.1 PC1046.1 PC1047.1 PC1048.1 PC1049.1 PC1050.1 PC1051.1 PC1052.1 PC1053.1 PC1054.1 PC1055.1 PC1056.1 PC1057.1 PC1058.1 PC1059.1 PC1060.1 PC1061.1 PC1062.1 PC1063.1 PC1064.1 PC1065.1 PC1066.1 PC1067.1 PC1068.1 PC1069.1 PC1070.1 PG4708.2 PL4701.2 PR4663.1 PT4701.1 R807.1 R812.2 R813.2
1V_VCCIO: C1108.1 C1109.1 C1110.1 C1111.1 C1133.1 C1134.1 C1135.1 CPU1.AK24 CPU1.AK26 CPU1.AL24 CPU1.AL25 CPU1.AL26 CPU1.AL27 CPU1.AM25 CPU1.AM27 CPU1.BH24 CPU1.BH25 CPU1.BH26 CPU1.BH27 CPU1.BJ24 CPU1.BJ26 CPU1.BP16 CPU1.BP18 R401.1 R4038.1 R4046.2
1V_VCCIO_R: C4007.1 R4046.1 U4002.6 U4002.7 U4002.8
1V_VCCSA: CPU1.BG8 CPU1.BG10 CPU1.BH9 CPU1.BJ8 CPU1.BJ9 CPU1.BJ10 CPU1.BK8 CPU1.BK25 CPU1.BK27 CPU1.BL8 CPU1.BL9 CPU1.BL10 CPU1.BL24 CPU1.BL26 CPU1.BM24 CPU1.BN25 PC1071.1 PC1072.1 PC1073.1 PC1074.1 PC1075.1 PC1076.1 PC1077.1 PC1078.1 PG5001.2 PL5001.2 R810.1
1V_VCCST_CPU: C801.1 C805.2 C806.2 CPU1.BP2 CPU1.BP11 CPU1.BR11 CPU1.BT11 PC4602.1 PR4603.1 PR4604.1 PR4605.1 PR4606.1 R308.1 R723.1 R726.1 R727.1 R4036.2
1V_VCCST_CPU_R: C4012.1 R4036.1 U4006.6 U4006.7 U4006.8
1V_VCCSTG: C802.1 CPU1.BG1 CPU1.BG2 CPU1.BG3 R301.1 R309.2 R310.2 R311.2 R312.2 R313.2 R314.2 R315.2 R4038.2
1V_VGA_EN_B: R8650.2 U8604.2
1V_VGA_EN_OR: Q8509.2 R8542.2 R8543.2
1V_VGA_EN_R: C8631.1 PU8603.7 Q8607.2 R8543.1 R8652.2
1V_VGA_EN_Y: R8652.1 U8604.4
1V_VGA_S0: C7610.1 C7611.1 C7612.1 C7613.1 C7623.1 C7625.1 C7626.1 GPU1.AA22 GPU1.AB23 GPU1.AC24 GPU1.AD25 GPU1.AE26 GPU1.AE27 L7602.2 PG8607.2 PG8608.2 R8607.1 R8641.1
1V_VGA_S0_DISCHG: Q8607.3 R8641.2
1V_VGA_S0_PG: D8601.2 PR8623.2 R8531.1 R8542.1
1V_VREF_CPU: C2406.1 R2402.2 U2401.95
3.3V_WLAN_EN: Q6102.G R6136.1
3V3_AON_1D8V_VGA_S0: C7616.1 GPU1.AA8 GPU1.AA9 R7616.2 R8609.2 R8610.2
3V5V_CT1: C4001.1 U4001.12
3V5V_CT2: C4010.1 U4003.10
3V5V_S0_ON: C4014.1 R4010.2 U4001.3 U4003.5
3V_5V_DSW_OK: D2503.3 PR5207.1 PR5305.1 R2513.2 R2514.2 U2502.4
3V_5V_EN: C4009.1 D4001.A PR4515.1 PR4516.1 R4006.1 R4007.1 R4009.1
3V_5V_POK: C1710.1 D2503.1 ED1703.1 PG4529.1 PG4531.1 R1728.2 R2513.1 R4033.1
3V_5V_POK#: Q1701.5 Q1701.6 R1726.1
3V_5V_POK_C: Q1701.2 R1727.2 R1728.1
5V_AUX_S5: PG4528.2 PR4510.2
5V_FAN_VCC: AFTP2603.1 C2603.1 C2604.1 C2605.1 D2601.K FAN1.1 R2612.2
5V_HDD_S0: AFTP6001.1 C6007.1 C6008.1 HDD1.9 HDD1.10 HDD1.11 R6001.2
5V_HDMI: C5702.1 F5701.2 HDMI1.18
5V_S0: C4005.1 C5542.1 C5550.1 C6001.1 C6002.1 D5701.3 EC8933.1 EC8934.1 EC8935.1 EC8936.1 EC8937.1 EC8938.1 EC8939.1 F5701.1 F6502.1 PR8502.1 Q5701.G Q6502.E R2612.1 R2701.1 R2703.2 R2707.1 R5558.1 R6001.1 R6504.1 R6512.1 U4001.13 U4001.14 U5502.1 U5502.3 U8601.4
5V_S5: C3422.1 C3507.1 C3602.1 C4031.1 C4032.1 C4041.1 C7222.1 C7227.1 C7231.1 C7232.1 EC8947.1 EC8948.1 EC8949.1 FC8906.1 FC8907.1 FC8908.1 FC8909.1 FC8910.1 PC4766.1 PC4866.1 PC4877.1 PC5001.1 PC5112.1 PC5130.1 PC5202.1 PC5305.1 PG4507.2 PG4508.2 PG4509.2 PG4510.2 PG4511.2 PG4512.2 PG4513.2 PG4514.2 PR4610.1 PR4635.1 PR4704.2 PR4803.2 PR4813.2 PR5108.1 PU4701.29 PU4801.29 PU4802.29 PU5001.6 PU5102.6 PU5201.21 PU5301.6 Q6403.E Q6404.E R3602.1 R3605.1 R3606.1 R4303.1 U3403.5 U3502.5 U3601.1 U4001.1 U4001.2 U4001.4 U4002.3 U4003.4 U4004.3 U4006.3 U7204.A11 U7204.B11 U7204.C11 U7204.D11 U7204.H10
5V_USB2_S0: C3401.1 C3402.1 C3403.1 C3404.1 IOBD1.24 IOBD1.25 IOBD1.26 U3403.1
5V_USB30_VCCA: AFTP3504.1 C3516.1 C3517.1 C3518.1 C3519.1 R3509.1 R3510.1 U3502.1 USB4.1
5V_USB30_VCCB: AFTP3501.1 C3506.1 C3508.1 C3509.1 C3510.1 C3601.1 C3603.1 C3604.1 C3605.1 EC3513.1 ED3502.5 R3509.2 R3510.2 TC3502.1 U3601.12 USB3.1
20V_DCBATOUT: PC4402.1 PC4403.1 PC4404.1 PC4405.1 PG4402.1 PR4401.2 PR4439.1 PR4479.1 PU4403.5 PU4403.6 PU4403.7 PU4403.8
20V_VCCPD_VBUS: C7325.1 C7326.1 C7327.1 C7328.1 C7329.1 C7330.1 D7203.K ER7201.2 ER7202.2 R7423.1 R7425.1 R7426.1 U7419.B2 U7419.C2 U7419.D2 U7419.E1 U7419.E2 USB1.A4 USB1.A9 USB1.B4 USB1.B9
20V_VCCPD_VBUS_L: C7219.2 ER7201.1 ER7202.1 R7234.1 R7235.1 U7204.H11 U7204.J10 U7204.J11 U7204.K11
+3V_1D8V_AVDD: C2710.1 R2719.2 U2701.33
+3V_1D8V_DVDD: C2720.1 C2721.1 C2723.1 C2740.1 C2741.1 R2710.1 R2715.2 R2717.1 U2701.1 U2701.8
+5V_AVDD: C2706.1 C2707.1 R2703.1 U2701.20
+5V_KB_BL: AFTP6605.1 C6501.1 F6502.2 KB_BL1.1 R6504.2
+5V_PVDD: R2701.2 R2707.2 R2713.1 R2714.1
+5V_PVDD1: C2713.1 C2714.1 C2717.1 C2718.1 R2713.2 R2714.2 U2701.34 U2701.39
DVSS: R2716.2 U2701.10
GND: AFTP2501.1 AFTP2604.1 AFTP4306.1 AFTP4307.1 AFTP4308.1 AFTP6531.1 AFTP6537.1 AFTP6565.1 BATT1.8 BATT1.9 BATT1.10 BATT1.11 BATT1.12 BS2.1 C801.2 C802.2 C803.1 C804.2 C805.1 C806.1 C1102.2 C1103.2 C1104.2 C1105.2 C1106.2 C1107.2 C1108.2 C1109.2 C1110.2 C1111.2 C1112.2 C1113.2 C1114.2 C1115.2 C1116.2 C1117.2 C1118.2 C1119.2 C1120.2 C1121.2 C1122.2 C1123.2 C1128.2 C1129.2 C1130.2 C1131.2 C1132.2 C1133.2 C1134.2 C1135.2 C1136.2 C1137.2 C1138.2 C1139.2 C1140.2 C1141.2 C1142.2 C1202.2 C1203.2 C1204.2 C1205.2 C1206.2 C1207.2 C1208.2 C1209.2 C1210.2 C1211.2 C1212.2 C1213.2 C1214.2 C1215.2 C1216.2 C1217.2 C1218.2 C1219.2 C1220.2 C1221.2 C1223.2 C1224.2 C1225.2 C1226.2 C1227.2 C1228.2 C1229.2 C1230.2 C1231.2 C1232.2 C1233.2 C1301.2 C1303.2 C1304.2 C1305.2 C1306.2 C1307.2 C1308.2 C1309.2 C1310.2 C1311.2 C1312.2 C1313.2 C1314.2 C1315.2 C1316.2 C1317.2 C1318.2 C1319.2 C1320.2 C1321.2 C1322.2 C1324.2 C1325.2 C1326.2 C1327.2 C1328.2 C1329.2 C1330.2 C1331.2 C1701.2 C1710.2 C1711.2 C1803.2 C1804.2 C1805.2 C1806.2 C1807.1 C1808.1 C2201.2 C2202.2 C2203.2 C2204.2 C2205.2 C2206.2 C2207.2 C2208.2 C2209.2 C2210.2 C2211.2 C2212.2 C2213.2 C2214.2 C2215.2 C2216.2 C2217.2 C2218.2 C2219.2 C2220.2 C2221.2 C2222.2 C2223.2 C2224.2 C2405.2 C2406.2 C2409.2 C2410.2 C2411.2 C2412.2 C2413.2 C2414.2 C2418.2 C2420.2 C2423.2 C2424.1 C2425.1 C2426.2 C2428.2 C2429.2 C2430.2 C2501.2 C2502.2 C2503.2 C2517.2 C2525.2 C2601.2 C2602.2 C2603.2 C2604.2 C2605.2 C2608.2 C2609.2 C2610.2 C2704.2 C2705.2 C2709.1 C2713.2 C2714.2 C2717.2 C2718.2 C2720.2 C2721.2 C2722.2 C2723.2 C2736.2 C2737.2 C2739.2 C2740.2 C2741.2 C3401.2 C3402.2 C3403.2 C3404.2 C3422.2 C3506.2 C3507.2 C3508.2 C3509.2 C3510.2 C3516.2 C3517.2 C3518.2 C3519.2 C3601.2 C3602.2 C3603.2 C3604.2 C3605.2 C4001.2 C4005.2 C4006.2 C4007.2 C4008.2 C4009.2 C4010.2 C4011.2 C4012.2 C4013.2 C4014.2 C4031.2 C4032.2 C4033.2 C4034.2 C4035.2 C4036.2 C4041.2 C4043.2 C4045.2 C4047.2 C4302.2 C4303.2 C4304.2 C4305.2 C4306.2 C4344.2 C5501.2 C5502.2 C5503.2 C5505.2 C5514.2 C5515.2 C5518.2 C5535.2 C5536.2 C5538.2 C5539.2 C5540.2 C5541.2 C5542.2 C5550.2 C5599.2 C5702.2 C6001.2 C6002.2 C6007.2 C6008.2 C6101.2 C6103.2 C6106.2 C6109.2 C6110.2 C6304.2 C6305.2 C6306.2 C6307.2 C6308.2 C6321.2 C6322.2 C6401.2 C6402.2 C6501.2 C6502.2 C6504.2 C7003.2 C7004.2 C7219.1 C7220.2 C7221.2 C7222.2 C7223.1 C7224.1 C7225.2 C7226.1 C7227.2 C7228.2 C7229.2 C7230.1 C7231.2 C7232.2 C7244.2 C7315.2 C7316.2 C7317.2 C7318.2 C7319.2 C7325.2 C7326.2 C7327.2 C7328.2 C7329.2 C7330.2 C7610.2 C7611.2 C7612.2 C7613.2 C7614.2 C7615.2 C7616.2 C7620.2 C7621.2 C7622.2 C7623.2 C7624.2 C7625.2 C7626.2 C7627.2 C7628.2 C7629.2 C7630.2 C7631.2 C7632.2 C7633.2 C7634.2 C7801.2 C7802.2 C7805.2 C7806.2 C7807.1 C7808.2 C7809.2 C7813.2 C7814.2 C7817.2 C7818.2 C7820.2 C7825.1 C7826.1 C7827.1 C7828.1 C7829.1 C7830.1 C7831.1 C7832.2 C7833.2 C7834.2 C7835.2 C7903.2 C7906.2 C7907.1 C7908.1 C7909.2 C7934.2 C7935.2 C7936.2 C7937.2 C7938.2 C7939.2 C8001.2 C8002.2 C8003.2 C8004.2 C8008.2 C8009.2 C8010.2 C8011.2 C8012.2 C8013.2 C8014.2 C8015.2 C8016.2 C8017.2 C8018.2 C8019.2 C8020.2 C8021.2 C8022.2 C8023.2 C8024.2 C8025.2 C8026.2 C8028.2 C8029.2 C8030.2 C8031.2 C8032.2 C8034.2 C8035.2 C8036.2 C8037.2 C8038.2 C8039.2 C8040.2 C8041.2 C8042.2 C8043.2 C8044.2 C8045.2 C8046.2 C8047.2 C8048.2 C8089.2 C8101.2 C8102.2 C8103.2 C8104.2 C8105.2 C8106.2 C8107.2 C8108.2 C8109.2 C8110.2 C8111.2 C8112.2 C8113.2 C8114.2 C8115.2 C8116.2 C8117.2 C8118.2 C8119.2 C8120.2 C8121.2 C8122.2 C8123.2 C8124.2 C8125.2 C8126.2 C8127.2 C8128.2 C8129.2 C8130.2 C8131.2 C8132.2 C8136.2 C8140.2 C8141.2 C8142.2 C8143.2 C8144.2 C8145.2 C8146.2 C8501.1 C8601.2 C8602.2 C8603.2 C8604.2 C8605.2 C8606.2 C8607.2 C8608.2 C8630.2 C8631.2 C9106.2 C9108.2 C9109.2 C9112.2 C9113.2 CPU1.A3 CPU1.A4 CPU1.A32 CPU1.A36 CPU1.AB3 CPU1.AB4 CPU1.AB7 CPU1.AB27 CPU1.AB30 CPU1.AB33 CPU1.AB36 CPU1.AC5 CPU1.AC10 CPU1.AC27 CPU1.AC30 CPU1.AD33 CPU1.AD35 CPU1.AE7 CPU1.AE24 CPU1.AE25 CPU1.AE26 CPU1.AE27 CPU1.AE30 CPU1.AF3 CPU1.AF4 CPU1.AF7 CPU1.AF25 CPU1.AF27 CPU1.AF30 CPU1.AF33 CPU1.AF36 CPU1.AG5 CPU1.AG10 CPU1.AG24 CPU1.AG26 CPU1.AH24 CPU1.AH25 CPU1.AH27 CPU1.AH28 CPU1.AH29 CPU1.AH30 CPU1.AH31 CPU1.AH33 CPU1.AH35 CPU1.AJ7 CPU1.AJ25 CPU1.AJ28 CPU1.AK3 CPU1.AK4 CPU1.AK33 CPU1.AK36 CPU1.AL7 CPU1.AL28 CPU1.AL29 CPU1.AL32 CPU1.AM5 CPU1.AM10 CPU1.AM28 CPU1.AM33 CPU1.AM35 CPU1.AN7 CPU1.AN8 CPU1.AN25 CPU1.AN28 CPU1.AN29 CPU1.AN30 CPU1.AN31 CPU1.AP3 CPU1.AP4 CPU1.AP33 CPU1.AP36 CPU1.AR4 CPU1.AR28 CPU1.AT4 CPU1.AT33 CPU1.AT35 CPU1.AT36 CPU1.AU4 CPU1.AU10 CPU1.AU28 CPU1.AU29 CPU1.AU32 CPU1.AV3 CPU1.AV4 CPU1.AV6 CPU1.AV8 CPU1.AV25 CPU1.AV28 CPU1.AV33 CPU1.AV36 CPU1.AW1 CPU1.AW3 CPU1.AW4 CPU1.AW28 CPU1.AW29 CPU1.AW30 CPU1.AW31 CPU1.AY4 CPU1.AY33 CPU1.AY35 CPU1.B2 CPU1.B5 CPU1.B7 CPU1.B9 CPU1.B12 CPU1.B15 CPU1.B18 CPU1.B21 CPU1.B23 CPU1.B25 CPU1.B27 CPU1.B29 CPU1.B31 CPU1.B34 CPU1.B36 CPU1.B37 CPU1.BA3 CPU1.BA4 CPU1.BA6 CPU1.BA10 CPU1.BA28 CPU1.BB3 CPU1.BB4 CPU1.BB33 CPU1.BB36 CPU1.BC4 CPU1.BC8 CPU1.BC25 CPU1.BC29 CPU1.BC32 CPU1.BD4 CPU1.BD6 CPU1.BD7 CPU1.BD28 CPU1.BD33 CPU1.BD35 CPU1.BD36 CPU1.BE3 CPU1.BE4 CPU1.BE8 CPU1.BE10 CPU1.BE28 CPU1.BE29 CPU1.BE30 CPU1.BE31 CPU1.BF3 CPU1.BF4 CPU1.BF33 CPU1.BF36 CPU1.BG4 CPU1.BG25 CPU1.BG28 CPU1.BH28 CPU1.BH29 CPU1.BH32 CPU1.BH33 CPU1.BH35 CPU1.BJ7 CPU1.BK2 CPU1.BK3 CPU1.BK4 CPU1.BK7 CPU1.BK10 CPU1.BK28 CPU1.BK33 CPU1.BL7 CPU1.BL25 CPU1.BL28 CPU1.BL29 CPU1.BL30 CPU1.BL31 CPU1.BL32 CPU1.BM9 CPU1.BM33 CPU1.BM35 CPU1.BM36 CPU1.BN7 CPU1.BN30 CPU1.BP3 CPU1.BP4 CPU1.BP7 CPU1.BP12 CPU1.BP15 CPU1.BP19 CPU1.BP25 CPU1.BP32 CPU1.BP33 CPU1.BP36 CPU1.BR16 CPU1.BR19 CPU1.BR22 CPU1.BR25 CPU1.BT5 CPU1.BT14 CPU1.BT15 CPU1.BT16 CPU1.BT25 CPU1.BT28 CPU1.BT33 CPU1.BT35 CPU1.BT36 CPU1.BU7 CPU1.BU11 CPU1.BU16 CPU1.BU20 CPU1.BU23 CPU1.BU24 CPU1.BU25 CPU1.BV3 CPU1.BV4 CPU1.BV11 CPU1.BV31 CPU1.BV33 CPU1.BW7 CPU1.BW11 CPU1.BW15 CPU1.BW24 CPU1.BY5 CPU1.BY11 CPU1.BY15 CPU1.BY18 CPU1.BY19 CPU1.BY22 CPU1.BY25 CPU1.BY28 CPU1.BY33 CPU1.BY35 CPU1.BY36 CPU1.C1 CPU1.C4 CPU1.C9 CPU1.C21 CPU1.C25 CPU1.C29 CPU1.C33 CPU1.C36 CPU1.C37 CPU1.CA11 CPU1.CA15 CPU1.CA22 CPU1.CA25 CPU1.CB2 CPU1.CB3 CPU1.CB4 CPU1.CB7 CPU1.CB11 CPU1.CB18 CPU1.CB19 CPU1.CB20 CPU1.CB24 CPU1.CB25 CPU1.CB33 CPU1.CC7 CPU1.CC11 CPU1.CC14 CPU1.CC16 CPU1.CC20 CPU1.CC24 CPU1.CC25 CPU1.CC28 CPU1.CC31 CPU1.CD11 CPU1.CD12 CPU1.CD14 CPU1.CD20 CPU1.CD24 CPU1.CD25 CPU1.CE7 CPU1.CE33 CPU1.CE35 CPU1.CE36 CPU1.CF2 CPU1.CF3 CPU1.CF4 CPU1.CF11 CPU1.CF14 CPU1.CF19 CPU1.CF23 CPU1.CF28 CPU1.CG7 CPU1.CG33 CPU1.CH31 CPU1.CJ2 CPU1.CJ3 CPU1.CJ4 CPU1.CJ11 CPU1.CJ14 CPU1.CJ19 CPU1.CJ23 CPU1.CJ28 CPU1.CJ33 CPU1.CJ35 CPU1.CJ36 CPU1.CK1 CPU1.CK4 CPU1.CK7 CPU1.CK37 CPU1.CL2 CPU1.CM1 CPU1.CM4 CPU1.CM5 CPU1.CM9 CPU1.CM13 CPU1.CM17 CPU1.CM21 CPU1.CM25 CPU1.CM29 CPU1.CM31 CPU1.CM33 CPU1.CM37 CPU1.CN1 CPU1.CN2 CPU1.CN5 CPU1.CN9 CPU1.CN13 CPU1.CN17 CPU1.CN21 CPU1.CN25 CPU1.CN29 CPU1.CN37 CPU1.CP1 CPU1.CP2 CPU1.CP9 CPU1.CP11 CPU1.CP13 CPU1.CP15 CPU1.CP19 CPU1.CP21 CPU1.CP27 CPU1.CP35 CPU1.CP37 CPU1.CR2 CPU1.CR6 CPU1.CR34 CPU1.CR36 CPU1.D1 CPU1.D5 CPU1.D6 CPU1.D8 CPU1.D9 CPU1.D21 CPU1.D25 CPU1.E9 CPU1.E23 CPU1.E27 CPU1.E29 CPU1.E31 CPU1.E33 CPU1.E35 CPU1.F2 CPU1.F3 CPU1.F4 CPU1.F12 CPU1.F15 CPU1.F18 CPU1.F21 CPU1.F24 CPU1.F33 CPU1.G9 CPU1.G21 CPU1.G27 CPU1.G33 CPU1.G35 CPU1.G36 CPU1.H9 CPU1.H21 CPU1.H27 CPU1.J5 CPU1.J6 CPU1.J12 CPU1.J15 CPU1.J18 CPU1.J21 CPU1.J24 CPU1.J33 CPU1.J36 CPU1.K3 CPU1.K4 CPU1.K9 CPU1.K21 CPU1.K22 CPU1.K24 CPU1.K25 CPU1.K27 CPU1.K28 CPU1.K29 CPU1.K30 CPU1.K31 CPU1.K32 CPU1.L6 CPU1.L27 CPU1.L33 CPU1.L35 CPU1.L36 CPU1.N6 CPU1.N25 CPU1.N27 CPU1.P3 CPU1.P4 CPU1.P7 CPU1.P10 CPU1.P33 CPU1.P36 CPU1.R27 CPU1.R28 CPU1.R29 CPU1.R30 CPU1.R31 CPU1.T7 CPU1.T27 CPU1.T30 CPU1.T33 CPU1.T35 CPU1.T36 CPU1.U7 CPU1.U24 CPU1.U26 CPU1.V3 CPU1.V4 CPU1.V26 CPU1.V27 CPU1.V30 CPU1.V33 CPU1.V36 CPU1.W7 CPU1.W10 CPU1.W27 CPU1.W30 CPU1.Y7 CPU1.Y26 CPU1.Y27 CPU1.Y30 CPU1.Y33 CPU1.Y35 D2601.A D4301.A D4302.1 D4303.3 D4304.1 D4305.1 D4306.1 D4307.A D7203.A DBG1.3 DBG1.15 DBG1.16 DBG3.4 DBG3.7 DBG3.8 DCIN1.9 DCIN1.10 DM1.1 DM1.2 DM1.5 DM1.6 DM1.9 DM1.10 DM1.14 DM1.15 DM1.18 DM1.19 DM1.22 DM1.23 DM1.26 DM1.27 DM1.30 DM1.31 DM1.35 DM1.36 DM1.39 DM1.40 DM1.43 DM1.44 DM1.47 DM1.48 DM1.51 DM1.52 DM1.56 DM1.57 DM1.60 DM1.61 DM1.64 DM1.65 DM1.68 DM1.69 DM1.72 DM1.73 DM1.77 DM1.78 DM1.81 DM1.82 DM1.85 DM1.86 DM1.89 DM1.90 DM1.93 DM1.94 DM1.98 DM1.99 DM1.102 DM1.103 DM1.106 DM1.107 DM1.167 DM1.168 DM1.171 DM1.172 DM1.175 DM1.176 DM1.180 DM1.181 DM1.184 DM1.185 DM1.188 DM1.189 DM1.192 DM1.193 DM1.196 DM1.197 DM1.201 DM1.202 DM1.205 DM1.206 DM1.209 DM1.210 DM1.213 DM1.214 DM1.217 DM1.218 DM1.222 DM1.223 DM1.226 DM1.227 DM1.230 DM1.231 DM1.234 DM1.235 DM1.238 DM1.239 DM1.243 DM1.244 DM1.247 DM1.248 DM1.251 DM1.252 DM1.261 DM1.262 DM2.1 DM2.2 DM2.5 DM2.6 DM2.9 DM2.10 DM2.14 DM2.15 DM2.18 DM2.19 DM2.22 DM2.23 DM2.26 DM2.27 DM2.30 DM2.31 DM2.35 DM2.36 DM2.39 DM2.40 DM2.43 DM2.44 DM2.47 DM2.48 DM2.51 DM2.52 DM2.56 DM2.57 DM2.60 DM2.61 DM2.64 DM2.65 DM2.68 DM2.69 DM2.72 DM2.73 DM2.77 DM2.78 DM2.81 DM2.82 DM2.85 DM2.86 DM2.89 DM2.90 DM2.93 DM2.94 DM2.98 DM2.99 DM2.102 DM2.103 DM2.106 DM2.107 DM2.167 DM2.168 DM2.171 DM2.172 DM2.175 DM2.176 DM2.180 DM2.181 DM2.184 DM2.185 DM2.188 DM2.189 DM2.192 DM2.193 DM2.196 DM2.197 DM2.201 DM2.202 DM2.205 DM2.206 DM2.209 DM2.210 DM2.213 DM2.214 DM2.217 DM2.218 DM2.222 DM2.223 DM2.226 DM2.227 DM2.230 DM2.231 DM2.234 DM2.235 DM2.238 DM2.239 DM2.243 DM2.244 DM2.247 DM2.248 DM2.251 DM2.252 DM2.261 DM2.262 EC1201.2 EC1202.2 EC1301.2 EC1706.2 EC1707.2 EC1712.2 EC1801.2 EC1803.1 EC1804.2 EC1901.1 EC1903.2 EC2002.2 EC2201.2 EC2401.2 EC2701.2 EC2702.2 EC2703.2 EC2704.2 EC2705.2 EC2709.2 EC2710.2 EC2711.2 EC2901.2 EC2902.2 EC2903.2 EC2904.2 EC3513.2 EC4306.1 EC4307.2 EC4308.2 EC4309.2 EC4310.2 EC4311.2 EC4534.2 EC5501.2 EC5502.2 EC5503.2 EC5504.2 EC5505.3 EC5505.8 EC6401.2 EC6402.2 EC6403.2 EC6404.2 EC6501.2 EC6502.2 EC6503.2 EC6504.2 EC6505.2 EC6506.2 EC6801.2 EC8901.2 EC8902.2 EC8903.2 EC8904.2 EC8905.2 EC8906.2 EC8907.2 EC8908.2 EC8909.2 EC8910.2 EC8911.2 EC8912.2 EC8913.2 EC8914.2 EC8915.2 EC8917.2 EC8919.2 EC8925.2 EC8928.2 EC8929.2 EC8933.2 EC8934.2 EC8935.2 EC8936.2 EC8937.2 EC8938.2 EC8939.2 EC8947.2 EC8948.2 EC8949.2 EC8950.2 EC8951.2 EC8952.2 EC8953.2 EC8954.2 EC8957.2 EC8958.2 EC8959.2 EC8960.2 EC8961.2 EC8962.1 EC8963.2 EC8965.2 EC8966.2 EC8967.2 EC8968.2 ED301.3 ED502.3 ED1217.2 ED1302.2 ED1701.3 ED1702.3 ED1703.3 ED1704.3 ED1801.3 ED2907.2 ED2908.2 ED2909.2 ED2910.2 ED2911.2 ED2912.2 ED3501.3 ED3501.8 ED3502.2 ED3504.3 ED3504.8 ED4001.3 ED5701.3 ED5701.8 ED5702.3 ED5702.8 ED5703.3 ED5703.8 ED6001.3 ED6001.8 ED6301.3 ED6301.8 ED6401.2 ED7301.3 ED7301.8 ED7302.3 ED7302.8 ED7303.3 ED7304.3 ED7305.3 ED7306.3 ED7307.2 EL4303.2 EL4304.2 FAN1.2 FAN1.5 FAN1.6 FC1102.2 FC1103.2 FC1801.1 FC6101.2 FC8901.2 FC8902.2 FC8903.2 FC8904.2 FC8905.2 FC8906.2 FC8907.2 FC8908.2 FC8909.2 FC8910.2 FC8911.2 FC8912.2 FC8913.2 FC8914.2 FC8915.2 FC8916.2 FC8917.2 FC8918.2 FC8919.2 FC8920.2 FC8921.2 FC8922.2 FC8923.2 FC8924.2 FC8925.2 FC8926.2 FC8927.2 FC8928.2 FC8929.2 FC8930.2 G1801.1 G6401.2 G6402.2 GPU1.A2 GPU1.A26 GPU1.AA7 GPU1.AB7 GPU1.AB11 GPU1.AB14 GPU1.AB17 GPU1.AB20 GPU1.AB24 GPU1.AC2 GPU1.AC5 GPU1.AC8 GPU1.AC22 GPU1.AC26 GPU1.AD12 GPU1.AD13 GPU1.AD15 GPU1.AD16 GPU1.AD18 GPU1.AD19 GPU1.AD21 GPU1.AD22 GPU1.AE11 GPU1.AE14 GPU1.AE17 GPU1.AE20 GPU1.AF1 GPU1.AF5 GPU1.AF8 GPU1.AF11 GPU1.AF14 GPU1.AF17 GPU1.AF20 GPU1.AF23 GPU1.AG2 GPU1.AG26 GPU1.B1 GPU1.B5 GPU1.B8 GPU1.B11 GPU1.B14 GPU1.B17 GPU1.B20 GPU1.B23 GPU1.B27 GPU1.E2 GPU1.E5 GPU1.E8 GPU1.E11 GPU1.E14 GPU1.E17 GPU1.E20 GPU1.E22 GPU1.E25 GPU1.H2 GPU1.H5 GPU1.H23 GPU1.H25 GPU1.K11 GPU1.K13 GPU1.K15 GPU1.K17 GPU1.L2 GPU1.L5 GPU1.L10 GPU1.L12 GPU1.L14 GPU1.L16 GPU1.L18 GPU1.L23 GPU1.L25 GPU1.M11 GPU1.M13 GPU1.M15 GPU1.M17 GPU1.N10 GPU1.N12 GPU1.N14 GPU1.N16 GPU1.N18 GPU1.P2 GPU1.P5 GPU1.P11 GPU1.P13 GPU1.P15 GPU1.P17 GPU1.P23 GPU1.P26 GPU1.R10 GPU1.R12 GPU1.R14 GPU1.R16 GPU1.R18 GPU1.T11 GPU1.T13 GPU1.T15 GPU1.T17 GPU1.U2 GPU1.U5 GPU1.U10 GPU1.U12 GPU1.U14 GPU1.U16 GPU1.U18 GPU1.U23 GPU1.U26 GPU1.V11 GPU1.V13 GPU1.V15 GPU1.V17 GPU1.Y2 GPU1.Y5 GPU1.Y23 GPU1.Y26 H1.1 H2.1 H3.1 H4.1 H5.1 H6.1 H7.1 H8.1 H9.1 H10.1 H11.1 H12.1 H13.1 H14.1 H15.1 H17.1 HDD1.1 HDD1.4 HDD1.7 HDD1.13 HDD1.14 HDMI1.2 HDMI1.5 HDMI1.8 HDMI1.11 HDMI1.17 HDMI1.20 HDMI1.21 HDMI1.22 HDMI1.23 HS1.1 IOBD1.16 IOBD1.19 IOBD1.22 IOBD1.38 IOBD1.41 IOBD1.42 IOBD1.43 IOBD1.44 KB1.1 KB1.31 KB1.32 KB_BL1.5 KB_BL1.6 LCD1.9 LCD1.12 LCD1.15 LCD1.18 LCD1.32 LCD1.33 LCD1.41 LCD1.42 LCD1.43 LCD1.44 LED1.3 PC1001.2 PC1002.2 PC1003.2 PC1004.2 PC1005.2 PC1006.2 PC1007.2 PC1008.2 PC1009.2 PC1010.2 PC1011.2 PC1012.2 PC1013.2 PC1014.2 PC1015.2 PC1016.2 PC1017.2 PC1018.2 PC1019.2 PC1020.2 PC1021.2 PC1022.2 PC1023.2 PC1024.2 PC1025.2 PC1026.2 PC1027.2 PC1028.2 PC1029.2 PC1030.2 PC1031.2 PC1032.2 PC1034.2 PC1036.2 PC1037.2 PC1038.2 PC1039.2 PC1040.2 PC1041.2 PC1042.2 PC1043.2 PC1044.2 PC1045.2 PC1046.2 PC1047.2 PC1048.2 PC1049.2 PC1050.2 PC1051.2 PC1052.2 PC1053.2 PC1054.2 PC1055.2 PC1056.2 PC1057.2 PC1058.2 PC1059.2 PC1060.2 PC1061.2 PC1062.2 PC1063.2 PC1064.2 PC1065.2 PC1066.2 PC1067.2 PC1068.2 PC1069.2 PC1070.2 PC1071.2 PC1072.2 PC1073.2 PC1074.2 PC1075.2 PC1076.2 PC1077.2 PC1078.2 PC1079.2 PC1080.2 PC1081.2 PC1082.2 PC1083.2 PC1084.2 PC4401.2 PC4402.2 PC4403.2 PC4404.2 PC4405.2 PC4406.2 PC4407.2 PC4408.2 PC4409.2 PC4410.2 PC4411.2 PC4412.2 PC4413.2 PC4414.2 PC4416.1 PC4417.1 PC4418.2 PC4419.2 PC4420.1 PC4421.2 PC4422.2 PC4424.1 PC4426.1 PC4427.2 PC4429.2 PC4430.2 PC4431.2 PC4432.2 PC4433.2 PC4434.2 PC4435.2 PC4437.2 PC4439.1 PC4440.1 PC4441.2 PC4447.2 PC4501.2 PC4502.2 PC4503.2 PC4504.2 PC4505.2 PC4507.2 PC4508.2 PC4509.2 PC4510.2 PC4511.2 PC4512.2 PC4513.2 PC4514.2 PC4515.2 PC4516.2 PC4517.2 PC4518.2 PC4519.2 PC4520.2 PC4522.2 PC4523.2 PC4524.2 PC4525.2 PC4527.2 PC4529.2 PC4530.2 PC4531.2 PC4532.2 PC4601.2 PC4602.2 PC4603.1 PC4604.1 PC4606.2 PC4607.2 PC4610.1 PC4612.2 PC4613.2 PC4614.2 PC4615.1 PC4620.2 PC4621.1 PC4622.2 PC4624.2 PC4629.1 PC4631.2 PC4633.2 PC4637.2 PC4638.2 PC4639.2 PC4640.2 PC4641.2 PC4644.2 PC4651.2 PC4701.2 PC4702.2 PC4703.2 PC4704.2 PC4706.2 PC4708.2 PC4766.2 PC4802.2 PC4803.2 PC4804.2 PC4805.2 PC4809.2 PC4810.2 PC4812.2 PC4813.2 PC4814.2 PC4815.2 PC4816.2 PC4817.2 PC4866.2 PC4877.2 PC5001.2 PC5002.2 PC5003.2 PC5004.2 PC5104.2 PC5105.2 PC5107.2 PC5108.2 PC5109.2 PC5111.2 PC5112.2 PC5113.2 PC5115.2 PC5116.2 PC5117.2 PC5118.2 PC5122.2 PC5124.2 PC5125.2 PC5127.2 PC5128.2 PC5129.2 PC5130.2 PC5201.2 PC5202.2 PC5203.2 PC5205.2 PC5206.2 PC5208.2 PC5209.2 PC5210.2 PC5211.2 PC5213.2 PC5214.2 PC5215.2 PC5216.2 PC5302.2 PC5303.2 PC5304.2 PC5305.2 PC5306.2 PC8501.2 PC8502.2 PC8503.2 PC8504.2 PC8505.2 PC8506.2 PC8507.1 PC8508.2 PC8510.1 PC8511.2 PC8512.2 PC8513.2 PC8515.2 PC8516.2 PC8518.2 PC8520.2 PC8522.1 PC8523.2 PC8525.2 PC8526.1 PC8609.2 PC8610.2 PC8611.2 PC8613.2 PC8614.2 PC8615.2 PC8616.2 PC8617.2 PC8618.2 PC8620.2 PC8621.2 PC8627.2 PC8628.2 PC8629.2 PC8630.2 PC8631.2 PD5101.A PDA1.1 PDA2.1 PQ4402.S PQ4405.1 PQ4405.4 PQ4415.1 PQ4415.4 PQ4416.1 PQ4416.4 PQ4417.S PQ4418.1 PQ4418.4 PR4406.2 PR4410.1 PR4413.2 PR4417.1 PR4426.2 PR4436.2 PR4447.2 PR4451.2 PR4453.1 PR4465.1 PR4474.1 PR4475.2 PR4485.2 PR4492.2 PR4494.2 PR4508.2 PR4512.2 PR4513.2 PR4514.2 PR4530.1 PR4551.2 PR4608.1 PR4614.2 PR4617.2 PR4621.1 PR4627.1 PR4628.2 PR4629.2 PR4639.2 PR4644.2 PR4654.2 PR4655.1 PR4659.1 PR4661.2 PR4672.1 PR4712.2 PR4817.2 PR4818.2 PR5101.2 PR5113.2 PR5115.2 PR5203.2 PR5204.2 PR5302.2 PR5306.2 PR8508.2 PR8517.2 PR8521.2 PR8577.2 PR8620.2 PR8626.2 PR8632.1 PT4701.2 PT4702.2 PT4801.2 PT4803.2 PT4805.2 PT8501.2 PT8502.2 PT8503.2 PU4401.33 PU4404.1 PU4404.2 PU4404.3 PU4406.1 PU4406.2 PU4406.3 PU4501.7 PU4501.8 PU4501.18 PU4501.21 PU4502.7 PU4502.8 PU4502.18 PU4502.21 PU4601.41 PU4701.12 PU4701.13 PU4701.14 PU4701.15 PU4701.28 PU4701.32 PU4701.34 PU4801.12 PU4801.13 PU4801.14 PU4801.15 PU4801.28 PU4801.32 PU4801.34 PU4802.12 PU4802.13 PU4802.14 PU4802.15 PU4802.28 PU4802.32 PU4802.34 PU5001.4 PU5001.9 PU5003.1 PU5003.2 PU5003.3 PU5101.4 PU5101.11 PU5101.12 PU5101.13 PU5101.14 PU5101.15 PU5101.16 PU5101.30 PU5101.32 PU5101.33 PU5102.1 PU5201.4 PU5201.12 PU5201.13 PU5201.14 PU5201.15 PU5201.19 PU5301.1 PU8510.5 PU8510.6 PU8510.7 PU8512.5 PU8512.6 PU8512.7 PU8514.21 PU8515.5 PU8515.6 PU8515.7 PU8516.5 PU8516.6 PU8516.7 PU8602.7 PU8602.8 PU8602.18 PU8602.21 PU8603.4 PU8603.8 PU8603.9 Q401.1 Q401.4 Q501.S Q502.S Q1701.1 Q1701.4 Q1702.1 Q1702.4 Q1802.S Q2001.1 Q2001.4 Q2408.S Q2501.S Q2510.S Q2705.S Q4001.1 Q4001.4 Q4302.E Q4304.E Q4349.1 Q4349.4 Q5701.S Q6102.S Q6501.S Q6505.S Q7001.1 Q7001.4 Q7404.1 Q7404.4 Q7405.4 Q7406.1 Q7406.4 Q7407.1 Q7407.4 Q7907.1 Q7907.4 Q8101.S Q8504.S Q8509.1 Q8509.4 Q8602.S Q8603.S Q8604.S Q8605.S Q8606.1 Q8606.4 Q8607.1 Q8607.4 Q8608.1 Q8608.4 Q8609.1 Q8609.4 R304.2 R305.2 R316.2 R317.2 R318.2 R403.1 R501.2 R502.2 R503.2 R601.2 R720.2 R808.2 R809.2 R1205.1 R1209.2 R1210.1 R1212.1 R1303.1 R1307.1 R1309.2 R1311.1 R1501.1 R1503.2 R1505.2 R1507.2 R1509.2 R1511.2 R1514.2 R1516.2 R1517.2 R1518.2 R1519.2 R1521.2 R1523.2 R1524.2 R1527.2 R1552.2 R1553.2 R1555.2 R1603.2 R1714.2 R1715.2 R1717.2 R1719.2 R1723.2 R1803.2 R1816.2 R1901.2 R1911.2 R1912.2 R2002.1 R2008.2 R2009.2 R2037.2 R2051.2 R2101.2 R2108.2 R2112.2 R2114.2 R2116.2 R2118.2 R2120.2 R2404.2 R2417.2 R2426.1 R2436.2 R2445.1 R2448.2 R2449.2 R2455.2 R2503.2 R2504.2 R2518.2 R2611.2 R2704.2 R2705.2 R2706.2 R2735.2 R3603.1 R3604.1 R4006.2 R4019.2 R4048.2 R4301.1 R4302.2 R4308.2 R4315.1 R4316.2 R4377.2 R4379.2 R5506.2 R5528.2 R5531.2 R5547.2 R5553.1 R5707.1 R5709.2 R5711.2 R6133.2 R6134.2 R6304.2 R6505.2 R6507.2 R6513.2 R7007.1 R7220.2 R7221.2 R7222.2 R7223.2 R7226.2 R7229.2 R7230.2 R7231.2 R7232.1 R7237.2 R7242.2 R7243.2 R7245.2 R7248.2 R7249.2 R7302.1 R7308.2 R7309.2 R7319.2 R7321.2 R7322.2 R7324.2 R7340.2 R7342.2 R7343.2 R7401.2 R7407.2 R7408.2 R7409.2 R7422.2 R7428.2 R7430.2 R7601.2 R7602.2 R7606.2 R7806.2 R7807.2 R7818.2 R7820.1 R7821.1 R7901.2 R7902.2 R7907.1 R7908.2 R7910.2 R7911.2 R7915.2 R7921.2 R7924.2 R7926.2 R7927.2 R7929.2 R7932.2 R7939.2 R7975.2 R7977.1 R8103.2 R8106.2 R8107.2 R8108.2 R8109.1 R8110.1 R8112.1 R8534.2 R8604.2 R9137.1 R9142.2 RN1201.2(A) RN1301.2(A) RN1602.3(B) RN1602.4(B) RN1703.1(A) RN1703.2(A) RN2009.1(A) RN2009.2(A) RN5502.2(A) RN5502.6(B) RN5502.8(B) RN7203.1(A) RN7203.2(A) RN7203.3(A) RN7203.4(A) RN7204.3(B) RN7204.4(B) RN7701.3(B) RN7701.4(B) RTC1.2 RTC1.3 RTC1.4 SBD1.5 SBD1.8 SBD1.11 SBD1.12 SKT251.4 SPK1.5 SPK1.6 SPR1.1 SPR2.1 SSD1.1 SSD1.3 SSD1.9 SSD1.15 SSD1.21 SSD1.27 SSD1.33 SSD1.39 SSD1.45 SSD1.51 SSD1.57 SSD1.71 SSD1.73 SSD1.75 SSD1.76 SSD1.77 TC3502.2 THM261.5 TPAD1.5 TPAD1.9 TPAD1.10 U2401.17 U2401.51 U2401.64 U2401.84 U2401.100 U2401.124 U2501.4 U2502.2 U2701.41 U3403.2 U3502.2 U3601.14 U3601.17 U4001.11 U4001.15 U4002.5 U4003.11 U4003.15 U4004.5 U4006.5 U4007.3 U4302.3 U5501.2 U5502.2 U6402.3 U7001.5 U7001.6 U7001.7 U7001.8 U7204.A1 U7204.A6 U7204.A7 U7204.A8 U7204.B7 U7204.B8 U7204.D8 U7204.E5 U7204.E6 U7204.E7 U7204.E8 U7204.F5 U7204.F6 U7204.F7 U7204.F8 U7204.G5 U7204.G6 U7204.G7 U7204.G8 U7204.H4 U7204.H5 U7204.H8 U7204.L1 U7205.4 U7205.9 U7301.41 U7419.B3 U7419.C3 U7419.D3 U7419.E3 U7601.3 U8502.3 U8601.11 U8601.15 U8604.3 U8605.3 U9101.16 U9101.23 U9101.32 U9101.33 USB1.13 USB1.14 USB1.15 USB1.16 USB1.17 USB1.18 USB1.19 USB1.20 USB1.21 USB1.22 USB1.A1 USB1.A12 USB1.B1 USB1.B12 USB3.4 USB3.7 USB3.10 USB3.11 USB3.12 USB3.13 USB4.4 USB4.7 USB4.10 USB4.11 USB4.12 USB4.13 VRAM1.A1 VRAM1.A3 VRAM1.A12 VRAM1.A14 VRAM1.B5 VRAM1.B10 VRAM1.C1 VRAM1.C3 VRAM1.C4 VRAM1.C11 VRAM1.C12 VRAM1.C14 VRAM1.D10 VRAM1.E1 VRAM1.E3 VRAM1.E12 VRAM1.E14 VRAM1.F5 VRAM1.F10 VRAM1.G5 VRAM1.G10 VRAM1.H1 VRAM1.H2 VRAM1.H13 VRAM1.H14 VRAM1.K1 VRAM1.K2 VRAM1.K13 VRAM1.K14 VRAM1.L5 VRAM1.L10 VRAM1.M5 VRAM1.M10 VRAM1.N1 VRAM1.N3 VRAM1.N12 VRAM1.N14 VRAM1.P10 VRAM1.R1 VRAM1.R3 VRAM1.R4 VRAM1.R11 VRAM1.R12 VRAM1.R14 VRAM1.T5 VRAM1.T10 VRAM1.U1 VRAM1.U3 VRAM1.U12 VRAM1.U14 VRAM4.A1 VRAM4.A3 VRAM4.A12 VRAM4.A14 VRAM4.B5 VRAM4.B10 VRAM4.C1 VRAM4.C3 VRAM4.C4 VRAM4.C11 VRAM4.C12 VRAM4.C14 VRAM4.D10 VRAM4.E1 VRAM4.E3 VRAM4.E12 VRAM4.E14 VRAM4.F5 VRAM4.F10 VRAM4.G5 VRAM4.G10 VRAM4.H1 VRAM4.H2 VRAM4.H13 VRAM4.H14 VRAM4.K1 VRAM4.K2 VRAM4.K13 VRAM4.K14 VRAM4.L5 VRAM4.L10 VRAM4.M5 VRAM4.M10 VRAM4.N1 VRAM4.N3 VRAM4.N12 VRAM4.N14 VRAM4.P10 VRAM4.R1 VRAM4.R3 VRAM4.R4 VRAM4.R11 VRAM4.R12 VRAM4.R14 VRAM4.T5 VRAM4.T10 VRAM4.U1 VRAM4.U3 VRAM4.U12 VRAM4.U14 WLAN1.1 WLAN1.7 WLAN1.13 WLAN1.18 WLAN1.19 WLAN1.33 WLAN1.39 WLAN1.45 WLAN1.51 WLAN1.57 WLAN1.63 WLAN1.69 WLAN1.75 WLAN1.76 WLAN1.77 X7901.2 X7901.4
V0.85A_VID0: CPU1.CB36 TP2201.1
V0.85A_VID1: CPU1.CB35 TP2202.1
V3D3_STB: R2708.2 U2701.16
VBUS_P_CTRL: Q7404.2 U7204.D7
VBUS_P_CTRL_R: Q7404.5 Q7404.6 R7409.1 R7423.2
VCC_SENSE: CPU1.AN6 PR4665.1 R719.2
VCCDSW_ON: C2525.1 D2503.2 R2520.2 U2401.88
VCCGT_SENSE: CPU1.E3 PR4667.1 R807.2
VCCIO_EN_R: C4033.1 D4004.A R4003.2 R4017.2 R4037.2 R4039.1 U4002.4
VCCPD_VBUS_ACK: PQ4417.G R7424.2 U7419.A2
VCCRTCEXT: C2201.1 CPU1.BP24
VCCSA_SENSE: CPU1.BG7 PR4601.2 R810.2
VCCST_PWRGD: D4002.A D4003.A ED1704.1 R1716.1 R2421.1 R4002.1 R4005.2 R4011.2
VCCST_PWRGD_R: C1711.1 CPU1.BJ2 ED1704.2 R1716.2 R1718.1 R1719.1
VCCSTG_EN_L: R4037.1 U4007.4
VCCSTU_EN_R: C4034.1 R4024.2 U4006.4
VDD: PC4422.1 PR4405.2 PR4427.1 PR4429.1 PR4448.1 PR4449.1 PU4401.18
VSS_SENSE: CPU1.AN5 PR4666.1 R720.1
VSSGT_SENSE: CPU1.D2 PR4668.1 R808.1
VSSSA_SENSE: CPU1.BE7 PR4602.2 R809.1
0D6V_S0: C1224.1 C1225.1 C1226.1 C1227.1 C1230.1 C1233.1 C1324.1 C1325.1 C1326.1 C1327.1 DM1.258 DM2.258 PG5120.1 PG5121.1
1D0V_PWR: PC5201.1 PC5203.1 PC5205.1 PC5206.1 PC5208.1 PG5201.1 PG5204.1 PG5206.1 PG5207.1 PG5208.1 PG5209.1 PG5211.1 PG5213.1 PG5215.1 PG5216.1 PG5223.2 PL5201.2
1D0V_S5: C1112.1 C1114.1 C1115.1 C1116.1 C1117.1 C1118.1 C1119.1 C1120.1 C1121.1 C1128.1 C1129.1 C2212.1 C2214.1 C2215.1 C2216.1 C2217.1 C2223.1 C4013.1 C4035.1 C4036.1 C4045.1 CPU1.BP14 CPU1.BP20 CPU1.BP22 CPU1.BR12 CPU1.BR14 CPU1.BR15 CPU1.BR20 CPU1.BT12 CPU1.BT18 CPU1.BT19 CPU1.BT22 CPU1.BU12 CPU1.BU14 CPU1.BU15 CPU1.BU18 CPU1.BU19 CPU1.BU22 CPU1.BV15 CPU1.BV16 CPU1.BV18 CPU1.BV19 CPU1.BV20 CPU1.BV22 CPU1.BW16 CPU1.BW18 CPU1.BW19 CPU1.BW20 CPU1.BW22 CPU1.BY16 CPU1.BY20 CPU1.CA12 CPU1.CA14 CPU1.CA16 CPU1.CA18 CPU1.CA19 CPU1.CA20 CPU1.CB12 CPU1.CB14 CPU1.CB15 CPU1.CC12 EC2201.1 FC8911.1 FC8912.1 FC8913.1 FC8914.1 FC8915.1 PG5201.2 PG5204.2 PG5206.2 PG5207.2 PG5208.2 PG5209.2 PG5211.2 PG5213.2 PG5215.2 PG5216.2 R2202.1 R2203.1 R2205.1 R2402.1 U4002.1 U4002.2 U4002.9 U4006.1 U4006.2 U4006.9
1D0V_S5_PWRGD: PR5206.1 R4029.1
1D0V_VCCA_XTAL: C2219.1 CPU1.CP5 R2202.2
1D0V_VCCAMPHYPLL: C2208.1 C2209.1 CPU1.BV2 R2205.2
1D0V_VCCDSW: C2213.1 CPU1.BT24
1D0V_VCCPRIM_MPHY: C2220.1 CPU1.BV12 CPU1.BV14 CPU1.BW12 CPU1.BW14 CPU1.BY12 CPU1.BY14 R2203.2
1D2V_S3: C804.1 C1130.1 C1131.1 C1132.1 C1136.1 C1137.1 C1138.1 C1139.1 C1140.1 C1141.1 C1142.1 C1202.1 C1203.1 C1204.1 C1205.1 C1206.1 C1208.1 C1209.1 C1210.1 C1214.1 C1215.1 C1216.1 C1217.1 C1218.1 C1219.1 C1220.1 C1221.1 C1303.1 C1304.1 C1305.1 C1306.1 C1307.1 C1308.1 C1309.1 C1310.1 C1315.1 C1316.1 C1317.1 C1318.1 C1319.1 C1320.1 C1321.1 C1322.1 C4008.1 C4043.1 CPU1.AD36 CPU1.AH32 CPU1.AH36 CPU1.AM36 CPU1.AN32 CPU1.AW32 CPU1.AY36 CPU1.BE32 CPU1.BH36 CPU1.R32 CPU1.Y36 DM1.12 DM1.33 DM1.54 DM1.75 DM1.96 DM1.111 DM1.112 DM1.117 DM1.118 DM1.123 DM1.124 DM1.129 DM1.130 DM1.135 DM1.136 DM1.141 DM1.142 DM1.147 DM1.148 DM1.153 DM1.154 DM1.159 DM1.160 DM1.163 DM1.178 DM1.199 DM1.220 DM1.241 DM2.12 DM2.33 DM2.54 DM2.75 DM2.96 DM2.111 DM2.112 DM2.117 DM2.118 DM2.123 DM2.124 DM2.129 DM2.130 DM2.135 DM2.136 DM2.141 DM2.142 DM2.147 DM2.148 DM2.153 DM2.154 DM2.159 DM2.160 DM2.163 DM2.178 DM2.199 DM2.220 DM2.241 EC1201.1 EC1202.1 EC1301.1 EC8901.1 EC8902.1 EC8903.1 EC8904.1 EC8905.1 EC8906.1 EC8907.1 EC8908.1 EC8909.1 EC8910.1 EC8911.1 EC8912.1 EC8913.1 EC8914.1 EC8915.1 FC1102.1 FC1103.1 PG5106.2 PG5107.2 PG5108.2 PG5109.2 PG5110.1 PG5111.2 PG5115.2 PG5116.1 R505.1 R1215.1 R1312.1 R4040.1 RN1201.1(A) RN1301.1(A) U4004.1 U4004.2 U4004.9
1D2V_VCCSFR_OC: C803.2 CPU1.BL27 CPU1.BM26 R4043.2
1D2V_VTT_PWRGD: PR5109.1 R4011.1
1D8V_AON_S0_DISCHG: Q8608.3 R8644.2
1D8V_CPVDD: C2704.1 C2705.1 R2709.2 U2701.29
1D8V_EN#: Q2705.D R2736.2 R2738.1
1D8V_EN_R#: C2738.2 Q2704.G R2738.2
1D8V_PWR: PC5301.1 PC5302.1 PC5303.1 PG5301.1 PG5302.1 PG5303.1 PR5303.1 PU5301.3 PU5301.4
1D8V_S0: C2736.1 Q2704.D R2052.1 R2709.1 R2719.1 R6401.1 R8602.1
1D8V_S5: C2737.1 C2738.1 C6402.1 PG5301.2 PG5302.2 PG5303.2 Q2704.S R1104.1 R1515.1 R2029.1 R2030.1 R2462.1 R2497.2 R2736.1 R6115.1 U6402.5
1D8V_S5_KBC: C2423.1 R2462.2 U2401.54
1D8V_VCCPRIM: C1122.1 C2210.1 C2211.1 CPU1.CC15 CPU1.CC18 CPU1.CC19 CPU1.CD15 CPU1.CD16 CPU1.CD18 CPU1.CD19 CPU1.CP17 CPU1.CP23 R1104.2 R1512.1 R1738.1 R1821.1 R2053.1 R2111.1 R2113.1 R2115.1 R2117.1
1D8V_VGA_EN: R8603.1 R8629.2
1D8V_VGA_EN_OR: Q8602.D R8629.1 R8637.2
1D8V_VGA_EN_OR#: Q8602.G Q8603.G Q8606.3 Q8606.6 R8634.2
1D8V_VGA_EN_R: C8602.1 R8603.2 U8601.3
1D8V_VGA_PLL: C7906.1 C7935.1 GPU1.L6 L7901.2 L8001.1
1D8V_VGA_S0_DISCHG: Q8603.D R8647.2
1D24V_VCCDPHY: CPU1.BY23 CPU1.BY24 CPU1.CA23 CPU1.CA24
1D24V_VCCDPHY_EC: C2218.1 CPU1.CP25
1D35V_PGOOD: PR8635.1 R8530.1
1D35V_PGOOD_L: R8530.2 U8502.2
1D35V_PWR: PC8611.1 PC8613.1 PC8614.1 PC8620.1 PC8621.1 PG8609.1 PG8610.1 PG8611.1 PG8612.1 PG8613.1 PG8618.1 PG8619.1 PG8620.1 PG8621.1 PL8603.2
1D35V_VGA_EN: D8601.3 PR8631.1 Q8609.2 R8604.1
1D35V_VGA_EN#: Q8609.5 Q8609.6 R8645.1
1D35V_VGA_S0: C7801.1 C7802.1 C7807.2 C7813.1 C7814.1 C7817.1 C7820.1 C7825.2 C7826.2 C7827.2 C7828.2 C7829.2 C7830.2 C7831.2 C7832.1 C7833.1 C7834.1 C7835.1 C8101.1 C8102.1 C8103.1 C8104.1 C8105.1 C8106.1 C8107.1 C8108.1 C8109.1 C8110.1 C8111.1 C8112.1 C8113.1 C8114.1 C8115.1 C8116.1 C8117.1 C8118.1 C8119.1 C8120.1 C8121.1 C8122.1 C8123.1 C8124.1 C8125.1 C8126.1 C8127.1 C8128.1 C8129.1 C8130.1 C8131.1 C8132.1 C8143.1 C8144.1 C8145.1 C8146.1 GPU1.B26 GPU1.C25 GPU1.E23 GPU1.E26 GPU1.F14 GPU1.F21 GPU1.G13 GPU1.G14 GPU1.G15 GPU1.G16 GPU1.G18 GPU1.G19 GPU1.G20 GPU1.G21 GPU1.H24 GPU1.H26 GPU1.J21 GPU1.K21 GPU1.L22 GPU1.L24 GPU1.L26 GPU1.M21 GPU1.N21 GPU1.R21 GPU1.T21 GPU1.V21 GPU1.W21 PG8609.2 PG8610.2 PG8611.2 PG8612.2 PG8618.2 PG8619.2 PG8620.2 PG8621.2 R7801.2 R7803.2 R7805.2 R7816.2 R7824.2 R8101.1 R8104.1 R8111.2 R8646.1 VRAM1.B1 VRAM1.B3 VRAM1.B12 VRAM1.B14 VRAM1.C5 VRAM1.C10 VRAM1.D1 VRAM1.D3 VRAM1.D11 VRAM1.D12 VRAM1.D14 VRAM1.E5 VRAM1.E10 VRAM1.F1 VRAM1.F3 VRAM1.F12 VRAM1.F14 VRAM1.G1 VRAM1.G2 VRAM1.G4 VRAM1.G11 VRAM1.G13 VRAM1.G14 VRAM1.H3 VRAM1.H12 VRAM1.K3 VRAM1.K12 VRAM1.L1 VRAM1.L2 VRAM1.L4 VRAM1.L11 VRAM1.L13 VRAM1.L14 VRAM1.M1 VRAM1.M3 VRAM1.M12 VRAM1.M14 VRAM1.N5 VRAM1.N10 VRAM1.P1 VRAM1.P3 VRAM1.P11 VRAM1.P12 VRAM1.P14 VRAM1.R5 VRAM1.R10 VRAM1.T1 VRAM1.T3 VRAM1.T12 VRAM1.T14 VRAM4.B1 VRAM4.B3 VRAM4.B12 VRAM4.B14 VRAM4.C5 VRAM4.C10 VRAM4.D1 VRAM4.D3 VRAM4.D11 VRAM4.D12 VRAM4.D14 VRAM4.E5 VRAM4.E10 VRAM4.F1 VRAM4.F3 VRAM4.F12 VRAM4.F14 VRAM4.G1 VRAM4.G2 VRAM4.G4 VRAM4.G11 VRAM4.G13 VRAM4.G14 VRAM4.H3 VRAM4.H12 VRAM4.K3 VRAM4.K12 VRAM4.L1 VRAM4.L2 VRAM4.L4 VRAM4.L11 VRAM4.L13 VRAM4.L14 VRAM4.M1 VRAM4.M3 VRAM4.M12 VRAM4.M14 VRAM4.N5 VRAM4.N10 VRAM4.P1 VRAM4.P3 VRAM4.P11 VRAM4.P12 VRAM4.P14 VRAM4.R5 VRAM4.R10 VRAM4.T1 VRAM4.T3 VRAM4.T12 VRAM4.T14
1D35V_VGA_S0_DISCHG: Q8609.3 R8646.2
2D5V_S3: C1207.1 C1211.1 C1212.1 C1213.1 C1231.1 C1232.1 C1311.1 C1312.1 C1313.1 C1314.1 C1330.1 C1331.1 DM1.257 DM1.259 DM2.257 DM2.259 PG5122.2 PG5123.2
3D3V_1D8V_AON_S0: C8004.1 C8035.1 C8036.1 C8089.1 C8607.1 GPU1.G10 GPU1.G12 PR8505.1 PR8515.1 PR8522.1 Q7906.G Q8601.G R7603.2 R7614.1 R7905.2 R7909.1 R7912.1 R7914.1 R7917.1 R7919.1 R7925.1 R7928.1 R7931.1 R7933.1 R7938.1 R7943.2 R7949.2 R7978.2 R8609.1 R8637.1 R8644.1 RN7901.3(B) RN7901.4(B) RN7910.3(B) RN7910.4(B) U7601.5 U8601.8 U8601.9
3D3V_1D8V_S0: C8601.1 C8604.1 R8601.2 R8602.2 U8601.1 U8601.2 U8601.6 U8601.7
3D3V_1D8V_VGA_S0: C8003.1 C8028.1 C8029.1 C8034.1 C8606.1 GPU1.G8 GPU1.G9 Q7601.G R7913.1 R7957.1 R8529.2 R8608.1 R8610.1 R8647.1 U8601.13 U8601.14
3D3V_AUX_S5: PG4532.2 PR4503.1 PR4505.1 R1726.2 R1727.1 R1737.1 R2453.1 R2473.1 R2502.2 R4004.1 R7952.2 R8640.1 R8643.2 R8645.2
3D3V_CAMERA_S0: C5539.1 EC5503.1 F5504.2 LCD1.26
3D3V_ECVBAT: C2428.1 R2451.1 R2452.1 R2472.2 R2473.2 U2401.122
3D3V_FLASH: C7228.1 C7244.1 R7233.1 R7244.1 R7252.1 R7253.1 R7254.1 R7255.1 U7204.G1 U7205.8
3D3V_GSEN2: C7003.1 C7004.1 R7004.2 R7005.1 R7006.2 U7001.9 U7001.10
3D3V_LCDVDD_R: R5523.2 U5501.3
3D3V_LCDVDD_S0: C5536.1 C5538.1 C5599.1 LCD1.4 LCD1.5 LCD1.6 LCD1.7 R5523.1
3D3V_LDO_SET: R5547.1 R5548.2 U5502.4
3D3V_MUX: C7315.1 C7316.1 C7317.1 C7318.1 C7319.1 R7301.1 R7303.2 R7306.1 R7307.1 R7318.1 R7320.1 R7323.1 R7325.1 R7327.1 R7341.1 R7344.1 U7301.1 U7301.6 U7301.20 U7301.28
3D3V_PD: R7250.2 U7204.B1 U7204.H1
3D3V_RTC: C2503.1 D2501.3 Q2507.S R2472.1 R2512.1 R2708.1
3D3V_RTC_SYS: D2501.1 R2502.1 R2503.1
3D3V_S0: C1223.1 C1228.1 C1328.1 C1329.1 C2601.1 C2602.1 C4006.1 DBG1.10 DM1.255 DM2.255 EC8950.1 EC8951.1 EC8952.1 EC8953.1 F5504.1 IOBD1.29 IOBD1.30 PG8605.1 PG8606.1 PR4609.1 PR8625.1 PR8634.2 PR8636.1 Q1801.2 Q1801.5 Q2414.G Q2601.2 Q2601.5 Q5702.2 Q5702.5 Q5703.C R402.2 R506.1 R1204.2 R1208.2 R1211.2 R1302.1 R1306.1 R1310.1 R1606.1 R1608.1 R1718.2 R1818.2 R1820.1 R2005.1 R2010.1 R2011.1 R2038.1 R2043.1 R2044.1 R2045.1 R2046.1 R2048.1 R2049.1 R2107.1 R2109.1 R2119.1 R2489.1 R2490.1 R2603.1 R2604.1 R2609.1 R2715.1 R2716.1 R2737.1 R4003.1 R4005.1 R4008.1 R5529.2 R5551.1 R5554.1 R5555.1 R5559.1 R6143.1 R6302.1 R6402.1 R6517.1 R7004.1 R7018.1 R7934.1 R7948.2 R7953.1 R8541.1 R8601.1 R8634.1 R8635.2 R9120.2 R9150.1 RN401.1(A) RN401.2(A) RN403.1(A) RN403.2(A) RN1810.1(A) RN1810.2(A) RN1813.1(A) RN1813.2(A) RN1813.3(A) RN1813.4(A) RN2007.3(B) RN2007.4(B) RN2008.3(B) RN2008.4(B) RN2602.1(A) RN2602.2(A) RN2603.3(B) RN2603.4(B) SBD1.10 THM261.1 U4003.8 U4003.9 U8502.5 U8604.5 U8605.5
3D3V_S5: C2416.1 C2421.1 C5505.1 C6103.1 C6104.1 C6401.1 C7229.1 D4302.2 FC8901.1 FC8902.1 FC8903.1 FC8904.1 FC8905.1 IOBD1.28 PC5125.1 PC5306.1 PG4519.2 PG4520.2 PG4521.2 PG4522.2 PG4523.2 PG4524.2 PR4430.1 PR4435.1 PR4450.2 PR4464.2 PR4472.1 PR5104.1 PR5114.1 PR5208.1 PR5304.1 PU5102.5 PU5102.9 PU5301.5 PU5301.9 Q2412.2 Q2412.5 Q6101.S R507.2 R1721.1 R1724.1 R1910.1 R1913.1 R2001.1 R2050.2 R2434.1 R2440.1 R2443.1 R2446.1 R2475.1 R2511.1 R2514.1 R2517.1 R2520.1 R2607.1 R4031.1 R4034.1 R4304.1 R4378.1 R6137.1 R6140.1 R6521.1 R7239.1 R7241.1 R7246.1 R7247.1 R7250.1 R7303.1 R7424.1 R7427.1 R8626.1 R9143.1 R9149.1 RN2405.5(B) RN2405.6(B) RN2405.7(B) RN2405.8(B) RN7206.1(A) RN7206.2(A) U2502.5 U4003.6 U4003.7 U4007.5 U4302.2 U5501.4 U5501.5
3D3V_S5_KBC: C2410.1 C2411.1 C2412.1 C2413.1 C2414.1 C2420.1 C2422.1 C2429.1 D4304.2 D4305.2 D4306.2 DBG3.1 Q2417.2 Q2417.5 R2414.2 R2415.1 R2420.1 R2424.2 R2429.2 R2442.1 R2446.2 R2450.1 R2478.1 R2608.1 R4032.1 RN2402.1(A) RN2402.2(A) RN2403.1(A) RN2403.2(A) RN2403.3(A) RN2403.4(A) RN2404.1(A) RN2404.2(A) RN2404.3(A) RN2404.4(A) RN2412.1(A) RN2412.2(A) RN2412.3(A) RN2412.4(A) RN2413.1(A) RN2413.2(A) RN2414.1(A) RN2414.2(A) RN2414.3(A) RN2414.4(A) RN2415.1(A) RN2415.2(A) RN2415.3(A) RN2415.4(A) RN2416.1(A) RN2416.2(A) RN2416.3(A) RN2416.4(A) U2401.5 U2401.19 U2401.22 U2401.43 U2401.65 U2401.82 U2401.103 U2401.115
3D3V_S5_PCH: R303.1 R405.1 R406.1 R1103.1 R1502.1 R1504.1 R1506.1 R1508.2 R1510.2 R1513.1 R1522.1 R1551.1 R1554.1 R1837.1 R2041.1 R2515.2 R2516.2 R9148.1 RN1601.1(A) RN1601.2(A) RN1601.3(A) RN1601.4(A) RN1807.1(A) RN1807.2(A) RN1807.3(A) RN1807.4(A) RN1811.1(A) RN1811.2(A)
3D3V_SPIVCC1: C2501.1 C2502.1 R2501.1 R2515.1 R2517.2 RN2501.3(B) RN2501.4(B) SKT251.8 U2501.8
3D3V_SSD: AFTP6304.1 C6304.1 C6305.1 C6306.1 C6307.1 C6308.1 C6321.1 C6322.1 R6302.2 R6303.1 R6339.1 SSD1.2 SSD1.4 SSD1.12 SSD1.14 SSD1.16 SSD1.18 SSD1.70 SSD1.72 SSD1.74
3D3V_TBT: C7225.1 U7204.H2
3D3V_TP_S5_R: C6503.1 Q6504.S R6521.2
3D3V_TP_VDD: AFTP6529.1 C6504.1 Q6504.D R6502.2 R6509.2 R6513.1 R6517.2 R6522.1 RN6502.1(A) RN6502.2(A) RN6504.1(A) RN6504.2(A) TPAD1.8
3D3V_TPAN_VDD: C5501.1 C5502.1 C5503.1 LCD1.40 R5560.2
3D3V_TPM: R9140.1 R9144.1 R9149.2 R9150.2 R9153.1
3D3V_TPM_VHIO: C9109.1 C9112.1 C9113.1 R9139.2 R9144.2 U9101.8 U9101.22
3D3V_TPM_VSB: C9106.1 C9108.1 R9143.2 U9101.1
3D3V_VCCDSW: C2224.1 CPU1.BR24 CPU1.BT23 R1520.1 R1525.1 R1707.1 R1722.1 R1822.1 R2511.2 R2516.1 RN1704.1(A) RN1704.2(A) U2502.1
3D3V_VCCPRIM: C1113.1 C1123.1 C2202.1 C2203.1 C2204.1 C2205.1 C2206.1 C2207.1 CPU1.BP23 CPU1.BT20 CPU1.BV23 CPU1.BW23 CPU1.CB16 CPU1.CB22 CPU1.CB23 CPU1.CC22 CPU1.CC23 CPU1.CD22 CPU1.CD23 CPU1.CP29 R1103.2 R1701.1 R1731.1
3D3V_VCCPRTC: C2221.1 C2222.1 CPU1.BR23 R2204.2
3D3V_WLAN: AFTP6101.1 C6101.1 C6106.1 C6109.1 C6110.1 FC6101.1 Q6101.D R6102.1 R6140.2 R6142.1 R6143.2 WLAN1.2 WLAN1.4 WLAN1.72 WLAN1.74
27MHZ_IN: C7907.2 GPU1.C11 R7903.1 X7901.1
27MHZ_OUT: GPU1.B10 R7903.2 R7904.2
27MHZ_OUT_R: C7908.2 R7904.1 X7901.3
65982_GPIO1: R7243.1 U7204.C2
65982_GPIO2: R7247.2 R7248.1 U7204.D10
65982_GPIO3: R7222.1 U7204.G11
65982_GPIO8: R7244.2 R7245.1 U7204.H6
65982D_AUXN: RN7203.7(B) U7204.J2
65982D_AUXP: RN7203.8(B) U7204.J1
65982D_BUSPWR: R7229.1 R7233.2 U7204.F10
65982D_DBG_CTL1: RN7204.1(A) U7204.E4
65982D_DBG_CTL2: RN7204.2(A) U7204.D5
65982D_DEBUG1: R7218.2 U7204.L2
65982D_DEBUG2: R7219.2 U7204.K2
65982D_DEBUG3: R7220.1 U7204.L3
65982D_DEBUG4: R7226.1 U7204.K3
65982D_EE_CLK: U7204.A3 U7205.6
65982D_EE_CS_N: R7255.2 U7204.B3 U7205.1
65982D_EE_DI: U7204.B4 U7205.5
65982D_EE_DO: R7254.2 U7204.A4 U7205.2
65982D_GND: C7223.2 U7204.H7
65982D_HRESET: R7221.1 U7204.D6
65982D_I2C_ADDR: R7232.2 U7204.F1
65982D_LDO_1V8A: C7224.2 U7204.K1
65982D_LDO_1V8D: C7226.2 U7204.A2
65982D_LDO_BMC: C7230.2 U7204.E1
65982D_LSTX_P2R: TP7207.1 U7204.K4
65982D_LSTX_R2P: R7242.1 TP7206.1 U7204.L4
65982D_MRESET: R7223.1 U7204.E11
65982D_PD_HPD: R7236.2 U7204.C10
65982D_PRD_CC1: R7225.1 U7204.K9
65982D_PRD_CC2: R7224.1 U7204.K10
65982D_RESET_N: TP7205.1 U7204.F11
65982D_ROSC: R7237.1 U7204.G2
65982D_SBU1: TP7201.1 U7204.K8
65982D_SBU2: TP7202.1 U7204.L8
65982D_UART_RX: RN7203.6(B) U7204.E2 U7204.F2
+DC_IN: C4301.1 C4302.1 EL4301.2 EL4302.2 PU4301.1 PU4301.2 PU4301.3 Q4305.2 R4307.1 R4376.1
+DC_IN_C: AFTP4303.1 AFTP4305.1 AFTP4316.1 D4301.K DCIN1.6 DCIN1.7 DCIN1.8 EC4301.1 EC4302.1 EC4312.1 EC4313.1 EL4301.1 EL4302.1
+RTC_VCC: AFTP2502.1 D2501.2 Q2501.G R2504.1 R2506.1
+SDC_IN: C4343.2 C7401.2 PC4401.1 PG4401.1 PR4401.1 PR4434.2 PU4302.1 PU4302.2 PU4302.3 Q4348.S Q8612.S R4318.1 R4370.1 R7404.2 R7406.1 R7430.1 U7418.1 U7418.2 U7418.3
+SDC_IN_SW: C4343.1 PU4302.4 R4318.2 R4333.2 R4368.1
+SDC_IN_SW_R1: Q4349.3 R4333.1
+V_VREF_PATH1: C1222.2 R1209.1
+V_VREF_PATH2: C1323.2 R1309.1
AC_DIS: Q4304.B Q4349.2 R4379.1 U2401.69
AC_IN#_G: R4376.2 R4377.1 U4302.5
AC_PRESENT: CPU1.BU35 D1701.A EC1707.1 Q1702.3 RN1704.3(B)
ACOK#: PQ4415.2 PQ4415.3 PR4427.2
ACOK_IN: PG4408.2 PQ4415.5 R2469.2
ACOK_IN_M: D1701.K D4308.K PQ4415.6
AD+: C4303.1 C4304.1 C4305.1 C4306.1 PD4401.1 PD4408.1 PD4411.A PR4473.1 PU4301.5 PU4301.6 PU4301.7 PU4301.8 PU4302.5 PU4302.6 PU4302.7 PU4302.8 R4311.1 R4316.1
AD_IA: PR4412.1 R2403.1 R2423.2
AD_OFF_L: Q4304.C Q4305.1
AD_OFF_R: C4301.2 PU4301.4 Q4305.3 R4307.2 R4308.1
ALERT#: R2603.2 THM261.6
ALWON: R4009.2 U2401.121
AMBER_LED_BAT: EC6402.1 Q6403.C R6407.1
AON_CT_2: C8605.1 U8601.10
AUD_AGND: AUD1.MS C2702.1 C2703.2 C2706.2 C2707.2 C2710.2 C2711.2 C2715.2 C2902.2 EC2701.1 EC2702.1 EC2703.1 EC2704.1 EC2705.1 EC2905.2 EC2906.2 EC2907.2 EC2908.2 EC8954.1 EC8958.1 EC8959.1 EC8960.1 R2702.2 R2704.1 R2705.1 R2706.1 R2914.2 R2919.2 R2920.2 U2701.19 U2701.31
AUD_HP1_JACK_L: R2908.1 R2913.2 R2922.2 U2701.25
AUD_HP1_JACK_L1: EC2907.1 R2907.1 R2908.2 R2919.1
AUD_HP1_JACK_R: R2910.1 R2912.2 R2921.2 U2701.26
AUD_HP1_JACK_R1: EC2908.1 R2909.1 R2910.2 R2920.1
AUD_HPJD_N: R2710.2 R2711.2 U2701.12
AUD_PC_BEEP: C2735.2 U2701.11
AUD_PC_BEEP_C: C2735.1 C2739.1 D2703.3 R2735.1
AUD_PORTA_L_HPMIC1: AUD1.1 ED2911.1 R2907.2
AUD_PORTA_R_HPMIC1: AUD1.2 ED2910.1 R2909.2
AUD_RING: EC2905.1 R2906.1 RN2901.4(B) U2701.13
AUD_SENSE: C2902.1 R2711.1 R2923.2
AUD_SLEEVE: EC2906.1 R2911.1 RN2901.3(B) U2701.14
AUD_SPK_L+: EC2902.1 R2902.1 U2701.35
AUD_SPK_L+_C: AFTP2902.1 R2902.2 SPK1.4
AUD_SPK_L-: EC2901.1 R2901.1 U2701.36
AUD_SPK_L-_C: AFTP2901.1 R2901.2 SPK1.3
AUD_SPK_R+: EC2904.1 R2904.1 U2701.38
AUD_SPK_R+_C: AFTP2904.1 R2904.2 SPK1.1
AUD_SPK_R-: EC2903.1 R2903.1 U2701.37
AUD_SPK_R-_C: AFTP2903.1 R2903.2 SPK1.2
AUD_VREF: C2702.2 U2701.22
AUX_EN_WOWL: CPU1.BT30 R2427.1 R6136.2
AUX_ON: R2491.2 U2401.3
BAT1_LED#: Q2412.4 RN2405.4(A) U2401.106
BAT2_LED#: Q2412.1 RN2405.1(A) U2401.1
BAT_AMBER: LED1.1 R6407.2
BAT_WHITE: LED1.2 R6406.2
BATT_WHITE_LED#: Q2412.6 Q6402.3 R6404.1
BATT_WHITE_LED_R#: Q6401.D Q6402.4 Q6404.B R6404.2
BEEP: R2734.1 U2401.45
BKLT_CTRL: D5503.3 R5524.2 RN5502.1(A) RN5503.1(A)
BKLT_IN_EC: R2401.1 U2401.67
BLON_OUT: D2401.3 RN5504.1(A)
BLON_OUT_C: LCD1.22 RN5502.7(B) RN5504.4(B)
BLUETOOTH_EN: CPU1.CP14 D6101.K R2109.2 R6113.2
BLUETOOTH_EN_R: AFTP6107.1 D6101.A R6102.2 R6113.1 WLAN1.54
BMON22: PR4493.2 R2483.2
BOARD_ID: R2474.1 U2401.111
BOARD_ID1: CPU1.CG12 R2009.1 R2010.2
BOARD_ID2: CPU1.CM14 R2005.2 R2008.1
BOARD_ID_R: C2408.2 R2443.2 R2444.1 R2474.2
BOT_MUX_N: ED7305.1 EL7302.3 USB1.B7
BOT_MUX_N_L: EL7302.4 U7204.L7
BOT_MUX_P: ED7305.2 EL7302.2 USB1.B6
BOT_MUX_P_L: EL7302.1 U7204.K7
BPM_CPU_N0: CPU1.U1 TP307.1
BPM_CPU_N1: CPU1.U2 TP308.1
BPM_CPU_N2: CPU1.U3 TP302.1
BPM_CPU_N3: CPU1.U4 TP303.1
BT+: AFTP4312.1 AFTP4313.1 AFTP4314.1 BATT1.1 BATT1.2 BATT1.3 D4307.K EC4307.1 EC4308.1 PR4466.2 PR4478.2 PR4483.2 PU4412.5 PU4412.6 PU4412.7 PU4412.8
BT_PCMFRM_CRF_RST_N: R1923.1 R6134.1 WLAN1.10
BT_PCMFRM_CRF_RST_N_R: CPU1.CJ32 R1923.2
BT_PCMOUT_CLKREQ0: R1922.1 R6133.1 WLAN1.14
BT_PCMOUT_CLKREQ0_R: CPU1.CH29 R1922.2
BT_USB20_CON_N: AFTP6109.1 R6110.1 WLAN1.5
BT_USB20_CON_P: AFTP6110.1 R6111.1 WLAN1.3
BT_USB20_N: CPU1.CC3 R6110.2
BT_USB20_P: CPU1.CC4 R6111.2
CAD_SNK: R7306.2 U7301.29
CAP_LED: AFTP6532.1 KB1.4 R6506.2
CAP_LED#: Q2414.S R2489.2 U2401.93
CAP_LED#_D: Q2414.D R6508.1
CAP_LED#_R: Q6502.B R6508.2
CAP_LED_Q: Q6502.C R6506.1
CARD1_USB20_N: CPU1.CG8 IOBD1.18
CARD1_USB20_P: CPU1.CG9 IOBD1.17
CATERR#_CPU: CPU1.AA4 TP301.1
CBN: C2708.2 U2701.28
CBP: C2708.1 U2701.30
CCD_USB20_CON_N: EL5501.3 LCD1.30
CCD_USB20_CON_P: EL5501.2 LCD1.31
CCD_USB20_N: CPU1.CC1 EL5501.4
CCD_USB20_P: CPU1.CC2 EL5501.1
CFG3: CPU1.R3 R1517.1 TP621.1
CFG4: CPU1.J4 R1518.1
CFG_RCOMP: CPU1.AB5 R601.1
CHG_AMBER_LED#: Q2412.3 Q6402.1 R6405.1
CHG_AMBER_LED_R#: Q6402.6 Q6403.B R6405.2
CHGR_PSYS_IMVP: PR4413.1 PR4614.1 PU4401.30 PU4601.1
CLK_PCIE_PEG_REQ#: CPU1.CF32 Q7601.D R7618.1 RN1813.5(B)
CLK_TP_SIO: EC6503.1 RN6503.1(A) RN6504.4(B) U2401.78
CLKIN_XTAL_LCP: CPU1.CM3 R1842.1
CLKIN_XTAL_LCP_R: R1842.2 WLAN1.64
CLKRUN#: CPU1.BY30 R1818.1
CMP_VIN0: R2470.1 U2401.20
CMP_VIN0_R: C2612.1 C2613.1 R2470.2 R2608.2 R2609.2 R2610.1
CMP_VOUT0: R2602.2 R2607.2 R2615.2 U2401.85
CNV_BRI_DT: CPU1.CJ20 R2007.2
CNV_BRI_DT_R: R2007.1 R6115.2 WLAN1.36
CNV_BRI_RSP: CPU1.CK20 R2030.2 R6118.1
CNV_BRI_RSP_R: R6118.2 WLAN1.22
CNV_RGI_DT: CPU1.CG19 R2006.2
CNV_RGI_DT_R: R1515.2 R1516.1 R2006.1 WLAN1.32
CNV_RGI_RSP: CPU1.CH19 R2029.2 R6109.1
CNV_RGI_RSP_R: R6109.2 WLAN1.34
CNV_WR_CLKN: CPU1.CN31 R6123.2
CNV_WR_CLKN_R: R6123.1 WLAN1.21
CNV_WR_CLKP: CPU1.CP31 R6124.2
CNV_WR_CLKP_R: R6124.1 WLAN1.23
CNV_WR_DN0: CPU1.CR30 R6121.2
CNV_WR_DN0_R: R6121.1 WLAN1.15
CNV_WR_DN1: CPU1.CM30 R6119.2
CNV_WR_DN1_R: R6119.1 WLAN1.9
CNV_WR_DP0: CPU1.CP30 R6122.2
CNV_WR_DP0_R: R6122.1 WLAN1.17
CNV_WR_DP1: CPU1.CN30 R6120.2
CNV_WR_DP1_R: R6120.1 WLAN1.11
CNV_WT_CLKN: CPU1.CP34 R6129.2
CNV_WT_CLKN_R: R6129.1 WLAN1.71
CNV_WT_CLKP: CPU1.CN34 R6130.2
CNV_WT_CLKP_R: R6130.1 WLAN1.73
CNV_WT_DN0: CPU1.CN32 R6127.2
CNV_WT_DN0_R: R6127.1 WLAN1.65
CNV_WT_DN1: CPU1.CP33 R6125.2
CNV_WT_DN1_R: R6125.1 WLAN1.59
CNV_WT_DP0: CPU1.CM32 R6128.2
CNV_WT_DP0_R: R6128.1 WLAN1.67
CNV_WT_DP1: CPU1.CN33 R6126.2
CNV_WT_DP1_R: R6126.1 WLAN1.61
CNV_WT_RCOMP: CPU1.CP32 CPU1.CR32 R2101.1
CPU_D4_TP: CPU1.CG23 TP1804.1
CPU_D6_TP: CPU1.CG20 TP1806.1
CPU_DP2_CTRL_CLK: CPU1.CH4 RN403.3(B)
CPU_DP2_CTRL_DATA: CPU1.CH3 RN403.4(B)
CPU_DP_HPD_P: Q401.2 Q401.3 R406.2
CPU_I2C_SCL_ISH0: CPU1.CH20 R2020.1 RN2007.2(A)
CPU_I2C_SCL_ISH1: CPU1.CJ22 RN2008.2(A)
CPU_I2C_SCL_P0: CPU1.CN11 EC6504.1 Q6503.1 R6518.1
CPU_I2C_SCL_P1: CPU1.CJ12 EC5505.5 EC5505.6 LCD1.38 R5555.2
CPU_I2C_SDA_ISH0: CPU1.CK22 R2021.1 RN2007.1(A)
CPU_I2C_SDA_ISH1: CPU1.CH22 RN2008.1(A)
CPU_I2C_SDA_P0: CPU1.CM11 EC6502.1 Q6503.4 R6519.1
CPU_I2C_SDA_P1: CPU1.CK12 EC5505.4 EC5505.7 LCD1.37 R5554.2
CPU_POPIRCOMP: CPU1.BP27 R304.1
CPU_SMB_ALERT#: CPU1.CJ15 R1551.2 R1552.1
CPU_SMB_ALERT#_P0: CPU1.CG15 R1504.2 R1505.1 R1843.1
CPU_SMB_ALERT#_P1: CPU1.CC34 R1555.1 R1837.2
CPU_SMB_SCL: CPU1.CK14 Q1801.3 RN1811.4(B)
CPU_SMB_SCL_P0: CPU1.CH14 RN1807.8(B)
CPU_SMB_SCL_P1: CPU1.CN15 Q2601.3 Q7901.6 R2438.2 RN1807.7(B)
CPU_SMB_SDA: CPU1.CH15 Q1801.6 RN1811.3(B)
CPU_SMB_SDA_P0: CPU1.CF15 RN1807.5(B)
CPU_SMB_SDA_P1: CPU1.CM15 Q2601.6 Q7901.3 R2439.2 RN1807.6(B)
CPVEE: C2709.2 U2701.27
CTL1: R3601.2 U3601.6
CTL2: R3606.2 U3601.7
CTL3: R3602.2 U3601.8
DAT_TP_SIO: EC6501.1 RN6503.2(A) RN6504.3(B) U2401.79
DBC_EN_R: LCD1.8 R5518.2
DBC_PANEL_EN: CPU1.CA31 R2043.2 R5518.1
DC_IN_OFF: Q4349.6 R4369.2
DCBATOUT: C5514.1 C5518.1 EC4534.1 EC8917.1 EC8919.1 EC8925.1 EC8928.1 EC8929.1 EC8957.1 EC8962.2 EC8963.1 F5503.1 FC8916.1 FC8917.1 FC8918.1 FC8919.1 FC8920.1 FC8921.1 FC8922.1 FC8923.1 FC8924.1 FC8925.1 FC8926.1 FC8927.1 FC8928.1 FC8929.1 FC8930.1 PC4406.1 PC4407.1 PC4408.1 PC4409.1 PC4410.1 PC4411.1 PC4412.1 PC4413.1 PC4414.1 PC4418.1 PC4434.1 PC4437.1 PC4443.1 PC8501.1 PC8502.1 PC8503.1 PC8504.1 PC8505.1 PC8511.1 PC8512.1 PC8513.1 PC8515.1 PC8516.1 PD4407.A PG4501.1 PG4502.1 PG4503.1 PG4504.1 PG4505.1 PG4506.1 PG4515.1 PG4516.1 PG4517.1 PG4518.1 PG4533.1 PG4534.1 PG4709.1 PG4710.1 PG4711.1 PG4712.1 PG4713.1 PG4714.1 PG4715.1 PG4716.1 PG4717.1 PG4718.1 PG4816.1 PG4817.1 PG4818.1 PG4819.1 PG4820.1 PG4821.1 PG4822.1 PG4823.1 PG4824.1 PG4825.1 PG5002.2 PG5003.2 PG5101.1 PG5102.1 PG5103.1 PG5210.1 PG5212.1 PG5214.1 PG8614.1 PG8615.1 PG8616.1 PG8617.1 PR4477.2 PR4479.2 PR4496.1 PR4509.1 PR4511.1 PR4612.1 PR8503.1 PU4405.5 PU4405.6 PU4405.7 PU4405.8 PU4413.1 PU4413.2 PU4413.3 PU8510.2 PU8510.3 PU8510.4 PU8510.10 PU8512.2 PU8512.3 PU8512.4 PU8512.10 PU8515.2 PU8515.3 PU8515.4 PU8515.10 PU8516.2 PU8516.3 PU8516.4 PU8516.10
DCBATOUT_LCD: C5515.1 C5535.1 F5503.2 LCD1.1 LCD1.2
DGPU_HOLD_RST#: CPU1.CR22 EC2002.1 R7604.1 RN2009.4(B) U7601.1
DGPU_PWR_1V: R8649.2 U8605.1
DGPU_PWR_EN: CPU1.CM24 Q8604.G R2011.2 R8605.1 RN2009.3(B)
DGPU_PWR_EN#: Q8608.5 Q8608.6 R8643.1
DGPU_PWR_EN_Q: PR8523.1 Q8604.D Q8608.2 R8605.2 R8611.1 R8626.2 R8649.1
DGPU_PWR_EN_R: C8603.1 R8611.2 U8601.5
DGPU_PWROK: CPU1.CJ25 EC2401.1 R2477.2 R8533.2 R8534.1 U8502.4
DGPU_PWROK_L: R8531.2 R8532.2 R8533.1 U8502.1
DGPUHOT#: D7902.K PQ4402.D R2422.1
DIMM1_SA0: DM1.256 R1204.1 R1205.2
DIMM1_SA1: DM1.260 R1208.1 R1210.2
DIMM1_SA2: DM1.166 R1211.1 R1212.2
DIMM2_SA0: DM2.256 R1302.2 R1303.2
DIMM2_SA1: DM2.260 R1306.2 R1307.2
DIMM2_SA2: DM2.166 R1310.2 R1311.2
DMIC_CLK_EDP: LCD1.27 R5503.2 R5556.2
DMIC_DATA_EDP: LCD1.28 R5502.2 R5557.2
DMIC_PCH_CLK: CPU1.CP24 R5556.1
DMIC_PCH_DATA: CPU1.CN24 R5557.1
DMIC_SCL_CODEC: EC5501.1 R5503.1 U2701.3
DMIC_SDA_CODEC: EC2711.1 EC5502.1 R5502.1 U2701.2
DP1_HPD_CPU: Q401.5 R404.2 R7236.1 R7326.2
DP1_HPD_CPU_R: CPU1.CM6 Q401.6 R403.2 R404.1 R405.2
DP2_AUX_C_N: C7302.1 R7301.2 U7301.25
DP2_AUX_C_P: C7301.1 R7302.2 U7301.24
DP2_AUX_CPU_N: C7302.2 CPU1.AD4
