# Allegro board 17859-1.0710WZS1337.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GSEN2_INT2_ISH: length 11.5
  TOP w0.102: R2026.1 122.83,54.19 v1(122.98,54.35)
  BOTTOM w0.076: v1(122.98,54.35) 123.39,54.75 v2(123.39,55.06) 123.39,56.48 122.88,56.99 122.16,56.99 121.41,57.74 121.41,57.87 121.4,57.89 121.4,58.35 121.5,58.45 121.5,60.32 121.91,60.73 121.91,61.14 121.64,61.42 121.64,61.79 121.71,61.91 121.71,62.58 CPU1.CA35
GSEN_INT1: length 266
  TOP w0.102: v1(132.43,41.43) 131.82,40.82 131.82,40.15 v2(125.03,33.36) 124.26,32.59 69.28,32.59 v1(67.13,34.75)
  L3 w0.102: v1(42.03,94.9) 42.03,94.16 38.5,90.63 38.5,89.36 35.12,85.98 35.12,84.14 34.36,83.38 34.36,81.95 33.52,81.11 33.52,78.13 32.38,76.99 32.38,75.34 31.77,74.73 31.16,74.73 30.37,73.94 30.37,70.26 28.75,68.64 28.75,67.24 28.59,67.08 28.59,66.24 29.02,65.81 29.08,65.81 30.94,63.95 30.94,61.31 30.8,61.16 30.8,57.17 v1(30.99,56.97) ; v1(67.13,34.75) 65.4,36.48 62.43,36.48 62.02,36.88 62.02,43.74 60.34,45.41 60.34,47.63 60.22,47.76 60.22,47.78 59.1,48.9 59.1,49 58.95,49.15 58.95,50.29 57.04,52.2 57.04,54.24 56.32,54.97 54.07,54.97 52.51,56.53 49.99,56.53 v1(49.42,57.1) ; v1(33.62,93.96) 35.07,95.4 35.45,95.4 38.91,98.86 62.4,98.86 67.94,104.4 77.49,104.4 77.95,104.85 79.72,104.85 79.78,104.8 v1(79.83,104.8)
  L6 w0.102: v1(132.43,41.43) 132.43,42.09 127.2,47.32 127.2,50.52 126.71,51.01 126.71,52.25 126.18,52.78 126.18,53.09 121.21,58.06 121.21,59.38 120.82,59.77 v1(120.57,59.77) ; v1(49.42,57.1) 49.42,57.1 48.74,56.42 47.72,56.42 47.41,56.72 45.3,56.72 44.3,57.72 43.36,57.72 42.79,57.16 42.79,56.63 41.39,55.22 39.8,55.22 39.24,54.66 39.24,54.38 38.97,54.11 38.38,54.11 37.82,54.66 33.98,54.66 32.81,55.83 31.79,55.83 31.03,56.59 31.03,56.94 v1(30.99,56.97) ; v1(33.62,93.96) 33.88,94.21 40.38,94.21 41.19,95.02 41.6,95.02 41.73,94.9 v1(42.03,94.9)
  BOTTOM w0.076: CPU1.BW34 120.59,63.33 120.59,62.19 120.61,62.08 120.61,61.83 120.59,61.75 120.59,59.79 v1(120.57,59.77)
  BOTTOM w0.102: v1(79.83,104.8) 79.85,104.78 79.85,104.55 80.26,104.14 81.58,104.14 81.6,104.16 83.18,104.16 83.47,103.87 83.47,103.49 82.68,102.7 82.68,101.98 SBD1.4
GSEN_INT2: length 267.9
  TOP w0.102: v1(132.63,43.51) 132.97,43.17 132.97,42.09 132.91,42.03 132.91,40.96 132.97,40.9 132.97,40.18 v2(131.09,38.3) 125.18,32.39 68.59,32.39 v1(66.66,34.31)
  L3 w0.102: v1(32.98,57.23) 32.34,57.23 31,58.57 31,61.06 32.59,62.64 32.59,64 30.92,65.66 30.14,65.66 29.74,66.07 29.05,66.07 28.8,66.32 28.8,66.8 28.95,66.96 28.95,67.16 29.61,67.82 29.61,68.2 29.53,68.28 29.53,69.14 30.6,70.2 30.6,73.89 31.24,74.53 31.86,74.53 32.68,75.35 32.68,76.8 33.73,77.85 33.73,81.02 34.56,81.86 34.56,83.3 35.33,84.06 35.33,85.88 38.7,89.26 38.7,90.53 42.46,94.29 42.46,95.08 42.21,95.33 41.85,95.33 41.4,94.87 v1(41.4,94.59) ; v1(48.79,57.07) 49.54,56.33 52.42,56.33 53.98,54.77 56.23,54.77 56.76,54.23 56.76,52.18 58.73,50.22 58.73,50.01 58.74,49.99 58.74,49.05 58.9,48.9 58.9,48.8 59.68,48.01 59.68,48.01 59.99,47.7 59.99,45.32 61.69,43.61 61.69,36.92 62.34,36.27 64.7,36.27 v1(66.66,34.31) ; v1(33.09,93.42) 33.09,95 33.69,95.6 35.34,95.6 38.83,99.09 61.92,99.09 61.94,99.06 62.3,99.06 67.84,104.6 77.39,104.6 77.87,105.08 79.47,105.08 79.62,105.23 80.03,105.23 80.46,104.8 v1(80.46,104.57)
  L6 w0.102: v1(48.79,57.07) 48.33,56.62 47.8,56.62 47.5,56.92 45.38,56.92 44.38,57.93 43.27,57.93 42.59,57.25 42.59,56.71 42.07,56.19 35.4,56.19 34.05,57.54 33.29,57.54 v1(32.98,57.23) ; v1(132.63,43.51) 132.15,44 131,44 130.93,44.07 130.91,44.07 127.4,47.58 127.4,50.62 126.92,51.11 126.92,52.35 126.38,52.89 126.38,53.2 121.96,57.63 v1(121.96,58.12) ; v1(41.4,94.59) 40.67,93.87 34.6,93.87 34.16,93.42 v1(33.09,93.42)
  BOTTOM w0.076: v1(121.96,58.12) 121.96,58.64 121.92,58.68 121.92,60.23 122.24,60.56 122.24,61.45 CPU1.CA37
  BOTTOM w0.102: SBD1.3 83.44,102.34 83.44,103.17 83.67,103.4 83.67,104.08 83.29,104.46 83.28,104.46 83.16,104.57 v1(80.46,104.57)
GSENSOR_CS: length 2.3
  TOP w0.127: 167.13,51.18 167.13,50.55 R7006.1 v2(166.01,50.32)
  TOP w0.305: 167.13,51.18 U7001.2
GSENSOR_SDO: length 3.3
  TOP w0.127: 167.63,51.18 167.63,50.35 R7005.2 167.94,50.04 R7007.2 169.31,50.04 v2(169.46,49.89)
  TOP w0.305: 167.63,51.18 U7001.3
GYRO_DRDY: length 221.5
  TOP w0.102: v1(25.38,61) 25.76,60.61 28.42,60.61 28.98,61.17 29.56,61.17 29.66,61.27 v1(29.66,61.29) ; R2028.2 119.3,46.31 120.03,45.57 120.82,45.57 121.05,45.34 121.52,45.34 121.96,44.89 121.96,39.86 121,38.89 115.05,38.89 114.26,39.68 101.15,39.68 100.1,38.62 79.28,38.62 74.01,43.89 v2(68.6,43.89) 68.36,44.13 68.23,44.13 v1(67.69,44.68)
  L3 w0.102: v1(85.64,103.85) 85.33,103.85 84.35,104.83 83.36,104.83 83.33,104.85 83.31,104.85 83.23,104.93 81.81,104.93 80.51,103.63 80.51,103.51 80.18,103.17 79.75,103.17 79.75,103.18 78.19,103.18 77.42,103.95 68.1,103.95 62.58,98.43 39.08,98.43 32.3,91.65 27.2,91.65 24.05,88.49 24.05,83.19 24.35,82.88 24.35,80.24 24.38,80.22 24.38,80.06 24.35,80.04 24.35,79.96 23.74,79.35 23.74,73.46 23.59,73.31 23.59,73 23.36,72.77 23.36,70.87 23.67,70.56 23.67,66.45 25.67,64.44 25.67,61.29 v1(25.38,61) ; v1(49.8,58.93) 49.8,59.29 50.13,59.62 52.32,59.62 53.77,58.17 55.92,58.17 56.74,57.36 61.1,57.36 66.29,52.17 66.29,48.49 67.57,47.21 67.57,44.79 v1(67.69,44.68)
  L6 w0.102: v1(29.66,61.29) 31.54,61.29 32.02,61.78 37.64,61.78 38.42,62.56 44.39,62.56 44.42,62.54 45.41,62.54 46.5,61.45 47.5,61.45 49.8,59.14 v1(49.8,58.93)
  BOTTOM w0.102: v1(85.64,103.85) 85.64,103.46 85.33,103.15 SBD1.1
GYRO_DRDY_ISH: length 17.3
  TOP w0.102: R2028.1 R2052.2 R2051.1 121.2,47.65 121.2,48.08 v2(121.33,48.21) 121.86,48.21 v1(121.89,48.19)
  BOTTOM w0.076: 121.53,50.75 120.95,51.34 120.95,52.3 121.08,52.43 121.08,56.9 121.06,56.91 121.06,56.94 120.88,57.12 120.88,59.27 120.96,59.35 120.96,60.39 120.8,60.55 120.8,61.42 120.85,61.46 CPU1.BW37
  BOTTOM w0.102: v1(121.89,48.19) 121.67,48.4 121.67,50.61 121.53,50.75
GYRO_INT: length 199.8
  TOP w0.102: R7003.2 R7002.2 219.22,60.25 v2(220.89,60.25) v1(223.46,60.25)
  L4 w0.102: v1(88.28,107.8) 89.2,107.8 89.71,107.29 103.32,107.29 103.88,106.73 109.97,106.73 112.03,108.79 118.32,108.79 119.79,107.32 126.97,107.32 128.75,109.1 159.84,109.1 160.24,108.69 170.15,108.69 174.16,104.68 177.72,104.68 180.21,107.17 185.9,107.17 187.52,108.79 194.86,108.79 196.95,106.71 214.07,106.71 214.37,106.4 217.21,106.4 223.87,99.75 223.87,60.66 v1(223.46,60.25)
  BOTTOM w0.102: SBD1.2 84.71,102.2 85.27,102.2 86.48,103.41 86.48,106.1 88.18,107.8 v1(88.28,107.8)
GYRO_INT_C: length 125.6
  TOP w0.102: R7003.1 218.36,57.33 218.36,55.73 223.46,50.62 223.46,44.3 220.49,41.33 219.15,41.33 217.72,39.9 217.72,37.31 216.51,36.1 215.3,36.1 214.04,34.84 214.04,32.74 215.54,31.24 215.54,30.84 v1(215.59,30.79) ; R2027.2 140.23,46.61 140.23,46.05 141.65,44.63 141.65,41.02 142.34,40.34 143.55,40.34 144.85,41.63 145.69,41.63 146.09,41.23 147.42,41.23 147.59,41.05 147.59,38.94 148.95,37.58 v2(164.61,37.58) 165.43,37.58 168.57,34.45 170.18,34.45 v1(170.8,35.06)
  L6 w0.102: v1(215.59,30.79) 215.03,30.23 206.49,30.23 205.87,30.85 202.14,30.85 201.52,30.23 194.88,30.23 193.5,31.6 191.56,31.6 190.62,32.54 185.59,32.54 184.19,33.94 179.95,33.94 179.04,34.85 177.72,34.85 176.51,36.06 172.38,36.06 171.38,35.06 v1(170.8,35.06)
GYRO_INT_ISH: length 30.7
  TOP w0.102: v2(139.08,47.86) 139.03,47.81 139.03,46.99 R2027.1 139.01,46.31 v1(138.88,46.18)
  BOTTOM w0.076: CPU1.CA34 122.82,63.59 122.99,63.42 122.99,63.38 122.99,62.56 122.93,62.39 122.93,62.18 122.97,62.08 122.97,61.84 122.93,61.74 122.93,61.73 122.9,61.66 122.9,60.23 122.7,60.02 122.7,59.08 124.66,57.13 124.66,56.67
  BOTTOM w0.102: 124.66,56.67 124.66,54.58 125.91,53.32 125.91,52.49 128.39,50.02 129.24,50.02 132.06,47.2 137.87,47.2 v1(138.88,46.18)
GYRO_INT_P11: length 4.5
  TOP w0.102: v2(217.72,56.47) 217.72,57.03 v1(217.7,57.05) 216.88,57.86 216.88,58.9 217.11,59.13 R7002.1
  BOTTOM w0.102: v1(217.7,57.05) 217.84,57.05 D7001.1
H_CPUPWRGD: length 17.7
  TOP w0.127: ED301.2 107.3,95.84 106.55,95.84 106.06,95.35 v1(106.06,95.05)
  L3 w0.127: v1(107.49,89.84) 106.06,91.26 v1(106.06,95.05)
  BOTTOM w0.127: v1(107.49,89.84) 106.9,89.84 R1714.1 105.25,88.19 TP1705.1 104.31,86.95 104.79,86.46 105.68,86.46 106.29,85.85 106.29,84.08 105.83,83.62 CPU1.AR2
H_PECI: length 5.1
  TOP w0.102: U2401.94 30.96,38.11 30.42,37.58 30.42,37.21 29.64,36.43 v2(29.28,36.43) 28.53,36.43 C2405.1 28.41,36.31 R2437.1
H_PROCHOT#_R: length 6.1
  TOP w0.089: v1(23.77,45.31) 23.46,45.61 v2(23.46,45.98) 23.54,46.05 R2416.1 24.38,45.01 R2418.2
  BOTTOM w0.089: v1(23.77,45.31) 24.1,44.98 24.1,44.2 23.41,43.51 23.41,43.26 23.21,43.05 Q2408.D
HDA_BITCLK_CODEC: length 127.4
  TOP w0.089: v1(70.31,46.6) 71.21,46.6 71.8,47.2 75.22,47.2 76.92,48.9 v1(77.69,48.9) ; R1920.1 113.71,47.4 EC1901.2 113.46,47.25 v1(112.24,46.03) ; v1(30.7,25.84) 30.41,25.84 29.79,25.23 29.79,25.05 29.49,24.75 29.49,21.97 31.59,19.87 31.59,18.3 34.31,15.58 v2(34.31,15.57) 34.61,15.27 EC2710.1 34.33,14.68 33.04,13.39 R2723.1
  L6 w0.089: v1(42.97,48.06) 41.46,46.55 41.46,45.67 40.63,44.83 38.73,44.83 35.67,41.77 34.96,41.77 32.99,39.8 32.99,39.35 32.35,38.71 32.35,35.79 30.96,34.4 30.96,30.97 30.88,30.89 30.88,28.6 30.65,28.37 30.65,27.63 30.3,27.28 30.3,26.24 v1(30.7,25.84)
  BOTTOM w0.089: v1(42.97,48.06) 42.97,48.06 43.45,48.54 44.47,48.54 44.67,48.75 45.51,48.75 46.07,48.19 46.88,48.19 47.77,49.08 50.11,49.08 50.64,49.61 51.91,49.61 51.92,49.6 52.02,49.6 52.24,49.38 53,49.38 53.56,49.94 55.19,49.94 56.43,48.69 57.6,48.69 58.01,49.1 58.26,49.1 58.31,49.05 58.41,49.05 58.69,48.77 58.69,48.67 61,46.36 61,46.32 61,46.31 61,46.28 61.51,45.77 61.54,45.77 61.94,45.37 62.76,45.37 63.47,46.08 63.77,46.08 63.88,45.97 63.88,45.64 63.98,45.53 64.29,45.53 64.4,45.64 64.4,45.97 64.5,46.08 64.84,46.08 64.94,45.97 64.94,45.64 65.05,45.53 65.45,45.53 65.55,45.64 65.55,45.97 65.66,46.08 68.47,46.08 69.1,46.71 70.21,46.71 v1(70.31,46.6) ; v1(112.24,46.03) 111.83,46.03 111.42,46.43 111.42,46.51 109.82,48.11 81.25,48.11 79.22,50.14 78.23,50.14 77.69,49.61 v1(77.69,48.9)
HDA_BITCLK_CODEC_R: length 6.1
  TOP w0.089: R2723.2 31.16,13.39 30.78,13.77 30.6,13.77 29.86,14.51 v2(28.52,14.51) 28.26,14.76 28.26,14.79 27.43,15.62 27.4,15.62 27.22,15.8 U2701.5
HDA_BITCLK_CPU: length 14.4
  TOP w0.089: R1920.2 113.71,49.02 114.29,49.61 v2(114.29,49.69) 114.64,50.03 114.64,54.27 v1(115.95,55.57)
  BOTTOM w0.089: v1(115.95,55.57) 116.36,55.98 116.36,56.92 116.12,57.15 116.12,60.07 117.09,61.04 117.09,61.57 CPU1.BN37
HDA_CODEC_SDIN0: length 5.5
  TOP w0.089: U2701.7 27.56,16.6 28.42,15.75 v2(29.1,15.75) 30.52,15.75 30.78,15.5 R2724.2
HDA_RST_N_CPU: length 2.6
  TOP w0.305: v1(116.33,63.27) 116.35,63.29 116.35,63.36 116.38,63.39 116.38,64.32 116.12,64.57 TP1903.1
  BOTTOM w0.305: v1(116.33,63.27) 116.28,63.22 116.1,63.22 CPU1.BL35
HDA_SDIN0_CPU: length 138.4
  TOP w0.089: v1(113.28,46.36) 112.72,45.8 v1(112.72,45.37) ; R2724.1 31.82,16.03 31.82,16.61 31.08,17.35 31.08,19.71 v2(30.64,20.16) 29.02,21.77 29.02,24.94 30.52,26.44 30.69,26.44 30.73,26.48 v1(30.73,26.48) ; v1(69.23,45.83) 71.22,45.83 72.12,46.73 75.41,46.73 76.96,48.27 v1(77.8,48.27)
  L6 w0.089: v1(30.73,26.48) 31.74,27.49 31.74,30.18 31.52,30.41 31.52,30.97 31.74,31.19 31.74,31.96 31.84,32.06 31.84,34.59 32.84,35.59 32.84,37.89 33.53,38.59 34.36,38.59 34.54,38.76 34.84,38.76 35.78,39.71 35.78,40.89 38.41,43.51 39.74,43.51 40.13,43.91 40.13,44.11 40.38,44.36 40.82,44.36 41.95,45.5 41.95,45.82 42.48,46.34 v1(42.9,46.34)
  BOTTOM w0.076: CPU1.BN35 116.71,62.62 116.71,62 116.6,61.8 116.6,61.39 116.62,61.37 116.62,61.1 115.77,60.25 115.77,56.92 115.34,56.49 115.34,55.04
  BOTTOM w0.089: v1(113.28,46.36) 113.17,46.47 113.17,47.08 110,50.24 110,52.45 110.99,53.44 113.74,53.44 115.34,55.04 ; v1(69.23,45.83) 69,45.6 67.05,45.6 66.52,45.06 63.39,45.06 63.23,44.9 61.19,44.9 60.25,45.84 55.91,45.84 53.9,47.85 51.89,47.85 51.77,47.74 50.98,47.74 50.79,47.55 48.56,47.55 47.39,46.38 45.03,46.38 45,46.36 43.83,46.36 43.82,46.34 v1(42.9,46.34) ; v1(112.72,45.37) 112.72,45.32 112.44,45.04 110.08,45.04 109.35,45.77 80.3,45.77 v1(77.8,48.27)
HDA_SDOUT_CODEC: length 128.6
  TOP w0.089: v1(30.22,25.05) 30.19,25.03 30.19,24.87 29.71,24.39 29.71,22.76 32.09,20.38 32.09,18.6 35.54,15.14 35.69,15.14 36.61,14.22 36.61,13.72 36.11,13.22 35.29,13.22 EC2709.1 34.54,13.9 33.27,12.63 R2722.1 ; v1(70.52,47.2) 71.14,47.2 71.61,47.67 75.02,47.67 76.73,49.37 77.89,49.37 78.28,48.97 v1(78.51,48.97) ; v2(111.2,45.42) 111.55,45.42 v1(111.73,45.6) 111.73,46.13 111.17,46.69 EC1903.1 111.17,47.68 R1921.1
  L6 w0.089: v1(42.54,48.57) 42.54,48.29 40.15,45.9 37.28,45.9 34.72,43.34 34.72,43.06 32.51,40.85 32.51,39.53 31.87,38.9 31.87,36.1 30.49,34.72 30.49,32.06 29.64,31.21 29.64,29.26 29.89,29.01 29.89,26.01 30.22,25.69 v1(30.22,25.05)
  BOTTOM w0.089: v1(78.51,48.97) 78.94,48.97 81.14,46.78 109.33,46.78 110.59,45.52 111.65,45.52 v1(111.73,45.6) ; v1(70.52,47.2) 68.92,47.2 68.28,46.56 63.19,46.56 62.89,46.26 62.81,46.26 62.78,46.23 62.4,46.23 62.37,46.26 61.72,46.26 61.49,46.49 61.49,46.56 59.18,48.87 59.18,48.97 58.62,49.53 58.52,49.53 58.19,49.86 55.95,49.86 55.39,50.42 50.77,50.42 49.91,49.56 47.55,49.56 47.37,49.38 45.23,49.38 45.16,49.3 44.55,49.3 44.27,49.02 43.22,49.02 42.77,48.57 v1(42.54,48.57)
HDA_SDOUT_CODEC_R: length 6.6
  TOP w0.089: R2722.2 31.24,12.63 v2(30.68,13.19) 30.58,13.29 30.4,13.29 29.66,14.02 28.21,14.02 28.04,14.2 28.04,14.68 27.32,15.4 U2701.4
HDA_SDOUT_CPU: length 18.9
  TOP w0.089: v1(112.41,49.56) 112.31,49.46 R1512.2 R1921.2 R1909.2 110.2,48.9 v2(109.79,48.48)
  BOTTOM w0.083: CPU1.BN36 117.03,62.23 116.88,61.96 116.77,61.76 116.77,61.46 116.79,61.44 116.79,61.01
  BOTTOM w0.089: 116.79,61.01 115.95,60.17 115.95,56.8 115.54,56.39 115.54,53.6 114.88,52.94 114.88,50.71 114.37,50.19 112.81,50.19 112.41,49.8 v1(112.41,49.56)
HDA_SPKR_R: length 2.2
  BOTTOM w0.254: v2(25.9,23.4) 25.14,23.4 R2741.2 24.96,22.87 24.44,22.34 D2703.1
HDA_SYNC_CODEC: length 125.5
  TOP w0.089: v1(69.23,44.81) v2(69.7,45.28) 69.79,45.36 71.42,45.36 72.31,46.26 75.81,46.26 v1(77.36,47.81) ; v1(27.35,17.71) 27.1,17.71 26.79,17.4 U2701.9 ; R1908.1 115.01,52.53 115.01,49.79 114.27,49.05 114.27,48.69 114.28,48.69 114.28,46.62 113.35,45.7 v1(113.35,45.34)
  L6 w0.089: v1(40,47.35) 39.02,46.37 37.09,46.37 34.23,43.52 34.23,43.26 32.04,41.06 32.04,39.72 31.39,39.08 31.39,36.3 30.02,34.93 30.02,33.45 29.64,33.07 29.64,32.71 29.13,32.2 29.13,29.82 28.72,29.42 28.72,28.96 27.27,27.51 27.27,25.63 27.73,25.17 v1(27.73,24.41)
  BOTTOM w0.089: v1(113.35,45.34) 113.35,44.92 112.99,44.55 109.82,44.55 109.14,45.24 109.11,45.24 109.06,45.29 79.88,45.29 v1(77.36,47.81) ; v1(27.35,17.71) 28.62,18.98 28.62,23.52 v1(27.73,24.41) ; v1(69.23,44.81) 68.93,45.11 67.25,45.11 66.7,44.56 63.55,44.56 63.43,44.43 60.99,44.43 60.05,45.37 55.69,45.37 54.06,47 53.08,47 52.88,47.2 52.19,47.2 51.77,46.77 50.64,46.77 50.46,46.94 48.64,46.94 47.59,45.9 45.23,45.9 45.18,45.85 42.35,45.85 40.84,47.36 40.04,47.36 40.02,47.35 v1(40,47.35)
HDA_SYNC_CPU: length 11.2
  TOP w0.089: v1(116.2,54.99) 115.03,53.82 R1908.2
  BOTTOM w0.083: CPU1.BN34 117.28,63.33 117.28,61.03 117.27,61.01 117.27,60.96 116.54,60.23 v2(116.54,57.99) 116.54,55.91
  BOTTOM w0.089: 116.54,55.91 116.54,55.44 116.2,55.1 v1(116.2,54.99)
HDD_DEVSLP: length 172.9
  TOP w0.102: R6002.1 191.79,12.5 195.37,16.08 200.63,16.08 204.41,12.3 204.41,9.09 206.49,7.01 212.27,7.01 216.02,10.76 216.02,16.89 213.91,18.99 213.91,20.96 216,23.04 216,24.23 216.35,24.59 216.35,25.76 217.11,26.52 217.11,28.2 218.1,29.19 218.1,30.1 217.52,30.69 217.52,32.87 v2(216.91,33.48) 216.53,33.86 215.53,33.86 v1(214.94,34.45)
  L6 w0.102: v1(214.94,34.45) 214.92,34.47 214.48,34.47 212.47,36.48 207.32,36.48 206.03,37.77 200.79,37.77 198.55,40.01 198.55,40.26 198.57,40.29 198.57,40.44 197.25,41.76 184.53,41.76 183.75,42.53 181.51,42.53 174.24,49.81 165.05,49.81 164.06,50.8 163.74,50.8 155.54,59 155.54,68.11 151.26,72.39 149.96,72.39 149.78,72.57 148.26,72.57 144.5,76.33 136.34,76.33 134.03,78.64 131.11,78.64 130.5,79.25 v1(130.5,79.91)
  BOTTOM w0.076: v1(130.5,79.91) 130.2,79.61 129.88,79.61 129.82,79.61 CPU1.CP8
HDD_DEVSLP_R: length 6.3
  TOP w0.102: v1(187.86,10.49) 188.01,10.34 189.63,10.34 v2(189.94,10.65) 190.7,11.41 R6002.2
  BOTTOM w0.102: HDD1.8 v1(187.86,10.49)
HDD_SATA_RX_CON_N: length 13.9
  BOTTOM w0.102: C6004.2 195.12,18.78 195.4,18.5 195.4,18.36 195.4,17.74 194.26,16.6 ; 194.26,16.6 194,16.34 194,16.1 193.86,15.97 ED6001.4 ED6001.7 193.86,14.16 194,14.03 194,13.31 191.94,11.25 190.04,11.25 189.22,12.07 189.22,12.47 189.36,12.61 HDD1.5 ; 194.26,16.6 v2(194.13,16.74)
HDD_SATA_RX_CON_P: length 14.6
  BOTTOM w0.102: 195.63,18.09 195.63,18.36 195.63,18.5 195.9,18.78 C6003.2 ; 195.63,18.09 v2(195.8,18.09) ; 195.63,18.09 195.63,17.64 194.23,16.25 194.23,16.1 194.36,15.97 ED6001.5 ED6001.6 194.36,14.16 194.23,14.03 194.23,13.22 192.04,11.03 189.94,11.03 189,11.97 189,12.47 188.86,12.61 HDD1.6
HDD_SATA_RX_N: length 125.2
  L3 w0.102: v1(184.5,26.49) 184.35,26.49 184.25,26.6 184.25,26.9 184.07,27.08 183.76,27.08 183.1,27.74 183.1,30.15 166.52,46.74 166.52,48.53 164.23,50.82 164.23,55.35 162.48,57.1 162.48,58.8 159.1,62.18 159.1,69.37 158.52,69.95 158.52,71.81 153.28,77.04 150.18,77.04 149.72,77.5 148.11,77.5 146.33,75.72 137.68,75.72 136.03,77.37 135.25,77.37 134.03,78.59 132.66,78.59 132.35,78.9 128.25,78.9 128.21,78.86 128.21,78.84 127.91,78.54 118.61,78.54 117.67,79.48 117.24,79.48 117.14,79.38 117.14,79.13 v1(117.21,79.06)
  BOTTOM w0.102: v1(117.21,79.06) 116.85,78.71 CPU1.BN10 ; C6004.1 195.12,20.53 195.22,20.63 195.57,20.63 195.68,20.73 195.68,27.47 193.78,29.37 190.04,29.37 189.12,28.45 189.12,27.54 188.2,26.62 184.63,26.62 v1(184.5,26.49)
HDD_SATA_RX_P: length 124.4
  L3 w0.102: v1(117.32,79.89) 117.47,79.68 117.76,79.68 118.7,78.74 127.82,78.74 128.01,78.93 128.01,78.95 128.16,79.1 132.44,79.1 132.74,78.79 134.11,78.79 135.33,77.57 136.11,77.57 137.76,75.92 146.25,75.92 148.03,77.7 149.8,77.7 150.26,77.24 153.37,77.24 158.72,71.89 158.72,70.04 159.3,69.45 159.3,62.27 162.68,58.89 162.68,57.19 164.43,55.43 164.43,50.9 166.72,48.62 166.72,46.82 183.31,30.24 183.31,27.82 183.85,27.28 v1(184.5,27.28)
  BOTTOM w0.102: v1(117.32,79.89) 117.05,79.62 CPU1.BN8 ; C6003.1 195.9,27.56 193.87,29.59 189.94,29.59 188.89,28.55 188.89,27.64 188.11,26.85 184.93,26.85 184.5,27.28 v1(184.5,27.28)
HDD_SATA_TX_CON_N: length 10.6
  BOTTOM w0.102: C6006.2 194.34,18.77 194.06,18.49 194.06,18.19 ; 194.06,18.19 194.06,18.07 192.73,16.74 192.73,16.1 192.86,15.97 ED6001.2 ED6001.9 192.86,14.16 192.73,14.03 192.73,13.24 191.48,12 190.73,12 190.5,12.23 190.5,12.47 190.36,12.61 HDD1.3 ; 194.06,18.19 v2(194.23,18.19)
HDD_SATA_TX_CON_P: length 9.9
  BOTTOM w0.102: v2(192.48,17.07) 192.61,16.94 ; 192.61,16.94 192.5,16.84 192.5,16.1 192.36,15.97 ED6001.1 ED6001.10 192.36,14.16 192.5,14.03 192.5,13.34 191.39,12.23 190.83,12.23 190.72,12.33 190.72,12.47 190.86,12.61 HDD1.2 ; 192.61,16.94 193.83,18.16 193.83,18.49 193.55,18.77 C6005.2
HDD_SATA_TX_N: length 129.7
  L3 w0.102: v1(194.15,27.56) 193.92,27.33 193.92,27 193.7,26.77 192.54,26.77 191.66,27.66 191.66,30.35 189.78,32.23 187.24,32.23 173.02,46.45 173.02,60.62 170.38,63.27 170.38,63.55 164.43,69.49 164.43,71.3 163.54,72.19 163.54,73.46 153.94,83.06 147.54,83.06 144.55,86.06 141.19,86.06 139.44,87.81 136.42,87.81 134.28,85.68 129.43,85.68 128.7,84.94 122.01,84.94 119.85,87.1 117.07,87.1 v1(116.77,86.8)
  BOTTOM w0.076: CPU1.BN4 116.95,82.83 117.11,83.38 117.16,83.51 117.16,83.7 117.12,83.86 117.12,84.02 117.16,84.18 117.16,84.58 116.96,84.97 116.96,86.11 116.77,86.3 v1(116.77,86.8)
  BOTTOM w0.102: C6006.1 194.34,20.37 194.25,20.45 194.25,24.92 194.02,25.15 194.02,27.43 v1(194.15,27.56)
HDD_SATA_TX_P: length 130.5
  L3 w0.102: v1(116.1,86.88) 116.53,87.3 119.93,87.3 122.09,85.14 128.61,85.14 129.35,85.88 134.2,85.88 136.33,88.01 139.52,88.01 141.28,86.26 144.63,86.26 147.63,83.26 154.03,83.26 163.75,73.54 163.75,72.27 164.64,71.38 164.64,69.57 170.58,63.63 170.58,63.35 173.22,60.71 173.22,46.54 187.33,32.43 189.87,32.43 191.87,30.43 191.87,27.74 192.63,26.98 193.62,26.98 193.72,27.08 193.72,27.49 193.66,27.56 v1(193.36,27.56)
  BOTTOM w0.076: CPU1.BN3 116.99,83.55 116.99,83.68 116.94,83.82 116.94,84.06 116.99,84.2 116.99,84.54 116.78,84.92 116.78,86.04 116.6,86.22 116.6,86.4 116.11,86.88 v1(116.1,86.88)
  BOTTOM w0.102: C6005.1 193.55,20.43 193.64,20.53 193.92,20.53 194.02,20.63 194.02,24.83 193.8,25.05 193.8,27.28 193.52,27.56 v1(193.36,27.56)
HDMI_DDI_TX_CMC_N0: length 5.3
  TOP w0.102: 19.08,62.37 19.3,62.16 19.52,62.16 19.88,62.51 v1(19.91,62.51) ; 19.08,62.37 18.49,62.97 18.49,63.02 18.28,63.22 RN5701.8 ; 19.08,62.37 v2(19.22,62.51)
  BOTTOM w0.102: R5713.1 18.35,62.42 18.78,62.42 18.93,62.27 19.64,62.27 19.88,62.51 v1(19.91,62.51) 19.91,62.49 20.44,61.95 C5705.2
HDMI_DDI_TX_CMC_N1: length 7.2
  TOP w0.102: v1(19.88,59.06) 20.21,58.73 20.43,58.73 21.48,57.68 21.48,55.78 21.71,55.55 RN5703.5
  BOTTOM w0.102: C5707.2 20.13,58.8 v1(19.88,59.06) 19.66,58.84 19.01,58.84 18.79,59.06 R5715.1
HDMI_DDI_TX_CMC_N2: length 5.7
  TOP w0.102: v2(20.87,56.62) 20.7,56.62 ; 20.7,56.62 20.7,57.15 20.29,57.56 v1(19.91,57.56) ; 20.7,56.62 20.7,56.28 20.44,56.02 20.44,55.78 20.62,55.6 RN5703.7
  BOTTOM w0.102: C5708.2 20.29,57.25 19.98,57.56 v1(19.91,57.56) 19.71,57.36 19.7,57.36 19.57,57.23 18.95,57.23 18.91,57.19 18.35,57.19 R5717.1
HDMI_DDI_TX_CMC_N3: length 6
  TOP w0.102: RN5701.6 18.38,62.14 18.66,61.85 18.66,61.04 19.2,60.51 19.6,60.51 v1(19.88,60.78)
  BOTTOM w0.102: C5701.2 20.52,60.43 20.16,60.78 v1(19.88,60.78) 19.88,60.5 19.74,60.37 19.23,60.37 18.86,60.73 R5721.1
HDMI_DDI_TX_CMC_P0: length 5.1
  TOP w0.102: v1(19.88,61.65) 19.6,61.93 19.2,61.93 18.5,62.64 RN5701.7
  BOTTOM w0.102: C5703.2 20.36,61.17 v1(19.88,61.65) 19.88,61.85 19.69,62.04 19.11,62.04 18.76,61.7 R5714.1
HDMI_DDI_TX_CMC_P1: length 7
  TOP w0.102: RN5703.6 21.12,55.7 21.25,55.83 21.25,57.58 20.33,58.5 20.19,58.5 v1(19.88,58.19)
  BOTTOM w0.102: R5716.1 18.76,58.3 19.08,58.61 19.78,58.61 19.88,58.51 v1(19.88,58.19) 20.05,58.03 C5706.2
HDMI_DDI_TX_CMC_P2: length 4.9
  TOP w0.102: v1(19.88,56.92) 20.2,56.92 20.47,56.66 20.47,56.37 20.21,56.12 20.21,55.76 20.03,55.58 RN5703.8
  BOTTOM w0.102: R5720.1 18.51,56.47 19.04,57 19.76,57 19.83,56.92 v1(19.88,56.92) 19.93,56.92 20.01,56.85 20.16,56.85 C5709.2
HDMI_DDI_TX_CMC_P3: length 5.2
  TOP w0.102: v1(19.88,59.92) 19.52,60.28 19.1,60.28 18.43,60.94 18.43,61.26 18.14,61.55 RN5701.5
  BOTTOM w0.102: R5722.1 18.85,59.97 19.02,60.14 19.66,60.14 v1(19.88,59.92) 20.21,59.59 C5704.2
HDMI_DDI_TX_CON_N0: length 13.7
  TOP w0.102: HDMI1.9 9.92,66.49 9.92,66.24 10.25,65.91 10.25,63.2 10.66,62.79 11.43,62.79 12.13,63.49 12.78,63.49 v1(13.1,63.81)
  BOTTOM w0.102: 13.83,63.37 13.95,63.25 13.95,62.36 14.2,62.11 14.35,62.11 14.48,62.24 ED5702.5 ED5702.6 16.16,62.24 ER5701.1 16.57,62.42 17.4,62.42 R5713.2 ; 13.83,63.37 v2(13.95,63.49) ; 13.83,63.37 13.71,63.49 13.42,63.49 v1(13.1,63.81)
HDMI_DDI_TX_CON_N1: length 12.3
  BOTTOM w0.102: R5715.2 17.42,59.08 ER5702.1 16.11,58.74 ED5701.6 ED5701.5 14.26,58.74 14.12,58.6 13.79,58.6 12.69,59.69 12.69,61.16 11.88,61.97 11.88,64.98 11.64,65.21 11.25,65.21 HDMI1.6
HDMI_DDI_TX_CON_N2: length 13.1
  BOTTOM w0.102: 12.61,57.87 13.38,57.1 14.12,57.1 14.26,57.24 ED5701.2 ED5701.9 16.39,57.24 ER5703.1 16.57,57.19 17.4,57.19 R5717.2 ; 12.61,57.87 v2(12.75,58) ; 12.61,57.87 11.88,58.6 11.88,60.96 10.27,62.57 10.27,62.98 9.91,63.33 9.91,63.5 HDMI1.3
HDMI_DDI_TX_CON_N3: length 13.5
  BOTTOM w0.102: HDMI1.12 11.25,68.21 12.17,68.21 12.59,67.8 12.59,62.16 13.43,61.32 13.43,61.01 13.84,60.61 14.15,60.61 14.28,60.74 ED5702.2 ED5702.9 16.44,60.74 ER5704.1 16.52,60.69 17.4,60.69 R5721.2
HDMI_DDI_TX_CON_P0: length 13.2
  TOP w0.102: HDMI1.7 9.74,66.1 10.02,65.82 10.02,63.11 10.57,62.56 11.53,62.56 12.22,63.26 12.78,63.26 v1(13.1,62.94)
  BOTTOM w0.102: 13.92,62.06 13.72,62.27 13.72,63.16 13.62,63.26 13.42,63.26 v1(13.1,62.94) ; 13.92,62.06 v2(13.79,61.93) ; 13.92,62.06 14.11,61.88 14.34,61.88 14.48,61.74 ED5702.4 ED5702.7 16.39,61.74 ER5701.2 16.52,61.74 17.4,61.74 R5714.2
HDMI_DDI_TX_CON_P1: length 12.2
  BOTTOM w0.102: HDMI1.4 11.25,64.99 11.55,64.99 11.65,64.88 11.65,61.88 12.47,61.06 12.47,59.6 13.69,58.37 14.12,58.37 14.26,58.24 ED5701.4 ED5701.7 16.44,58.24 ER5702.2 16.57,58.34 17.4,58.34 R5716.2
HDMI_DDI_TX_CON_P2: length 12.7
  BOTTOM w0.102: 13.45,56.87 v2(13.45,56.7) ; 13.45,56.87 13.29,56.87 11.65,58.51 11.65,60.86 10.04,62.47 10.04,62.88 9.82,63.1 HDMI1.1 ; 13.45,56.87 14.12,56.87 14.26,56.74 ED5701.1 ED5701.10 16.16,56.74 ER5703.2 16.52,56.51 17.4,56.51 R5720.2
HDMI_DDI_TX_CON_P3: length 13.6
  BOTTOM w0.102: HDMI1.10 11.25,67.99 12.08,67.99 12.36,67.7 12.36,62.06 13.2,61.22 13.2,60.92 13.74,60.38 14.15,60.38 14.28,60.24 ED5702.1 ED5702.10 16.11,60.24 ER5704.2 16.57,60.01 17.4,60.01 R5722.2
HDMI_DDI_TX_N0: length 108.7
  L4 w0.102: v1(100.63,81.27) 100.43,81.47 100.43,83.63 97.59,86.46 94.67,86.46 93.47,87.66 78.12,87.66 77.69,88.09 72.41,88.09 72.1,87.79 61.16,87.79 60.14,88.8 48.46,88.8 43.38,83.72 43.38,81.05 41.84,79.52 41.84,79.18 42.61,78.41 42.61,78.27 42.47,78.12 42.33,78.12 41.55,78.89 41.22,78.89 40.81,78.49 40.81,78.15 41.47,77.49 41.47,77.32 41.35,77.2 41.18,77.2 40.52,77.86 40.19,77.86 39.9,77.57 39.08,77.57 38.62,77.12 37.79,77.12 37.05,76.38 37.05,74.45 35.15,72.55 35.15,71.53 34.56,70.94 34.56,70.31 34.39,70.13 34.39,66.27 32.76,64.65 32.76,63.2 32,62.44 29.92,62.44 29.38,61.9 26.94,61.9 26.7,61.66 26.7,61.26 26.58,61.14 26.42,61.14 26.3,61.26 26.3,61.66 26.06,61.9 24.99,61.9 24.25,61.17 23.46,61.17 23.08,61.55 v1(22.07,61.55)
  BOTTOM w0.102: C5705.1 21.66,61.95 v1(22.07,61.55) ; CPU1.AF6 100.57,81.27 100.61,81.27 100.62,81.27 v1(100.63,81.27)
HDMI_DDI_TX_N1: length 108.7
  L4 w0.102: v1(22.07,58.72) 24.06,58.72 25.26,59.92 28.48,59.92 28.79,60.23 30.34,60.23 30.72,60.61 30.85,60.61 31.33,61.09 32.38,61.09 34.08,62.79 34.08,64.24 35.76,65.92 35.76,67.93 36.14,68.31 36.14,70.79 36.37,71.02 36.37,71.38 39.08,74.09 41.72,74.09 43.53,75.91 43.53,76.96 45.43,78.87 45.43,82.03 46.22,82.81 46.22,84.84 48.97,87.58 55.59,87.58 56.66,86.52 70.1,86.52 74.71,81.9 77.94,81.9 82.04,85.99 93.39,85.99 95.13,84.25 96.19,84.25 97.91,82.53 97.91,80.95 98.72,80.14 100.39,80.14 101.11,80.86 101.11,81.33 101.53,81.75 v1(101.53,81.95)
  BOTTOM w0.102: CPU1.AJ5 101.91,81.57 v1(101.53,81.95) ; v1(22.07,58.72) 21.98,58.8 C5707.1
HDMI_DDI_TX_N2: length 110.2
  L4 w0.102: v1(22.01,57.36) 22.12,57.46 23.86,57.46 25.56,59.16 28.59,59.16 29.05,59.62 30.59,59.62 30.97,60 31.13,60 31.61,60.48 32.66,60.48 34.87,62.69 34.87,64.09 36.75,65.97 36.75,70.54 36.98,70.77 36.98,71.07 39.39,73.48 41.98,73.48 44.14,75.64 44.14,76.57 46.22,78.65 46.22,81.94 46.83,82.55 46.83,84.56 49.24,86.97 55.27,86.97 56.36,85.88 64.49,85.88 65.2,85.17 70.58,85.17 74.54,81.21 80.2,81.21 84.59,85.6 93.04,85.6 94.82,83.82 96.07,83.82 97.43,82.46 97.43,80.25 98.05,79.63 100.58,79.63 102,81.05 102,81.21 102.53,81.73 v1(102.53,81.79)
  BOTTOM w0.102: CPU1.AL5 v1(102.53,81.79) ; C5708.1 21.53,57.36 v1(22.01,57.36)
HDMI_DDI_TX_N3: length 107.8
  L4 w0.102: v1(22.09,60.12) 22.22,60 22.35,60 22.52,60.18 23.57,60.18 23.74,60 24.45,60 24.99,60.53 28.11,60.53 28.42,60.84 29.92,60.84 30.35,61.27 30.62,61.27 31.18,61.83 32.25,61.83 33.37,62.94 33.37,64.39 35,66.02 35,69.88 35.17,70.06 35.17,70.69 35.76,71.28 35.76,72.27 38.2,74.7 40.07,74.7 40.44,75.08 40.44,75.22 39.96,75.7 39.96,76.04 40.2,76.28 40.54,76.28 40.88,75.94 41.04,75.94 41.59,76.48 42.18,76.48 44.83,79.13 44.83,80.51 44.74,80.6 44.21,80.6 43.99,80.82 43.99,83.47 48.71,88.19 55.85,88.19 56.92,87.12 59.12,87.12 59.24,87.24 59.24,87.67 59.47,87.91 59.81,87.91 60.05,87.67 60.05,87.24 60.17,87.12 70.36,87.12 74.98,82.51 77.65,82.51 81.53,86.39 93.9,86.39 94.28,86.01 95.09,86.01 98.36,82.73 98.36,81.36 98.48,81.24 v1(98.85,81.24)
  BOTTOM w0.102: v1(22.09,60.12) 21.95,59.98 21.81,59.98 C5701.1 ; v1(98.85,81.24) 98.97,81.24 CPU1.AE5
HDMI_DDI_TX_P0: length 109
  L4 w0.102: v1(99.78,81.18) 100.12,81.18 100.22,81.28 100.22,83.54 97.5,86.26 94.58,86.26 93.39,87.45 78.04,87.45 77.61,87.89 72.49,87.89 72.19,87.58 61.07,87.58 60.06,88.6 48.54,88.6 43.58,83.64 43.58,80.97 42.05,79.43 42.05,79.27 42.82,78.49 42.82,78.18 42.55,77.92 42.24,77.92 41.47,78.69 41.3,78.69 41.01,78.4 41.01,78.23 41.67,77.58 41.67,77.24 41.43,77 41.1,77 40.44,77.66 40.27,77.66 39.98,77.37 39.16,77.37 38.7,76.91 37.87,76.91 37.26,76.3 37.26,74.37 35.35,72.46 35.35,71.44 34.77,70.86 34.77,70.23 34.59,70.05 34.59,66.19 32.96,64.56 32.96,63.11 32.08,62.23 30,62.23 29.47,61.7 27.03,61.7 26.91,61.58 26.91,61.18 26.67,60.94 26.33,60.94 26.09,61.18 26.09,61.58 25.98,61.7 25.07,61.7 24.34,60.96 23.38,60.96 23,61.34 22.52,61.34 22.45,61.27 22.45,61.04 22.3,60.89 v1(22.07,60.89)
  BOTTOM w0.102: v1(99.78,81.18) 99.78,81.18 100.17,81.57 CPU1.AF5 ; v1(22.07,60.89) 21.79,61.17 C5703.1
HDMI_DDI_TX_P1: length 108.6
  L4 w0.102: v1(22.07,58.02) 22.24,58.02 22.37,58.14 22.37,58.4 22.49,58.52 24.14,58.52 25.34,59.72 28.57,59.72 28.87,60.02 30.42,60.02 30.8,60.4 30.93,60.4 31.41,60.89 32.46,60.89 34.28,62.71 34.28,64.16 35.96,65.83 35.96,67.85 36.34,68.23 36.34,70.71 36.57,70.94 36.57,71.3 39.16,73.89 41.8,73.89 43.73,75.82 43.73,76.88 45.64,78.79 45.64,81.94 46.43,82.73 46.43,84.75 49.05,87.38 55.51,87.38 56.58,86.31 70.01,86.31 74.63,81.7 78.03,81.7 82.13,85.79 93.3,85.79 95.04,84.05 96.11,84.05 97.71,82.45 97.71,80.86 98.64,79.94 100.48,79.94 101.31,80.77 101.31,81.12 101.42,81.23 v1(101.59,81.23)
  BOTTOM w0.102: v1(22.07,58.02) 22.05,58.03 C5706.1 ; CPU1.AJ6 101.76,81.23 v1(101.59,81.23)
HDMI_DDI_TX_P2: length 110.4
  L4 w0.102: v1(22.04,56.72) 22.13,56.63 22.4,56.63 22.5,56.73 22.5,57.1 22.65,57.25 23.95,57.25 25.65,58.96 28.68,58.96 29.14,59.41 30.68,59.41 31.06,59.79 31.21,59.79 31.69,60.28 32.74,60.28 35.07,62.61 35.07,64 36.95,65.88 36.95,70.45 37.18,70.68 37.18,70.99 39.47,73.28 42.06,73.28 44.34,75.56 44.34,76.48 46.43,78.56 46.43,81.86 47.03,82.47 47.03,84.48 49.33,86.77 55.19,86.77 56.28,85.68 64.41,85.68 65.12,84.97 70.5,84.97 74.46,81 80.28,81 84.68,85.4 92.96,85.4 94.74,83.62 95.98,83.62 97.23,82.37 97.23,80.17 97.96,79.43 100.66,79.43 102.37,81.14 v1(102.53,81.14)
  BOTTOM w0.102: CPU1.AL6 v1(102.53,81.14) ; C5709.1 21.63,56.7 22.02,56.7 v1(22.04,56.72)
HDMI_DDI_TX_P3: length 107.9
  L4 w0.102: v1(22.13,59.44) 22.13,59.48 22.63,59.97 23.48,59.97 23.66,59.79 24.54,59.79 25.07,60.33 28.2,60.33 28.5,60.63 30,60.63 30.43,61.06 30.7,61.06 31.26,61.62 32.34,61.62 33.57,62.86 33.57,64.31 35.2,65.93 35.2,69.79 35.38,69.97 35.38,70.61 35.96,71.19 35.96,72.18 38.28,74.5 40.15,74.5 40.64,74.99 40.64,75.31 40.16,75.78 40.16,75.95 40.28,76.07 40.45,76.07 40.79,75.73 41.13,75.73 41.68,76.28 42.26,76.28 45.03,79.05 45.03,80.6 44.83,80.8 44.29,80.8 44.19,80.9 44.19,83.38 48.8,87.99 55.76,87.99 56.83,86.92 59.2,86.92 59.44,87.16 59.44,87.59 59.56,87.71 59.73,87.71 59.85,87.59 59.85,87.16 60.08,86.92 70.28,86.92 74.89,82.31 77.73,82.31 81.61,86.18 93.81,86.18 94.19,85.8 95.01,85.8 98.16,82.65 98.16,81.27 v1(98.87,80.56)
  BOTTOM w0.102: v1(22.13,59.44) 21.98,59.59 C5704.1 ; v1(98.87,80.56) 98.94,80.56 CPU1.AE6
HDMI_DET_CON: length 14.6
  TOP w0.102: ED5703.10 ED5703.1 14.04,66 12.39,67.65 12.39,69.65 v2(13.92,71.18) 14.09,71.35 R5710.2 R5711.1 10.19,72.98 HDMI1.19
HDMI_HPD_B: length 6
  TOP w0.102: R5710.1 15.58,72.21 v2(15.88,71.91) 16.96,71.91 17.34,71.53 v1(17.34,70.93)
  BOTTOM w0.102: v1(17.34,70.93) Q5703.B
HDMI_HPD_CPU: length 217.2
  TOP w0.102: v1(19.5,66.5) 19.5,67.19 v2(19.22,67.47) R5712.1
  L3 w0.102: v1(19.5,66.5) 19.5,67.47 20.39,68.35 20.39,68.99 21.05,69.65 21.05,72.7 22.66,74.31 22.66,78.63 21.36,79.94 21.36,84.71 22.14,85.5 22.14,87.43 21.84,87.73 21.84,88.98 22.96,90.1 22.96,92.76 23.62,93.42 30.96,93.42 33.34,95.81 35.25,95.81 38.73,99.29 62.02,99.29 62.05,99.27 62.2,99.27 67.74,104.8 77.29,104.8 78.01,105.53 81.77,105.53 81.95,105.71 86.13,105.71 87.53,107.11 100.78,107.11 101.21,107.55 104.16,107.55 104.92,106.78 106.47,106.78 106.52,106.73 109.07,106.73 113.19,102.61 113.47,102.61 113.5,102.57 113.86,102.57 113.9,102.61 114.03,102.61 v1(114.32,102.9)
  L4 w0.102: v1(130.44,81.16) 130.44,81.13 130.8,80.77 131.31,80.77 131.44,80.9 133.17,80.9 133.78,80.29 133.78,79.73 135.83,77.68 137.18,77.68 137.59,77.27 142.36,77.27 142.82,77.73 142.82,79.83 143.87,80.88 149.19,80.88 149.8,80.27 v1(153.23,80.27) ; v1(142.72,89.26) 142.72,89.28 142.77,89.33 142.77,89.56 142.03,90.3 134.49,90.3 133.8,89.61 128.54,89.61 126.97,91.19 126.97,91.8 125.19,93.58 123.67,93.58 123.46,93.37 119.76,93.37 115.7,97.44 115.44,97.44 113.99,98.88 113.99,102.57 v1(114.32,102.9)
  L6 w0.102: v1(153.23,80.27) 152.01,81.49 151.15,81.49 150.9,81.74 150.9,82.3 150.32,82.88 150.25,82.88 149.26,83.87 147.16,83.87 146.12,84.91 145.46,84.91 141.65,88.72 141.65,89.56 141.78,89.69 142.54,89.69 142.72,89.51 v1(142.72,89.26)
  BOTTOM w0.102: CPU1.CN6 128.94,80.85 130.02,80.85 130.33,81.16 v1(130.44,81.16)
HDMI_HPD_E: length 9.3
  TOP w0.102: R5709.1 R5712.2 17.34,69.47 v2(16.78,70.02) 16.78,71.35 v1(16.81,71.38)
  BOTTOM w0.102: v1(16.81,71.38) 16.94,71.5 21.63,71.5 22,71.14 Q5703.E
HDMI_PLL_GND: length 7.4
  L4 w0.254: v1(17.41,68.14) 17.13,67.86 17.13,63.93 v1(16.4,63.2)
  BOTTOM w0.254: v1(17.41,68.14) 17.43,68.14 17.57,68 Q5701.D
  vias: v2(18.46,54.31)
HDMI_SCL_CON: length 19
  TOP w0.089: v1(13.3,64.7) 13.5,64.5 ED5703.4 ED5703.7 15.9,64.5 v1(16.61,65.2) 16.68,65.28 17.52,65.28 RN5702.1
  L3 w0.089: HDMI1.15 10.08,70.87 10.08,71.99 10.33,72.24 11.09,72.24 11.69,71.64 11.69,66.31 v1(13.3,64.7)
  BOTTOM w0.089: Q5702.3 16.58,63.9 v2(16.44,64.03) 16.2,64.27 16.2,64.8 v1(16.61,65.2)
HDMI_SCL_CPU: length 160.8
  L4 w0.114: v1(21.13,65.28) 21.13,69.33 22.69,70.89 23.9,70.89 24.76,71.76 24.76,73.94 25.11,74.3 25.11,75.52 26.16,76.56 26.16,79.38 29.03,82.25 29.03,85.6 30.27,86.85 30.27,88.77 37.21,95.7 42.98,95.7 43.35,95.33 50.24,95.33 51.08,96.17 64.61,96.17 64.92,95.86 68.93,95.86 69.85,96.78 74.06,96.78 74.54,96.29 80.92,96.29 81.99,95.23 84.88,95.23 84.96,95.15 99.21,95.15 101.21,93.14 105.34,93.14 108.05,90.44 108.05,90.05 108.2,89.89 108.2,88.62 107,87.42 107,84.36 108.39,82.97 108.39,79.85 109.02,79.23 115.84,79.23 116.58,78.49 120.31,78.49 120.47,78.64 121.99,78.64 122.32,78.97 122.32,79.3 v1(122.85,79.84)
  L6 w0.089: v1(122.85,79.84) 123.79,80.77 123.86,80.77 124.23,81.14 124.23,84.96 126.62,87.36 130.49,87.36 v1(131.16,86.69)
  BOTTOM w0.089: v1(21.13,65.28) 20.88,65.03 v2(20.06,65.03) 19.25,65.03 18.94,64.72 17.77,64.72 17.56,64.94 Q5702.4 ; v1(131.16,86.69) 131.04,86.81 131.04,87.61 131.57,88.15 RN401.3 ; CPU1.CC8 123.07,79.62 v1(122.85,79.84)
HDMI_SCL_R: length 3.1
  TOP w0.089: RN5702.4 18.73,65.26 19.09,64.9 v2(19.58,64.9) 19.58,65.41 v1(19.53,65.46)
  BOTTOM w0.089: v1(19.53,65.46) 20.04,65.98 D5701.2
HDMI_SDA_CON: length 15.6
  TOP w0.089: v1(16.58,65.86) 16.22,65.5 v2(16.09,65.5) ED5703.9 ED5703.2 14,65.5 11.75,67.75 11.75,69.71 HDMI1.16 ; RN5702.2 16.65,64.59 v1(16.62,64.56)
  L6 w0.089: v1(16.58,65.86) 16.17,65.46 16.17,65.02 v1(16.62,64.56)
  BOTTOM w0.089: v1(16.58,65.86) 16.96,66.25 17.34,66.25 17.99,66.89 18.6,66.89 18.86,66.64 Q5702.6
HDMI_SDA_CPU: length 157.4
  L4 w0.114: v1(122.86,79.2) 122.02,78.36 120.49,78.36 120.42,78.29 116.48,78.29 115.74,79.02 108.93,79.02 108.19,79.77 108.19,82.88 106.6,84.47 106.6,89.56 106.85,89.82 106.85,91.11 105.2,92.76 101.06,92.76 99.05,94.77 84.8,94.77 84.73,94.85 81.5,94.85 81.12,95.23 71.04,95.23 70.78,95.48 64.76,95.48 64.46,95.79 51.23,95.79 50.3,94.86 42.7,94.86 42.23,95.34 37.36,95.34 30.65,88.63 30.65,86.69 29.56,85.6 29.56,82.25 26.54,79.23 26.54,76.41 26.05,75.92 26.05,72.52 24.03,70.49 22.8,70.49 21.58,69.27 21.58,64.87 v1(21.43,64.72)
  L6 w0.089: v1(122.86,79.2) 123.27,79.61 123.27,79.92 124.41,81.07 124.41,84.9 126.7,87.18 130.04,87.18 v1(130.52,86.69)
  BOTTOM w0.089: v1(130.52,86.69) 130.09,87.12 v2(130.09,87.51) 130.09,87.76 130.77,88.44 RN401.4 ; v1(122.86,79.2) 123.09,78.97 CPU1.CC9 ; Q5702.1 18.86,64.25 19.37,64.77 19.83,64.77 19.91,64.68 21.39,64.68 v1(21.43,64.72)
HDMI_SDA_R: length 4.1
  TOP w0.089: v1(19.55,64.34) 19.3,64.59 RN5702.3
  BOTTOM w0.089: v1(19.55,64.34) 19.82,64.08 D5701.1 20.78,64.08 v2(21.86,62.99)
HOST_DEBUG_TX: length 98.7
  TOP w0.102: v1(32.7,51.69) 32.7,52.29 33.45,53.04 v2(33.45,53.09) 32.91,53.09 32.68,52.86 R6801.1 ; DBG3.5 90.86,8.17 v1(89.63,9.4) ; R2478.2 30.3,44.02 31.01,43.31 U2401.81 33.11,43.31 v1(33.19,43.23)
  L3 w0.102: v1(45.98,42.09) 47.04,42.09 51.05,38.08 51.05,28.62 53.51,26.16 53.51,22.54 57.5,18.54 57.5,18.16 58.01,17.66 58.64,17.66 62.49,13.81 64.3,13.81 66.86,11.25 68.32,11.25 69.54,10.03 69.54,9.61 70.44,8.71 83.03,8.71 84.17,9.86 89.17,9.86 89.63,9.4 v1(89.63,9.4) ; v1(33.19,43.23) 33.04,43.39 32.94,43.39 32.46,43.87 32.46,45.72 32.48,45.75 32.48,48.39 32.46,48.42 32.46,48.85 32.28,49.02 32.28,49.05 32.13,49.2 32.13,49.61 32.28,49.76 32.28,49.79 32.81,50.32 32.81,51.58 v1(32.7,51.69)
  BOTTOM w0.102: v1(33.19,43.23) 33.28,43.23 34.4,42.12 38.55,42.12 38.88,41.79 40,41.79 40.61,42.4 43.94,42.4 44.11,42.22 45.66,42.22 45.79,42.09 v1(45.98,42.09)
HOST_DEBUG_TX_CON: length 2.8
  TOP w0.102: v2(33.45,54.41) 32.89,54.41 v1(32.86,54.38) 32.56,54.08 R6801.2
  BOTTOM w0.102: DBG1.11 32.59,54.65 v1(32.86,54.38)
HPDIN: length 2.5
  TOP w0.089: U7301.32 27.72,73.39 v1(27.68,73.43)
  BOTTOM w0.089: R7307.2 27.88,73.27 27.72,73.43 v1(27.68,73.43) 27.48,73.64 v2(27.48,74.02)
HVA_GATE1: length 3.9
  TOP w0.089: U7204.B9 75.51,97.26 75.76,97.01 75.76,96.6 75.76,96.6 75.76,96.17 75.6,96.01
  TOP w0.254: R7230.1 v2(75.81,94.57) 75.81,94.82 75.61,95.02 75.61,95.36 75.6,95.37 75.6,96.01
HVA_GATE2: length 3
  TOP w0.089: 75.13,95.69 75.13,95.94 75.51,96.32 U7204.A9
  TOP w0.508: R7231.1 75.13,94.01 v2(75.13,95.68) 75.13,95.69
HW_ACAV_IN: length 4.5
  TOP w0.102: R2469.1 48.61,35.69 48.18,36.12 v2(47.95,36.12) 47.42,36.12 46.53,35.23 45.69,35.23 45.58,35.34 U2401.128
HW_ACAVIN_NB: length 62.7
  TOP w0.102: R4315.2 41.27,82.96 40.74,82.43 39.87,82.43 39.49,82.81 R4311.2 38.99,82.74 38.99,80.15 v1(38.81,79.96) ; U2401.24 44.47,46.51 43.58,47.4 v1(43.58,50.02)
  L3 w0.102: v1(38.81,79.96) 38.81,79.07 37.59,77.86 37.59,76.15 38.07,75.67 38.07,74.09 35.25,71.28 35.25,61.85 35.68,61.42 35.68,59.63 37.55,57.76 38.81,57.76 41.14,55.43 41.58,55.43 42.34,54.67 42.34,51.26 v1(43.58,50.02)
  BOTTOM w0.102: R4378.2 37.84,80.14 37.48,79.79 36.44,79.79 v2(36.41,79.75) 35.96,79.3 35.3,79.3 34.79,78.79 33.22,78.79 32.94,79.07 Q4349.5 32.05,79.07 31.9,78.92 31.9,78.79 31.77,78.67 31.77,78.29 30.53,77.05 D4308.A ; R4378.2 38.4,80.37 v1(38.81,79.96) ; R4378.2 37.69,80.8 35.35,80.8 U4302.1
I2C1_SCL_R: length 16
  TOP w0.089: AFTP6528.1 175.05,12.78 v1(175.56,12.27) 175.94,11.89 175.94,10.82 R6518.2 R6515.2 175.76,8.82 RN6502.4
  BOTTOM w0.089: Q6503.6 180.47,17.01 179.62,17.86 178.97,17.86 177.4,16.28 175.99,16.28 175.21,15.5 TPAD1.6 175.21,14.96 175.39,14.78 175.67,14.78 176.35,14.11 176.35,13.06 v1(175.56,12.27)
I2C1_SDA_R: length 23.3
  TOP w0.089: v1(180.74,13.82) 180.44,14.12 v1(180.44,19.38) ; R6511.2 177.42,8.75 RN6502.3 176.5,12.14 R6519.2 176.4,13.82 AFTP6527.1 175.83,14.23 v1(175.32,13.72)
  L4 w0.114: v1(175.32,13.72) 178.05,13.72 178.4,13.36 180.28,13.36 v1(180.74,13.82)
  BOTTOM w0.089: v1(175.32,13.72) 174.98,13.72 174.21,14.49 TPAD1.7 ; Q6503.3 181.77,19.01 181.4,19.38 v1(180.44,19.38)
I2C_CLK_PD: length 113.2
  TOP w0.089: v1(23.34,62.15) 24.11,62.15 24.51,61.75 28.44,61.75 29.1,62.41 29.1,62.44 29.25,62.59 30.8,62.59 31.01,62.39 32.25,62.39 32.91,63.05 32.91,64.87 v2(33,64.96) 34.61,66.58 34.61,67.67 34.09,68.19 R7304.2 ; v1(82.59,97.41) 82.37,97.18 RN7206.3 81.97,96.77 80.58,98.16 80.58,98.21 80.34,98.45 80.34,98.45 80.27,98.51 80.03,98.51 80.03,98.51 79.25,98.51 U7204.D2
  L4 w0.114: v1(82.59,97.41) 81.38,97.41 80.62,98.17 80.62,98.23 80.36,98.48 80.3,98.48 78.85,99.94 75.7,99.94 75.66,99.98 74.82,99.98 73.25,98.4 71.98,98.4 71.55,98.83 69.33,98.83 67.94,97.44 64.46,97.44 64.21,97.18 50.84,97.18 50.03,96.36 43.38,96.36 43.31,96.44 36.9,96.44 29.51,89.05 29.51,87.18 28.26,85.93 28.26,82.55 25.39,79.68 25.39,77.68 23.95,76.23 23.95,74.2 20.32,70.57 20.32,64.69 22.86,62.15 v1(23.34,62.15)
I2C_CLK_PD_MUX: length 4.9
  TOP w0.089: U7301.21 29.66,68.56 30.8,67.41 v2(32.15,67.41) 32.53,67.41 32.82,67.7 R7304.1
I2C_DATA_PD: length 109.8
  TOP w0.089: RN7206.4 81.88,96.12 81.67,96.33 81.67,96.76 80.39,98.05 v1(80.18,98.05) 80.17,98.04 79.98,98.04 79.76,98.27 U7204.D1 ; v1(23.9,61.65) 24.08,61.46 28.54,61.46 29.39,62.32 30.7,62.32 30.91,62.1 32.35,62.1 33.19,62.94 33.19,64.66 v2(34.08,65.54) 34.89,66.36 34.89,67.77 R7305.2
  L4 w0.114: v1(80.18,98.05) 80.11,98.05 78.68,99.47 78.12,99.47 78.12,99.47 77.56,99.47 77.08,99 74.4,99 73.43,98.02 71.72,98.02 71.28,98.46 69.49,98.46 68.09,97.06 64.81,97.06 64.48,96.73 50.92,96.73 50.19,96 43.22,96 43.14,96.07 37.06,96.07 29.89,88.91 29.89,87.02 28.65,85.78 28.65,82.4 25.78,79.53 25.78,77.52 24.33,76.08 24.33,74.04 20.69,70.41 20.69,64.85 21.78,63.76 22.35,63.76 23.9,62.21 v1(23.9,61.65)
I2C_DATA_PD_MUX: length 4.4
  TOP w0.089: R7305.1 32.52,68.98 31.69,68.15 v2(31.03,68.15) 31.03,68.61 30,69.65 U7301.22
I2C_IRQ1#: length 4.1
  TOP w0.102: R7240.2 81.53,95.25 v2(81.4,95.38) 81.4,95.68 81.15,95.94 81.15,96.14 79.75,97.54 79.75,97.56 79.55,97.77 U7204.C1
I2CB_SCL: length 17.7
  TOP w0.089: v1(187.61,75.74) 187.73,75.62 v2(187.73,74.68)
  L3 w0.114: v1(187.61,75.74) 187.91,75.44 187.91,72.94 187.24,72.26 187.24,68.56 187.37,68.43 187.37,65.48 189.2,63.66 189.2,61.93 v1(189.15,61.88)
  BOTTOM w0.089: RN7905.3 188.9,61.63 v1(189.15,61.88) ; GPU1.C9 v1(187.61,75.74)
I2CB_SDA: length 16.5
  TOP w0.089: v1(189.73,62.23) 189.33,62.64 v2(189.22,62.64)
  L3 w0.114: v1(188.56,73.1) 187.58,72.12 187.58,68.6 187.75,68.43 187.75,65.94 189.58,64.11 189.58,63.76 189.73,63.6 v1(189.73,62.23)
  BOTTOM w0.089: v1(188.56,73.1) 187.95,73.72 187.95,74.14 187.53,74.56 GPU1.C8 ; v1(189.73,62.23) 189.73,61.85 189.55,61.67 RN7905.4
I2CC_SCL: length 15.7
  L3 w0.114: v1(189.38,73.38) 189.66,73.11 189.66,71.55 188.41,70.31 188.41,68.53 188.51,68.43 188.51,66.25 190.34,64.42 190.34,64.37 190.72,63.99 190.72,63.96 191,63.68 v1(191,62.31)
  BOTTOM w0.089: RN7904.4 191.07,62.24 v1(191,62.31) 190.77,62.54 v2(190.77,62.94) ; GPU1.A9 188.98,73.79 188.98,73.78 v1(189.38,73.38)
I2CC_SDA: length 16.7
  L3 w0.114: v1(189.19,72.78) 189.19,71.43 188.05,70.29 188.05,68.51 188.13,68.43 188.13,66.09 189.96,64.26 189.96,64.21 190.34,63.83 190.34,62.31 v1(190.37,62.28)
  BOTTOM w0.089: GPU1.B9 188.31,74.45 188.31,73.94 188.98,73.27 188.98,72.99 v1(189.19,72.78) ; RN7904.3 190.42,62.23 v1(190.37,62.28) 189.88,62.77 v2(189.22,62.77)
I2CEN: length 4.3
  TOP w0.102: U7301.17 27.72,68.09 v1(27.86,67.95)
  BOTTOM w0.102: R7344.2 27.12,68.81 v2(27.6,69.29) 27.86,69.29 R7343.1 28.49,68.23 28.19,67.92 27.89,67.92 v1(27.86,67.95)
I_ADP: length 26
  TOP w0.102: v1(26.64,28.78) 26.64,28.2 25.09,26.65 25.09,26.34 v2(25.14,26.29) 25.6,25.83 R2423.1 C2436.1 ; v1(37.36,37.72) 38.38,36.7 U2401.110
  L3 w0.102: v1(26.64,28.78) 26.64,28.86 26.46,29.03 26.46,32.46 27.55,33.56 28.21,33.56 v1(28.24,33.53)
  BOTTOM w0.102: v1(28.24,33.53) 28.34,33.53 28.54,33.33 31.57,33.33 31.82,33.07 31.82,32.87 32.13,32.57 32.61,32.57 34.61,34.57 34.61,35.38 35.71,36.48 35.71,37.04 36.52,37.85 37.23,37.85 v1(37.36,37.72)
I_BATT: length 16.1
  TOP w0.102: v1(34.87,39.4) 34.87,38.76 32.84,36.73 32.84,35.23 33.06,35 v2(33.06,34.37) 32.76,34.37 32.38,34.75 C2431.1 32.1,34.7 R2483.1 ; v1(40.13,38.31) 40.11,38.31 39.98,38.17 U2401.114
  BOTTOM w0.102: v1(40.13,38.31) 39.62,38.81 35.94,38.81 35.63,39.12 35.15,39.12 v1(34.87,39.4)
IC_DELAY: length 5
  BOTTOM w0.102: v2(33.03,84.75) U4302.4 34.11,82.6 34.69,82.6 C4344.1
ICSP_CLK: length 80.1
  TOP w0.102: v2(91.15,10.04) 91.03,9.91 v1(91.03,9.4) 91.18,9.4 92.36,8.23 DBG3.2 ; v1(34.72,37.04) 34.78,36.97 U2401.101
  L3 w0.102: v1(91.03,9.4) 90.29,8.66 85.08,8.66 82.91,6.49 82.83,6.49 82.82,6.48 75.91,6.48 75.53,6.86 69.72,6.86 69.01,7.57 61.79,7.57 59.63,9.73 57.27,9.73 55.95,11.05 54.6,11.05 53.61,12.04 52.8,12.04 50.34,14.51 50.34,14.66 50.36,14.68 50.36,15.02 46.1,19.28 44.15,19.28 41.62,21.81 41.62,26.36 41.37,26.61 40.58,26.61 38.08,29.12 38.08,32.74 34.72,36.1 v1(34.72,37.04)
ICSP_CLR: length 86.8
  TOP w0.102: v2(88.64,9.93) 88.64,9.93 88.64,9.79 v1(89,9.43) 89,9.3 90.36,7.94 DBG3.6 ; R2414.1 29.43,40.97 29.8,40.97 29.81,40.96 30.17,40.96 30.18,40.97 v1(30.65,40.97) 30.71,40.91 U2401.87
  L3 w0.102: v1(45.51,41.66) 45.61,41.66 47.26,40 47.26,36.76 48.05,35.97 48.08,35.97 48.76,35.28 48.76,35.26 49.3,34.72 49.3,33.99 49.35,33.93 49.35,29.96 53.26,26.06 53.26,22.43 57.3,18.39 57.3,18.08 57.92,17.45 58.54,17.45 62.4,13.59 64.23,13.59 66.78,11.05 68.24,11.05 69.34,9.95 69.34,9.53 70.35,8.51 83.13,8.51 84.04,9.43 v1(89,9.43)
  BOTTOM w0.102: v1(30.65,40.97) 31.33,41.65 37.99,41.65 38.73,40.92 39.44,40.92 40.71,42.19 43.83,42.19 44.55,41.48 45.33,41.48 v1(45.51,41.66)
ICSP_DAT: length 80.9
  TOP w0.102: v1(34.72,37.67) 35.2,37.19 35.2,35.91 U2401.102 ; v2(89.88,10.01) 90.32,9.58 v1(90.32,9.38) 91.33,8.36 91.61,8.36 91.86,8.12 DBG3.3
  L3 w0.102: v1(34.72,37.67) 35.15,37.24 35.15,36.02 38.28,32.89 38.28,29.24 40.67,26.84 41.46,26.84 41.85,26.45 41.85,21.9 44.24,19.51 45.97,19.51 45.99,19.54 46.17,19.54 46.2,19.51 46.43,19.51 50.57,15.37 50.57,14.58 52.9,12.25 53.72,12.25 54.71,11.25 56.05,11.25 57.37,9.93 59.73,9.93 61.84,7.83 69.06,7.83 69.82,7.06 75.64,7.06 76.02,6.68 82.72,6.68 84.9,8.87 89.81,8.87 v1(90.32,9.38)
ILIM_HI: length 2.9
  TOP w0.102: R3604.2 22.19,32.41 21.84,32.06 v2(21.84,31.7) v1(22.65,31.7)
  BOTTOM w0.102: v1(22.65,31.7) 22.56,31.7 22.47,31.61 U3601.16
ILIM_LO: length 3.9
  TOP w0.102: v1(23.03,32.34) 23.34,32.64 23.34,33.28 v2(23.11,33.5) 23.07,33.54 22.38,33.54 R3603.2
  BOTTOM w0.102: U3601.15 22.45,32.11 22.68,32.34 v1(23.03,32.34)
ILIM_SEL: length 2.3
  BOTTOM w0.102: U3601.4 19.39,30.37 v2(18.92,29.9) 18.1,29.9 R3605.2
INPUT3VSEL: length 47.6
  TOP w0.102: R1520.2 146.12,45.21 R1521.1 147.03,46.13 v2(147.03,50.14) 147.03,51.44 142.92,55.55 135.95,55.55 131.01,60.5 131.01,61.42 128.67,63.76 128.67,65.36 128.26,65.76 128.26,66.54 126.88,67.92 125.2,67.92 124.95,67.67 124.95,67.47 124.67,67.19 124.33,67.19 123.94,67.58 123.94,67.76 123.68,68.02 119.73,68.02 119.45,67.74 119.45,67.31 v1(119.04,66.91)
  BOTTOM w0.102: v1(119.04,66.91) 119.01,66.94 118.43,66.94 118.25,67.11 118.25,67.59 CPU1.BT27
INT2_SELECT: length 125
  TOP w0.102: R7012.1 164.31,54.59 161.85,52.14 v2(161.66,52.14) 161.21,51.69 v1(160.4,51.69) ; v1(214.76,58.49) 215.79,59.51 R7008.1 216.33,59.54 216.33,61.42 216.61,61.7 Q7001.5
  L3 w0.102: v1(160.4,51.69) 160.4,49.66 164.72,45.34 164.72,41.25 169.28,36.68 170.63,36.68 170.63,36.68 170.84,36.68 171.55,35.97 171.8,35.97 v1(173.03,34.74)
  L6 w0.102: v1(217.48,25.01) 217.03,25.01 216.2,25.83 216.2,27.42 215.2,28.43 206.72,28.43 205.39,29.76 202.67,29.76 202.05,29.14 194.41,29.14 193.03,30.51 188.97,30.51 188.72,30.76 185.19,30.76 183.23,32.72 179.55,32.72 178.53,33.73 177.21,33.73 176.07,34.88 173.16,34.88 v1(173.03,34.74)
  BOTTOM w0.102: v1(217.48,25.01) 217.69,25.22 221.11,25.22 222.57,26.69 222.57,51.44 216.62,57.39 D7001.2 216.62,58.18 216.07,58.73 215.01,58.73 v1(214.76,58.49)
INT#_TYPEC_R: length 4.2
  TOP w0.089: 76.52,95.61 76.52,96.01 76.96,96.45 77.11,96.45 77.25,96.6 77.25,97.02 U7204.B6
  TOP w0.102: R7238.2 77.08,94.95 v2(77.24,95.1) 77.24,95.28 77.13,95.38 76.75,95.38 76.52,95.61
IR_CAM_DET#: length 9.4
  BOTTOM w0.076: 134.46,69.17 v2(134.31,69.32) 134.08,69.55 133.65,69.55 132.96,70.23 132.53,70.23 132.11,70.66 129.77,70.66 129.69,70.68 129.48,70.68 129.44,70.68 129.43,70.66 129.13,70.66 129.05,70.69 128.44,70.69 128.42,70.72 128.26,70.72 CPU1.CM22
  BOTTOM w0.102: R2046.2 135.81,67.72 135.81,67.74 135.45,68.1 135.45,68.3 134.59,69.17 134.46,69.17
IRQ1#: length 1.9
  TOP w0.102: R7240.1 82.65,94.77 R7241.2 83.38,94.49 v2(83.51,94.36)
ISH_KB_DISABLE: length 22.6
  TOP w0.102: v1(128.77,49.17) 129.03,49.43 v2(129.36,49.43) 129.74,49.43 129.92,49.25 129.92,47.86 129.84,47.78 Q2001.2
  BOTTOM w0.076: 121.24,58.89 121.3,58.96 121.3,60.53 121.13,60.71 121.13,61.22 121.26,61.36 121.26,61.8 arc(121.26,61.83) 121.24,61.86 121.22,61.9 arc(121.21,61.94) 121.2,61.99 121.2,62.58 CPU1.BW35
  BOTTOM w0.102: v1(128.77,49.17) 128.34,48.75 127.91,48.75 122.57,54.08 122.57,54.56 122.9,54.89 122.9,56.7 122.79,56.81 122.09,56.81 121.22,57.68 121.22,58.88 121.24,58.89
IST_TRIG: length 6.4
  BOTTOM w0.102: TP620.1 131.16,59.67 131.16,61.83 130.55,62.44 129.47,62.44 CPU1.CP36
ITP_PMODE: length 5.5
  BOTTOM w0.102: CPU1.W4 95.8,82.86 95.8,84.34 95.92,84.83 95.92,85.02 94.38,86.55 TP618.1
JACK_PLUG: length 13.3
  TOP w0.254: v1(14.12,15.27) 15.03,15.27 15.11,15.34 15.82,15.34 15.97,15.19 v2(16,15.19) 16,14.99 15.59,14.58 ED2909.1 15.28,13.79 15.41,13.67 R2923.1
  L4 w0.254: AUD1.5 13.78,11.65 14.89,12.76 14.89,14.9 14.52,15.27 v1(14.12,15.27)
JACK_PLUG_DET: length 12.6
  TOP w0.254: AUD1.6 5.31,12.7 11.55,12.7 13,11.25 v2(13.37,11.25) 14.04,11.25 14.47,11.69 R2914.1 14.47,12.68 ED2907.1
JGND:
  vias: v2(24.02,87.95) v3(23.49,92.53) v3(24.05,91.83) v3(24.28,92.84) v3(25.11,92.84) v3(25.11,91.82)
JIO3_PCIE_WAKE#: length 82.6
  TOP w0.102: R1822.2 165.98,63.78 v1(165.93,63.73) ; AFTP6608.1 196.43,54.84 196.43,54.96 196.72,55.25 v1(196.72,55.27) 196.69,55.27 196.43,55.53 196.43,56.88 R6105.2
  L4 w0.102: v1(151,77.96) 151.63,77.32 151.63,75.42 151.66,75.39 151.66,74.91 151.96,74.6 154.68,74.6 156.61,72.67 156.61,71.75 159.21,69.16 159.21,67.97 159.38,67.8 159.38,67.8 161.06,66.12 163.54,66.12 v1(165.93,63.73) 165.93,63.53 175.05,54.41 175.05,51.03 181.98,44.1 182.79,44.1 183.33,44.64 183.33,48.16 185.41,50.24 192.83,50.24 196.43,53.84 196.43,54.96 196.72,55.25 v1(196.72,55.27)
  BOTTOM w0.102: R1843.2 146.37,80.34 148.79,80.34 151,78.13 v1(151,77.96)
JIO3_PCIE_WAKE#_R: length 7.7
  TOP w0.102: v1(197.02,57.13) 196.87,57.13 196.56,57.43 v2(196.56,57.74) 196.56,57.92 195.98,58.5 R6105.1
  BOTTOM w0.102: v1(197.02,57.13) 197.23,57.13 200.21,60.11 WLAN1.55
