# Allegro board 17859-1.0710WZS1337.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
KB_BL_CTRL#: length 6.8
  TOP w0.508: AFTP6607.1 100.48,11.4 v1(100.62,11.25)
  BOTTOM w0.305: 100.05,11.25 KB_BL1.4
  BOTTOM w0.508: Q6501.D 104.37,11.25 v1(100.62,11.25) 100.05,11.25
KB_DET#: length 253.7
  TOP w0.102: AFTP6519.1 62.07,9.5 v1(62.51,9.93)
  L3 w0.102: v1(62.51,9.93) 62.51,10.4 61.24,11.67 59.75,11.67 59.45,11.38 57.89,11.38 56.59,12.68 55.24,12.68 54.68,13.24 54.68,13.54 52.09,16.13 52.09,16.41 46.95,21.55 46.95,25.16 41.62,30.49 41.62,34.32 43.86,36.55 43.86,37.49 43.31,38.05 v1(43.31,38.82) ; v1(131.95,77.12) 131.95,76.18 133.27,74.86 133.27,74.35 138.35,69.27 152.48,69.27 153.68,68.06 153.68,56.93 155.51,55.1 157.6,55.1 160.83,51.87 160.83,49.56 165.91,44.48 165.91,40.58 169.38,37.11 v1(170.81,37.11)
  BOTTOM w0.076: v1(131.95,77.12) 131.87,77.19 131.51,77.19 131.35,77.34 130.73,77.39 130.14,77.76 129.84,77.76 129.66,77.74 129.54,77.74 129.35,77.76 129.18,77.76 129.14,77.76 129.07,77.75 129.06,77.75 128.51,77.67 128.27,77.56 CPU1.CM12
  BOTTOM w0.102: KB1.30 v1(62.51,9.93) ; v1(131.95,77.12) 133.62,77.12 134.22,76.52 135.42,76.52 135.74,76.2 136.11,76.2 137.15,75.16 R2045.2 ; v1(170.81,37.11) 170.56,37.11 167.16,33.7 154.18,33.7 153.43,32.95 72.54,32.95 68.81,36.68 66.69,36.68 66.24,36.22 58.95,36.22 57.75,37.42 56.24,37.42 56,37.18 54.26,37.18 53.03,38.41 50.29,38.41 50.13,38.26 50.13,37.85 49.91,37.62 49.5,37.62 49.27,37.85 49.27,38.26 49.12,38.41 45.49,38.41 45.38,38.51 45.03,38.51 44.93,38.61 43.51,38.61 v1(43.31,38.82)
KB_DISABLE_CPU_R: length 4.4
  TOP w0.102: Q2001.5 131.31,47.78 131.35,47.82 131.35,48.35 131.27,48.43 Q2001.6 130.47,48.65 130.47,49.79 v2(130.52,49.84) 130.52,50.6 R2001.2
KB_LED_BL_DET: length 170.4
  TOP w0.102: v1(101.85,13.41) 102.53,12.73 AFTP6606.1 102.18,12.14 101.42,12.91 101.42,14.07 R6507.1
  L4 w0.102: v1(101.85,13.41) 102.89,14.46 102.89,14.99 103.58,15.67 107.66,15.67 110.36,18.37 134.91,18.37 135.33,17.96 136.14,17.96 137.13,18.95 153.33,18.95 153.51,18.77 168.97,18.77 169.72,18.03 v1(169.72,17.95) ; v1(175.9,24.78) 175.74,24.62 175.74,24.18 175.51,23.95 175.13,23.95 174.87,24.21 174.87,32.11 175.15,32.39 175.38,32.39 175.76,32.77 175.76,33.82 170.84,38.74 168.09,38.74 167.99,38.84 167.28,38.84 162.43,43.69 162.43,44.05 162.1,44.38 162.07,44.38 161.61,44.83 161.59,44.83 v1(160.85,45.57)
  L6 w0.102: v1(175.9,24.78) 175.99,24.87 177.54,24.87 178.43,23.98 178.43,20.69 178.18,20.43 178.18,19.41 178.68,18.9 178.68,17.96 178.38,17.66 177.67,17.66 177.34,17.99 176.96,17.99 176.5,17.53 170.14,17.53 v1(169.72,17.95)
  BOTTOM w0.076: CPU1.CK36 127.07,62.1 129.38,59.79 130.21,59.79 132.32,57.69 133.46,57.69 133.52,57.63
  BOTTOM w0.102: v1(160.85,45.57) 160.85,49.51 158.64,51.72 157.2,51.72 156.89,51.41 156.53,51.41 156.13,51.82 148.04,51.82 143.78,56.09 135.07,56.09 133.52,57.63 ; R6503.1 101.85,13.77 v1(101.85,13.41)
KB_LED_DET_C: length 7.4
  TOP w0.102: v1(100.68,13.41) C6502.1 100.58,14 v2(99.79,14.79)
  BOTTOM w0.102: KB_BL1.2 97.41,11.97 97.73,12.3 100.22,12.3 100.68,12.75 v1(100.68,13.41) R6503.2
KB_LED_PWM: length 102.1
  TOP w0.102: v1(103.91,14.66) v2(103.91,15.29) ; v1(40.56,43.94) 40.18,44.32 40.18,46.51 40.48,46.81 40.48,49.13 40.96,49.61 40.96,49.84 41.18,50.05 U2401.44
  L4 w0.102: v1(40.56,43.94) 41.53,43.94 41.75,43.72 41.85,43.72 41.88,43.69 43.43,43.69 44.37,42.75 44.85,42.75 45.1,42.5 45.76,42.5 45.79,42.52 46.17,42.52 46.2,42.5 48.43,42.5 50.41,40.52 50.41,37.21 50.36,37.16 50.36,36.2 50.44,36.12 50.44,35.94 51.43,34.95 51.43,34.11 51.76,33.78 51.76,32.51 51.43,32.18 51.43,30.41 51.4,30.38 51.4,30.28 50.95,29.82 50.95,28.53 52.27,27.21 52.27,21.03 54.68,18.62 54.68,18.09 54.61,18.02 54.61,17.67 56.25,16.04 56.42,16.04 56.43,16.03 57.09,16.03 57.22,15.9 57.88,15.9 58.01,16.03 58.41,16.03 58.54,15.9 59.05,15.9 60.5,14.46 61.89,14.46 61.94,14.4 65.6,14.4 67.33,12.68 67.63,12.37 70,12.37 71.11,11.25 73.43,11.25 74.01,11.84 75.46,11.84 76.89,10.4 89.69,10.4 90.14,10.85 93.43,10.85 94.72,12.14 98.65,12.14 99,12.5 102.86,12.5 103.91,13.54 v1(103.91,14.66)
  BOTTOM w0.102: v1(103.91,14.66) R6505.1 103.91,12.92 Q6501.G
KBC_BEEP_R: length 2.8
  BOTTOM w0.254: R2734.2 26.79,24.06 v2(27.1,23.75) 27.1,23.04 D2703.2
KBC_PWRBTN#: length 187.4
  TOP w0.102: v1(50.19,30.79) 50.19,30.99 50.39,31.19 R2432.1 ; RN6401.2 215.97,36.78 TP9954.1 215.37,36.45 213.84,34.92 213.84,31.86 216.22,29.47 216.22,26.27 215.92,25.96 215.92,25.88 215.03,25 v1(214.95,25)
  L6 w0.102: v1(214.95,25) 212.54,25 211.32,23.78 211.32,23.75 211.09,23.52 209.62,23.52 207.64,21.54 204.04,21.54 203.84,21.75 201.16,21.75 199,23.9 199,24.52 197.95,25.58 190.14,25.58 187.57,28.15 179.47,28.15 178.89,27.56 v1(178.84,27.56)
  BOTTOM w0.102: v1(178.84,27.56) 178.4,27.56 176.08,29.88 155.57,29.88 155.13,29.44 108.81,29.44 108.78,29.42 98.44,29.42 98.42,29.44 51.53,29.44 v1(50.19,30.79)
KBC_PWRBTN#_C: length 19.6
  TOP w0.102: v1(219.07,48.47) 217.7,47.09 217.7,46.05 217.85,45.9 G6401.1 G6402.1 220.36,45.7 EC6403.1 221.36,45.72 ED6401.1 222.6,45.29 222.6,45.09 v2(221.16,43.65) 218.97,41.46 218.2,41.46 216.15,39.4 216.15,39.07 215.97,38.89 RN6401.3
  BOTTOM w0.102: IOBD1.9 218.79,48.75 v1(219.07,48.47)
KSI0: length 63.8
  TOP w0.089: U2401.98 33.58,34.76 v1(33.59,34.75) 33.59,34.38 32.74,33.53 32.74,32.91 32.45,32.62 32.1,32.62 31.81,32.91 31.81,33.05 31.54,33.32 29.89,33.32 29.68,33.11 28.06,33.11 27.68,33.49 27.68,33.63 27.45,33.86 RN2404.8 ; v1(68.74,9.93) 69.69,8.98 AFTP6507.1
  L3 w0.089: v1(47.92,32.31) 48.57,31.66 48.57,29.81 52.02,26.36 52.02,21.2 52.72,20.5 54.34,20.5 56.89,17.95 56.89,17.91 57.63,17.17 57.75,17.05 58.36,17.05 59.63,15.78 59.63,13.63 59.9,13.36 64.18,13.36 66.7,10.85 67.82,10.85 v1(68.74,9.93)
  L4 w0.089: v1(47.92,32.31) 47.92,32.42 47.26,33.07 46.22,33.07 44.04,35.25 34.1,35.25 v1(33.59,34.75)
  BOTTOM w0.089: v1(68.74,9.93) 68.81,9.93 68.91,9.83 KB1.22
KSI1: length 70
  TOP w0.089: U2401.99 33.98,34.97 34.02,34.93 34.02,34.54 32.93,33.45 32.93,32.51 v1(32.25,31.83) 32.68,31.4 32.68,29.44 32.59,29.35 30.04,29.35 29.61,29.77 RN2403.5 ; AFTP6540.1 68.32,9.05 v1(67.38,9.98)
  L3 w0.089: v1(47.77,31.42) 48.19,31 48.19,29.38 50.63,26.94 50.63,26.04 51.59,25.08 51.59,21 53.18,19.41 53.94,19.41 54.67,18.68 54.67,18.08 54.62,18.03 54.62,17.68 55.66,16.64 58.21,16.64 59.07,15.78 59.07,14.71 58.52,14.15 58.52,13.58 59.18,12.91 64.07,12.91 66.52,10.47 66.9,10.47 v1(67.38,9.98)
  L4 w0.089: v1(47.77,31.42) 47.77,31.86 47.49,32.14 47.49,32.28 47.06,32.71 42.66,32.71 42.31,32.36 34.83,32.36 34.17,33.02 33.44,33.02 v1(32.25,31.83)
  BOTTOM w0.089: KB1.24 67.31,9.91 v1(67.38,9.98)
KSI2: length 70.1
  TOP w0.089: v1(65.71,9.93) 65.86,9.78 AFTP6533.1 ; U2401.6 46.35,39.31 45.81,38.76 45.46,38.76 45.05,39.17 44.9,39.17 v1(44.83,39.25) ; v1(30.4,30.43) 30.16,30.19 27.77,30.19 27.6,30.36 RN2403.6
  L3 w0.089: v1(44.83,39.25) 44.83,39.17 44.93,39.07 44.93,38.78 45.56,38.16 45.56,38.03 45.56,38.03 45.56,36.43 44.85,35.72 44.81,35.72 42.85,33.76 42.85,30.8 43.1,30.56 45.51,30.56 v1(46.17,29.9) 49.02,27.05 49.02,24.35 49.28,24.09 49.28,21.51 50.28,20.5 51.02,20.5 55.69,15.83 55.72,15.83 59.05,12.5 62.53,12.5 64.15,10.88 64.76,10.88 v1(65.71,9.93)
  L4 w0.089: v1(46.17,29.9) 45,28.73 31.11,28.73 30.73,29.12 30.73,30.1 v1(30.4,30.43)
  BOTTOM w0.089: KB1.26 v1(65.71,9.93)
KSI3: length 72.5
  TOP w0.089: v1(45.84,39.42) 46.15,39.73 46.98,39.73 U2401.7 ; v1(68.11,9.94) 69.13,8.91 69.13,8.05 AFTP6502.1 ; RN2404.7 27.45,33.27 27.83,32.89 v1(30.07,32.89)
  L3 w0.089: v1(45.84,39.42) 46.7,38.56 46.7,36.43 47.57,35.56 47.9,35.56 48.33,35.13 48.33,34.88 48.13,34.67 48.13,33.23 47.49,32.59 47.49,32.14 47.74,31.89 47.91,31.89 48.38,31.42 48.38,29.66 51.8,26.24 51.8,21.11 52.93,19.99 54.54,19.99 57.42,17.11 57.42,17.1 57.68,16.84 58.29,16.84 59.28,15.85 59.28,14.61 58.73,14.06 58.73,13.69 59.25,13.17 64.1,13.17 66.62,10.66 67.39,10.66 v1(68.11,9.94)
  L4 w0.089: v1(45.84,39.42) 44.3,37.88 40.89,37.88 39.54,36.53 33.7,36.53 v1(30.07,32.89)
  BOTTOM w0.089: KB1.23 68.11,9.93 v1(68.11,9.94)
KSI4: length 69.7
  TOP w0.089: v1(31.31,29.77) 31.31,30.38 30.3,31.4 28.01,31.4 27.47,30.86 RN2403.7 ; U2401.104 35.98,36.56 35.48,37.06 35.48,37.7 v1(35.32,37.86) ; AFTP6521.1 64.82,8.51 v1(64.82,9.98)
  L3 w0.089: v1(31.31,29.77) 31.31,31.49 31.84,32.02 31.84,35.4 34.54,38.1 35.08,38.1 v1(35.32,37.86) ; v1(45.54,29.92) 48.32,27.14 48.32,24.74 49.06,24 49.06,21.07 52.7,17.43 53.54,17.43 57.8,13.17 57.8,12.3 58.13,11.97 58.95,11.97 59.28,12.3 62.46,12.3 64.07,10.69 64.54,10.69 64.82,10.41 v1(64.82,9.98)
  L4 w0.089: v1(45.54,29.92) 44.72,29.1 31.75,29.1 31.46,29.39 31.46,29.68 31.38,29.77 v1(31.31,29.77)
  BOTTOM w0.089: KB1.27 64.91,9.92 64.85,9.98 v1(64.82,9.98)
KSI5: length 64.5
  TOP w0.089: RN2404.6 27.45,32.77 27.68,32.54 27.68,32.29 27.93,32.03 30.55,32.03 v1(31.39,32.87) ; U2401.105 36.38,35.19 36.24,35.05 36.04,35.05 34.87,33.89 34.87,33.73 34.89,33.71 34.89,32.54 v1(35.55,31.88) ; v1(66.51,9.98) 67.6,8.89 AFTP6513.1
  L3 w0.089: v1(47.77,30.79) 47.77,29.5 50.41,26.85 50.41,25.95 51.33,25.04 51.33,20.58 55.55,16.36 58.21,16.36 58.87,15.7 58.87,14.89 58.32,14.34 58.32,13.5 59.12,12.7 64,12.7 66.51,10.2 v1(66.51,9.98)
  L4 w0.089: v1(47.77,30.79) 47.77,30.77 47.62,30.62 41.31,30.62 40.53,31.4 39.5,31.4 39.01,31.88 v1(35.55,31.88) 35.07,31.4 32.08,31.4 31.83,31.65 31.83,32.05 31.84,32.06 31.84,32.42 v1(31.39,32.87)
  BOTTOM w0.089: KB1.25 v1(66.51,9.98)
KSI6: length 59
  TOP w0.089: RN2404.5 27.2,32.18 27.55,31.83 31.01,31.83 v1(31.41,32.24) ; v1(64.13,9.98) 63.98,9.83 AFTP6511.1 ; v1(35.55,31.22) 35.97,31.64 35.97,32.06 35.69,32.34 35.43,32.34 35.08,32.69 35.08,33.8 36.13,34.85 36.72,34.85 37.18,35.31 U2401.107
  L3 w0.089: v1(64.13,9.98) 64.13,10.34 62.38,12.09 59.4,12.09 59.07,11.76 58.06,11.76 57.6,12.22 57.6,12.23 57.5,12.33 57.5,13.2 53.48,17.22 52.57,17.22 48.1,21.7 48.1,26.73 v1(44.9,29.92)
  L4 w0.089: v1(44.9,29.92) 44.49,30.33 40.96,30.33 40.35,30.94 39.68,30.94 39.41,31.22 v1(35.55,31.22) 35.55,31.21 32,31.21 31.41,31.8 v1(31.41,32.24)
  BOTTOM w0.089: v1(64.13,9.98) 64.13,9.93 64.11,9.91 KB1.28
KSI7: length 70
  TOP w0.089: v1(32.25,29.77) 32.2,29.77 30.37,31.6 27.76,31.6 27.6,31.45 RN2403.8 ; v1(36.79,37.4) 37.58,36.61 U2401.108 ; v1(63.39,9.93) 63.39,8.64 AFTP6523.1
  L3 w0.089: v1(32.25,29.77) 31.83,29.35 31.14,29.35 30.89,29.6 30.89,30.03 30.96,30.11 30.96,34.79 34.46,38.29 35.9,38.29 v1(36.79,37.4) ; v1(43.63,29.9) 44.6,28.93 45.24,28.93 47.88,26.29 47.88,20.93 51.97,16.85 53.58,16.85 57.3,13.13 57.3,12.25 57.97,11.57 59.29,11.57 59.59,11.87 61.38,11.87 62.82,10.43 62.89,10.43 v1(63.39,9.93)
  L4 w0.089: v1(43.63,29.9) 43.03,29.3 33.67,29.3 33.19,29.77 v1(32.25,29.77)
  BOTTOM w0.089: v1(63.39,9.93) 63.31,9.85 KB1.29
KSO0: length 92
  TOP w0.089: v1(41.1,39.17) 42.56,37.71 U2401.2 ; RN2415.7 54.99,44.23 54.68,43.92 v1(54.68,43.68) ; v1(76.98,9.93) 77.14,9.93 77.9,9.17 77.9,6.96 AFTP6520.1
  L3 w0.089: v1(76.98,9.93) 76.16,9.1 70.6,9.1 69.94,9.76 69.94,10.17 68.48,11.64 67.02,11.64 64.31,14.35 62.55,14.35 59.05,17.86 59,17.86 58.8,18.06 58.17,18.06 57.91,18.32 57.91,19.13 56.53,20.5 56.53,22.73 55.6,23.67 55.6,28.52 52.44,31.68 52.44,34.72 54.14,36.42 54.14,37.03 49.41,41.77 v1(49.41,45.62) ; v1(41.1,39.17) 40.8,39.47 40.8,43.57 40.98,43.76 40.98,45.04 v1(40.61,45.42)
  BOTTOM w0.089: v1(76.98,9.93) 76.94,9.88 76.45,9.88 76.11,9.55 KB1.13 ; v1(40.61,45.42) 41.29,44.73 45.64,44.73 45.69,44.78 48.57,44.78 v1(49.41,45.62) 49.5,45.54 51.01,45.54 51.73,44.81 52.65,44.81 52.99,45.15 54.5,45.15 54.98,44.67 54.98,43.99 v1(54.68,43.68)
KSO1: length 56.4
  TOP w0.089: AFTP6517.1 75.1,10.29 v1(75.1,9.96) ; U2401.14 47.71,42.51 48.48,43.28 53.03,43.28 53.62,43.87 v1(54.07,43.87) 54.07,43.69 54.5,43.26 54.96,43.26 RN2415.8
  L3 w0.089: v1(75.1,9.96) 74.28,10.78 73.82,10.78 70.83,13.77 68.04,13.77 63.94,17.87 63.94,19.75 63.04,20.65 63.04,31.14 56.8,37.37 56.8,40.4 55.16,42.04 55.16,42.47 54.68,42.95 54.68,43.08 54.07,43.69 v1(54.07,43.87)
  BOTTOM w0.089: KB1.15 74.51,9.52 74.94,9.95 75.1,9.95 v1(75.1,9.96)
KSO2: length 60.1
  TOP w0.089: U2401.15 47.84,42.91 48.4,43.47 52.86,43.47 v1(53.92,44.53) 54.7,45.32 RN2415.5 ; v1(75.74,9.91) 77.08,11.25 AFTP6510.1
  L3 w0.089: v1(75.74,9.91) 75.32,9.5 74.7,9.5 74.47,9.73 74.47,10.1 73.97,10.59 73.74,10.59 70.79,13.54 67.99,13.54 63.72,17.81 63.72,19.66 62.81,20.58 62.81,31.09 56.61,37.29 56.61,40.04 54.89,41.76 54.89,42.29 53.62,43.56 53.62,44.23 v1(53.92,44.53)
  BOTTOM w0.089: KB1.14 75.31,9.48 v1(75.74,9.91)
KSO3: length 66.4
  TOP w0.089: v1(73.64,9.93) 74.73,8.84 AFTP6518.1 ; RN2416.8 47.42,52.99 v1(47.62,52.78) ; v1(51.58,43.94) 51.3,43.66 48.32,43.66 47.97,43.31 U2401.16
  L3 w0.089: v1(73.64,9.93) 70.46,13.11 67.8,13.11 62.82,18.09 62.66,18.09 62.4,18.34 62.4,18.51 62.27,18.64 62.27,19.71 61.23,20.74 61.23,31.85 57.78,35.31 56.83,35.31 55.98,36.15 55.98,39.77 55.25,40.5 54.24,40.5 51.58,43.16 v1(51.58,43.94) 51.58,47.86 51.7,47.98 51.7,50.03 50.52,51.21 50.52,51.51 49.38,52.65 47.75,52.65 v1(47.62,52.78)
  BOTTOM w0.089: v1(73.64,9.93) 73.71,9.86 KB1.16
KSO4: length 65.4
  TOP w0.089: v1(71,9.93) 71,9.38 AFTP6522.1 ; RN2416.6 46.33,52.97 46.32,52.96 v1(46.32,52.78) 45.61,52.07 44.32,52.07 43.98,51.73 U2401.37
  L3 w0.089: v1(71,9.93) 68.8,12.14 67.08,12.14 64.22,15 62.54,15 61.69,15.85 61.69,17.05 58.53,20.21 58.53,26.63 54.15,31 54.15,32.9 54.52,33.27 54.52,37.19 50.03,41.69 50.03,50.2 48.25,51.98 47.18,51.98 47.01,52.15 45.71,52.15 45.26,52.61 45.26,52.96 45.5,53.21 45.9,53.21 v1(46.32,52.78)
  BOTTOM w0.089: v1(71,9.93) 70.51,9.44 KB1.20
KSO5: length 82
  TOP w0.089: AFTP6536.1 70.37,8.77 v1(70.37,9.93) ; v1(44.1,52.45) 43.58,51.93 U2401.38 ; v1(30.36,53.56) 30.36,53.26 30.09,52.99 RN2412.8
  L3 w0.089: v1(70.37,9.93) 70.37,10.02 68.48,11.91 67.02,11.91 64.17,14.76 62.43,14.76 59.13,18.06 59.08,18.06 58.82,18.32 58.82,18.62 57.8,19.64 57.8,21.77 56.04,23.54 56.04,28.81 52.63,32.22 52.63,34.26 54.33,35.96 54.33,37.11 49.84,41.61 49.84,50.12 48.17,51.79 47.66,51.79 v1(47.37,51.49)
  L4 w0.089: v1(30.36,53.56) 31.91,53.56 33.75,51.72 35.53,51.72 36.03,51.22 42.87,51.22 v1(44.1,52.45)
  BOTTOM w0.089: v1(44.1,52.45) 44.6,51.95 47.14,51.95 47.37,51.72 v1(47.37,51.49) ; KB1.21 69.71,9.34 70.3,9.93 v1(70.37,9.93)
KSO6: length 66
  TOP w0.089: U2401.39 43.18,52.15 43.91,52.89 44.29,52.89 44.55,52.63 44.55,52.5 44.77,52.28 45.18,52.28 v1(45.69,52.78) 45.74,52.83 RN2416.5 ; AFTP6512.1 73.39,8.82 v1(72.27,9.93)
  L3 w0.089: v1(72.27,9.93) 69.61,12.6 67.44,12.6 64.54,15.5 62.6,15.5 62.1,16 62.1,17.33 59.77,19.66 59.77,23.52 59.47,23.81 59.47,31.56 57.98,33.05 57.98,33.61 54.9,36.69 54.9,37.46 50.41,41.95 50.41,50.79 50.14,51.05 50.14,51.35 49.22,52.27 48.07,52.27 47.97,52.17 47.27,52.17 47.09,52.35 46.12,52.35 v1(45.69,52.78)
  BOTTOM w0.089: v1(72.27,9.93) 72.27,9.9 72.11,9.74 KB1.18
KSO7: length 82
  TOP w0.089: AFTP6534.1 74.21,7.36 v1(71.64,9.93) ; v1(30.37,52.48) 30.29,52.4 RN2412.7 ; v1(39.41,52.2) 39.11,52.2 38.78,51.87 U2401.50
  L3 w0.089: v1(71.64,9.93) 69.2,12.37 67.14,12.37 64.32,15.19 62.62,15.19 61.89,15.92 61.89,17.23 58.74,20.38 58.74,26.98 55.37,30.35 55.37,31.78 54.71,32.43 54.71,37.27 50.22,41.77 50.22,50.67 v1(49.04,51.84)
  BOTTOM w0.089: v1(71.64,9.93) 71.64,9.75 71.31,9.42 KB1.19 ; v1(49.04,51.84) 48.53,52.36 45.4,52.36 44.69,53.08 43.54,53.08 42.29,51.83 39.79,51.83 v1(39.41,52.2) 38.41,53.21 36.23,53.21 35.18,52.16 33.21,52.16 32.74,52.63 30.52,52.63 v1(30.37,52.48)
KSO8: length 71.5
  TOP w0.089: v1(72.91,9.93) 72.98,9.93 75.97,6.94 AFTP6505.1 ; U2401.46 40.38,51.74 40.58,51.95 40.94,51.95 v1(41.24,52.25) ; v1(46.96,52.78) 46.83,52.91 RN2416.7
  L3 w0.089: v1(72.91,9.93) 72.91,10.35 70.38,12.88 67.76,12.88 67.74,12.91 67.71,12.91 62.73,17.88 62.58,17.88 62.2,18.27 62.2,18.42 62.07,18.54 62.07,18.57 59.99,20.65 59.99,23.61 59.69,23.9 59.69,33.11 57.75,35.05 56.82,35.05 55.79,36.08 55.79,38.06 50.6,43.25 50.6,50.87 50.33,51.13 50.33,51.43 49.3,52.46 47.9,52.46 47.8,52.36 47.38,52.36 47.38,52.36 v1(46.96,52.78)
  L4 w0.089: v1(41.24,52.25) 41.24,52.75 41.7,53.21 46.53,53.21 v1(46.96,52.78)
  BOTTOM w0.089: KB1.17 v1(72.91,9.93)
KSO9: length 89.3
  TOP w0.089: R2450.2 29.26,47.47 R2449.1 29.62,48.27 v1(30.39,47.5) 30.5,47.5 30.65,47.65 30.65,48.14 31.02,48.51 U2401.68 ; v1(80.91,8.07) 82.01,6.97 AFTP6516.1
  L3 w0.089: v1(37.41,48.14) 37.41,46.26 37.59,46.08 37.59,44.88 38.2,44.27 38.2,37.42 39.07,36.54 39.07,29.37 40.95,27.5 41.73,27.5 43.22,26 43.22,21.45 44.43,20.25 46.61,20.25 51.18,15.69 51.18,14.83 53.15,12.86 53.94,12.86 54.93,11.86 56.28,11.86 57.6,10.54 60,10.54 61.98,8.57 69.15,8.57 70.05,7.67 75.89,7.67 76.3,7.27 80.1,7.27 v1(80.91,8.07)
  BOTTOM w0.089: v1(30.39,47.5) 31.53,46.35 35.07,46.35 36.86,48.14 v1(37.41,48.14) ; KB1.7 v1(80.91,8.07)
KSO10: length 92.2
  TOP w0.089: v1(82.51,8.07) 82.21,8.37 82.21,11 AFTP6503.1 ; v1(30.4,46.64) 30.8,46.64 31.08,46.91 U2401.72 ; RN2414.5 29.08,44.96 v1(29.36,45.24)
  L3 w0.089: v1(82.51,8.07) 81.32,6.89 76.12,6.89 75.72,7.28 69.89,7.28 69.13,8.05 61.93,8.05 59.84,10.14 57.45,10.14 56.13,11.46 54.78,11.46 53.79,12.45 53.02,12.45 50.77,14.7 50.77,15.48 46.44,19.81 44.25,19.81 42.07,22 42.07,26.55 41.55,27.06 40.77,27.06 38.48,29.35 38.48,32.97 37.79,33.66 37.79,44.12 37.18,44.73 37.18,45.8 36.56,46.42 36.56,47.23 v1(36.98,47.65) ; v1(29.36,45.24) 29.36,45.26 29.77,45.68 29.77,46.21 30.19,46.64 v1(30.4,46.64)
  BOTTOM w0.089: v1(36.98,47.65) 36.87,47.65 35.38,46.16 30.87,46.16 v1(30.4,46.64) ; KB1.5 v1(82.51,8.07)
KSO11: length 88.7
  TOP w0.089: AFTP6506.1 83.07,6.71 v1(81.71,8.07) ; RN2414.6 28.95,45.55 29.08,45.67 29.76,45.67 30.13,46.03 v1(30.19,46.03) 30.27,46.11 U2401.74
  L3 w0.089: v1(81.71,8.07) 80.71,7.08 76.19,7.08 75.8,7.47 69.97,7.47 69.13,8.31 61.97,8.31 59.94,10.34 57.53,10.34 56.2,11.66 54.86,11.66 53.87,12.65 53.08,12.65 50.97,14.76 50.97,15.58 46.52,20.03 44.34,20.03 42.29,22.09 42.29,26.64 41.64,27.28 40.86,27.28 38.88,29.25 38.88,36.45 37.99,37.34 37.99,44.2 37.38,44.81 37.38,45.88 36.98,46.28 v1(36.98,47.01)
  BOTTOM w0.089: v1(36.98,47.01) 36.98,46.59 36.36,45.97 30.26,45.97 v1(30.19,46.03) ; KB1.6 v1(81.71,8.07)
KSO12: length 89.2
  TOP w0.089: v1(76.91,8.07) 77.34,8.5 AFTP6538.1 ; v1(30.95,52.06) 30.9,52.02 30.05,52.02 30.04,52.01 30.03,52.01 29.92,51.9 RN2412.6 ; U2401.75 30.92,45.71 30.75,45.54 v1(30.59,45.54)
  L3 w0.089: v1(38.5,47.35) 38.85,47 38.85,42.14 39.5,41.49 39.5,36.93 39.73,36.7 39.73,29.6 40.07,29.25 42.55,29.25 46.63,25.17 46.63,21.31 54.48,13.46 54.48,13.16 55.16,12.47 56.51,12.47 57.83,11.15 60.24,11.15 61.96,9.44 69.12,9.44 70.28,8.28 76.7,8.28 v1(76.91,8.07) ; v1(30.95,52.06) 30.95,52.04 30.98,52 30.98,51.48 30.64,51.14 30.64,50.79 30.47,50.62 30.47,49.04 30.39,48.95 30.25,48.95 29.84,48.54 29.84,48.19 30.09,47.93 30.65,47.93 30.8,47.78 30.8,47.7 30.83,47.68 30.83,47.32 30.8,47.3 30.8,46.84 30.83,46.81 30.83,46.46 30.8,46.43 30.8,45.75 v1(30.59,45.54)
  BOTTOM w0.089: v1(38.5,47.35) 38.08,47.77 37.69,47.77 37.44,47.52 37.44,46.49 36.72,45.77 30.83,45.77 v1(30.59,45.54) ; KB1.12 v1(76.91,8.07)
KSO13: length 86.9
  TOP w0.089: v1(29.34,46.1) 29.3,46.05 RN2414.7 ; v1(29.99,45.3) 30.07,45.21 30.09,45.21 30.22,45.09 30.96,45.09 31.05,45.18 31.08,45.18 31.2,45.31 U2401.76 ; v1(79.31,8.07) 80.43,9.2 AFTP6535.1
  L3 w0.089: v1(79.31,8.07) 78.69,7.46 76.47,7.46 76.05,7.88 70.12,7.88 69.17,8.83 61.99,8.83 60.07,10.75 57.68,10.75 56.36,12.07 55.01,12.07 54.02,13.06 53.22,13.06 51.61,14.67 51.61,15.56 46.67,20.5 45.89,20.5 44.26,22.12 44.26,25.27 41.82,27.71 41.03,27.71 39.26,29.48 39.26,36.62 38.4,37.49 38.4,44.35 37.87,44.88 v1(37.87,47.35)
  BOTTOM w0.089: v1(29.34,46.1) 29.34,45.94 v1(29.99,45.3) 30.17,45.11 32.81,45.11 33.27,45.57 37.06,45.57 37.87,46.37 v1(37.87,47.35) ; KB1.9 v1(79.31,8.07)
KSO14: length 78.5
  TOP w0.089: v1(80.11,9.93) 79.98,10.06 AFTP6539.1 ; U2401.77 32.35,44.91 32.84,45.39 34.84,45.39 35.57,44.66 v1(35.57,43.59) ; RN2415.6 54.79,44.73 v1(54.56,44.49)
  L3 w0.089: v1(80.11,9.93) 79.19,10.85 77.13,10.85 73.65,14.33 67.76,14.33 64.15,17.94 64.15,19.84 63.27,20.73 63.27,31.18 56.99,37.45 56.99,40.74 56.28,41.46 56.28,42.77 v1(54.56,44.49)
  BOTTOM w0.089: KB1.8 v1(80.11,9.93) ; v1(35.57,43.59) 36.51,44.53 45.71,44.53 45.76,44.58 49.04,44.58 49.5,45.04 51.23,45.04 51.66,44.61 52.72,44.61 53.08,44.96 54.1,44.96 54.56,44.5 v1(54.56,44.49)
KSO15: length 84.8
  TOP w0.089: U2401.86 30.95,41.31 30.87,41.39 30.83,41.39 30.83,41.4 30.48,41.4 30.47,41.39 v1(29.99,41.39) ; v1(78.51,8.07) 79.95,6.63 AFTP6515.1 ; v1(29.29,46.73) 29.2,46.64 RN2414.8
  L3 w0.089: v1(78.51,8.07) 78.08,7.65 76.6,7.65 76.17,8.08 70.2,8.08 69.03,9.25 61.84,9.25 60.14,10.95 57.75,10.95 56.43,12.27 55.09,12.27 54.1,13.26 53.28,13.26 51.81,14.73 51.81,15.81 46.91,20.71 45.98,20.71 45.38,21.31 45.38,26.11 43.57,27.93 41.12,27.93 39.51,29.54 39.51,36.65 39.03,37.12 v1(39.03,41.35) ; v1(29.29,46.73) 28.92,46.36 28.92,45.02 30.01,43.93 30.01,41.41 v1(29.99,41.39)
  BOTTOM w0.089: v1(29.99,41.39) 30.51,41.91 38.24,41.91 38.8,41.35 v1(39.03,41.35) ; KB1.10 v1(78.51,8.07)
KSO16: length 86.4
  TOP w0.089: v1(77.82,9.93) 78.45,9.3 AFTP6508.1 ; v1(33.98,39.27) 33.85,39.14 33.77,39.14 33.53,38.91 U2401.92 ; RN2412.5 29.88,51.04 30.55,51.04 30.89,51.39 31.54,51.39 v1(31.67,51.26)
  L3 w0.089: v1(51.58,36.68) 51.38,36.48 51.38,29.11 54.91,25.58 54.91,21.54 57.68,18.77 57.68,18.65 57.7,18.62 57.7,18.25 57.96,18 57.96,17.99 58.08,17.86 58.72,17.86 58.92,17.66 58.95,17.66 62.6,14 64.39,14 66.95,11.45 68.4,11.45 69.75,10.09 69.75,9.68 70.52,8.91 76.8,8.91 v1(77.82,9.93) ; v1(31.67,51.26) 31.67,50.52 31.34,50.19 31.34,50.17 31.19,50.02 31.19,48.8 31.34,48.64 31.34,48.62 31.52,48.44 31.52,48.01 31.54,47.98 31.54,46.15 31.52,46.13 31.52,41.07 31.54,41.05 31.54,40.85 33.24,39.14 33.85,39.14 v1(33.98,39.27)
  BOTTOM w0.089: KB1.11 77.71,9.75 77.82,9.86 v1(77.82,9.93) ; v1(33.98,39.27) 33.98,39 34.07,38.92 35.55,38.92 35.86,38.61 38.17,38.61 38.9,37.88 40.31,37.88 40.61,38.18 44.72,38.18 45.51,37.39 49.14,37.39 49.32,37.21 50.08,37.21 50.26,37.39 50.49,37.39 51.2,36.68 v1(51.58,36.68)
L_BKLT_CTRL: length 121.7
  TOP w0.114: v1(35.22,90.5) 35.22,90.17 35.48,89.92 36.56,89.92 36.98,89.5 40.47,89.5 v2(40.8,89.17) 42.23,87.73 42.23,86.34 v1(43.71,84.86)
  L4 w0.114: v1(126.29,77.85) 125.96,77.52 125.93,77.52 125.83,77.42 125.5,77.42 125.47,77.45 125.19,77.45 125.17,77.42 124.84,77.42 124.76,77.5 124.44,77.5 123.72,76.78 123.72,75.87 123.16,75.31 121.69,75.31 121.46,75.54 119.65,75.54 119.43,75.32 117.82,75.32 117.19,75.95 113.07,75.95 112.21,76.81 109.14,76.81 108.3,77.65 107.25,77.65 105.4,79.5 105.4,82.3 105.7,82.6 105.7,82.97 104.42,84.25 104.42,87.83 103.98,88.27 103.98,90.11 103.32,90.76 99.25,90.76 98.09,91.93 96.67,91.93 95.63,92.97 79.52,92.97 79.08,93.4 66.95,93.4 66.28,92.73 64.72,92.73 63.59,93.86 54.18,93.86 53.79,93.47 46.58,93.47 45.76,92.66 43.56,92.66 43.25,92.36 40.25,92.36 39.59,91.7 36.42,91.7 v1(35.22,90.5)
  BOTTOM w0.114: R5530.1 44.32,84.25 v1(43.71,84.86) ; CPU1.CH11 126.01,78.3 126.01,78.14 v1(126.29,77.85)
L_BKLT_EN: length 252.6
  TOP w0.102: R2436.1 24.02,37.04 23.16,37.9 R2401.2 22.42,39.07 R2405.1 21.63,38.56 21.63,37.29 22.4,36.53 22.4,36.24 22.75,35.88 v1(22.75,35.69)
  L4 w0.102: v1(127.62,77.88) 128.19,78.45 132.77,78.45 134.16,77.07 136.87,77.07 137.28,76.66 143.23,76.66 144.9,78.33 144.9,78.4 146.65,80.15 148.68,80.15 149.47,79.35 151.32,79.35 151.47,79.2 151.48,79.2 151.58,79.1 151.63,79.1 152.78,77.96 152.78,77.9 152.95,77.73 152.95,77.72 156.84,73.83 156.84,71.81 159.61,69.05 159.61,68 161.29,66.32 163.95,66.32 166.72,63.55 166.72,63.05 175.25,54.51 175.25,51.44 v1(177.97,48.72)
  BOTTOM w0.102: CPU1.CK11 127.32,78.18 v1(127.62,77.88) ; v1(177.97,48.72) 173.48,44.22 173.48,33.06 172.8,32.38 172.62,32.38 171.83,31.6 155.06,31.6 154.3,30.84 57.35,30.84 56.59,31.6 55.32,31.6 54.71,32.21 52.34,32.21 49.17,35.38 48.56,35.38 48.48,35.46 47.62,35.46 47.57,35.41 43.56,35.41 43.48,35.33 43.45,35.33 41.55,33.43 39.41,33.43 38.81,32.82 37.77,32.82 35.73,30.79 35.35,30.79 34.77,31.37 30.45,31.37 30.22,31.6 30.19,31.6 28.9,32.9 27.4,32.9 v2(26.07,34.23) 26,34.29 24.35,34.29 22.96,35.69 v1(22.75,35.69)
L_BKLT_EN_L: length 4.1
  TOP w0.102: R2405.2 22.27,38.2 22.63,37.85 v2(22.63,37.29) 22.24,37.29 v1(22.07,37.47)
  BOTTOM w0.102: D2401.2 22.14,38.06 22.14,37.54 v1(22.07,37.47)
LAN_CLK_CPU_N: length 160.2
  L6 w0.089: v1(110.85,87.59) 110.85,87.4 111,87.25 111.2,87.25 111.35,87.4 111.35,89.11 112.06,89.82 112.06,91.39 113.37,92.7 121.89,92.7 126.17,88.42 139.18,88.42 141.98,85.62 141.98,83.77 142.84,82.91 145.2,82.91 146.72,81.38 148.15,81.38 149.79,79.75 151.38,79.75 158.59,72.54 158.59,71.62 164.34,65.87 164.34,59.87 163.85,59.37 163.85,57.88 164.87,56.86 175.79,56.86 177.55,58.63 188.44,58.63 189.63,59.82 194.3,59.82 195.12,59.01 196.87,59.01 198.67,57.2 198.67,53.49 200.66,51.5 202.49,51.5 203.68,50.31 203.68,43.99 204.48,43.18 205.46,43.18 205.61,43.33 205.61,43.46 v1(205.37,43.7)
  BOTTOM w0.102: v1(110.85,87.59) 111.11,87.33 111.31,87.33 111.37,87.27 ; v1(205.37,43.7) 205.61,43.46 205.61,42.85 205.32,42.57 205.32,37.62 206.39,36.55 211.76,36.55 212.14,36.17 216.33,36.17 216.62,35.89 217.18,35.89 217.32,35.75 IOBD1.35 ; 111.37,87.27 v2(111.5,87.4) ; 111.37,87.27 111.55,87.09 111.55,83.7 111.27,83.43 CPU1.BD3
LAN_CLK_CPU_P: length 160.3
  L6 w0.089: v1(206.16,43.69) 206.02,43.69 205.8,43.48 205.8,43.25 205.54,42.99 204.4,42.99 203.49,43.91 203.49,50.23 202.41,51.31 200.58,51.31 198.48,53.41 198.48,57.12 196.79,58.82 195.04,58.82 194.23,59.63 189.71,59.63 188.52,58.44 177.63,58.44 175.86,56.67 164.79,56.67 163.66,57.8 163.66,59.45 164.15,59.95 164.15,65.79 158.4,71.54 158.4,72.46 151.3,79.56 149.71,79.56 148.07,81.19 146.65,81.19 145.12,82.72 142.76,82.72 141.79,83.69 141.79,85.54 139.1,88.23 126.09,88.23 121.81,92.51 113.45,92.51 112.25,91.31 112.25,89.74 111.54,89.03 111.54,87.32 111.28,87.06 111.07,87.06 v1(110.85,86.84)
  BOTTOM w0.102: IOBD1.34 217.32,36.25 217.18,36.11 216.71,36.11 216.43,36.4 212.23,36.4 211.85,36.78 206.49,36.78 205.55,37.72 205.55,42.48 205.84,42.76 205.84,43.52 206.01,43.69 v1(206.16,43.69) ; 111.32,86.13 111.32,87 111.21,87.1 111.11,87.1 v1(110.85,86.84) ; 111.32,86.13 111.32,83.8 111.04,83.52 111.04,83.51 110.71,83.17 CPU1.BC3 ; 111.32,86.13 v2(111.14,86.13)
LAN_CLKREQ_CPU_N: length 156.6
  TOP w0.102: RN1813.7 126.67,53.52 v2(126.79,53.65) 127.52,54.38 127.52,56.04 127.04,56.52 127.04,61.35 124.96,63.43 124.96,64.47 124,65.43 124,65.78 124.24,66.01 125.02,66.01 v1(125.39,65.64)
  L6 w0.102: v1(125.39,65.64) 125.04,65.28 125.04,63.48 127.71,60.81 127.71,58.94 129.54,57.1 133.34,57.1 133.42,57.18 133.9,57.18 135.58,55.5 137.31,55.5 138.47,54.33 138.47,53.16 140.33,51.31 140.33,42.84 141.45,41.73 141.45,41.68 141.78,41.35 141.82,41.35 142.33,40.84 148.42,40.84 149.45,41.86 155.94,41.86 157.65,40.16 167.42,40.16 167.96,40.69 169.26,40.69 169.72,41.15 176.27,41.15 180.61,36.81 184.07,36.81 184.8,37.54 191.16,37.54 193.26,35.44 193.26,34.77 195.95,32.09 197.64,32.09 198.11,32.57 199.41,32.57 199.71,32.26 200.12,32.26 200.45,32.59 202.97,32.59 203.3,32.26 206.06,32.26 206.98,31.35 207.89,31.35 208.4,31.85 208.45,31.85 208.83,32.24 210.08,32.24 210.26,32.06 211.6,32.06 211.88,32.34 215.39,32.34 215.67,32.06 v1(215.74,32.06)
  BOTTOM w0.102: IOBD1.8 219.17,49.25 219.91,48.52 219.91,33.37 218.43,31.89 216.39,31.89 216.39,31.89 215.91,31.89 v1(215.74,32.06) ; v1(125.39,65.64) 125.34,65.69 125.17,65.69 CPU1.CF30
LAN_PCIE_RX_N: length 140.8
  L4 w0.102: v1(117.34,81.21) 117.22,81.21 117.11,81.32 117.11,81.5 118.9,83.29 132.2,83.29 134.36,81.13 134.36,80.04 135.33,79.07 137.59,79.07 138.83,80.32 142.41,80.32 143.58,81.49 145.76,81.49 146.78,82.5 151.98,82.5 162.66,71.83 162.66,70.71 163.13,70.23 163.87,70.23 169.97,64.13 169.97,63.3 169.56,62.89 169.56,62.28 170.3,61.54 170.3,61.32 176.73,54.89 176.73,53.55 179.83,50.45 179.83,49.76 v1(179.65,49.58)
  BOTTOM w0.102: v1(179.65,49.58) 179.58,49.51 179.58,49.33 179.68,49.23 180,49.23 180.11,49.13 180.11,48.86 179.97,48.72 179.16,48.72 179.06,48.62 ; 179.06,48.62 v2(178.95,48.73) ; 179.06,48.62 178.53,48.09 178.53,47.33 184.28,41.58 187.85,41.58 192.83,36.6 192.83,32.16 194.94,30.05 201.51,30.05 204.98,33.52 217.1,33.52 217.37,33.25 IOBD1.40 ; CPU1.BP5 117.68,81.66 117.44,81.66 117.23,81.46 117.23,81.32 v1(117.34,81.21)
LAN_PCIE_RX_P: length 140.9
  L4 w0.102: v1(117.35,80.57) 116.91,81.01 116.91,81.59 118.82,83.49 132.29,83.49 134.56,81.21 134.56,80.12 135.41,79.28 137.5,79.28 138.75,80.52 142.33,80.52 143.5,81.69 145.68,81.69 146.7,82.71 152.06,82.71 162.86,71.91 162.86,70.79 163.21,70.44 163.95,70.44 170.17,64.21 170.17,63.22 169.77,62.81 169.77,62.36 170.5,61.62 170.5,61.4 176.93,54.98 176.93,53.63 180.03,50.53 180.03,49.89 v1(180.33,49.58)
  BOTTOM w0.102: v1(117.35,80.57) 117.43,80.57 CPU1.BP6 ; 182.76,43.42 178.76,47.42 178.76,48 179.25,48.49 180.06,48.49 180.33,48.76 v1(180.33,49.58) ; 182.76,43.42 184.37,41.81 187.95,41.81 193.06,36.7 193.06,32.25 195.03,30.28 201.41,30.28 204.88,33.75 IOBD1.39 ; 182.76,43.42 v2(182.87,43.54)
LAN_PCIE_TX_C_N: length 8.1
  BOTTOM w0.089: 117.57,87.05 117.59,87.04 117.59,87.01 118.32,86.27 118.32,84.04 118.03,83.75 CPU1.BR2
  BOTTOM w0.102: 117.57,87.05 116.91,87.71 115.72,87.71 115.11,88.32 114.39,88.32 114.29,88.42 114.29,88.54 114.42,88.67 C1613.2
LAN_PCIE_TX_C_P: length 7.7
  BOTTOM w0.089: 117.41,86.89 117.42,86.87 117.45,86.87 118.13,86.19 118.13,84.35 118.04,84.27 CPU1.BR1
  BOTTOM w0.102: v2(115.72,87.3) 115.72,87.48 ; 115.72,87.48 115.62,87.48 115.01,88.09 114.29,88.09 114.06,88.33 114.06,88.55 113.94,88.67 C1614.2 ; 115.72,87.48 116.82,87.48 117.41,86.89
LAN_PCIE_TX_N: length 149.2
  L6 w0.089: v1(114.54,90.6) 114.25,90.88 114.25,91.13 114.46,91.34 120.9,91.34 121.27,90.97 121.27,89.03 123.44,86.86 125.36,86.86 126.28,87.79 130.79,87.79 130.93,87.65 138.75,87.65 141.1,85.29 141.1,82.74 141.95,81.89 145.05,81.89 146.64,80.3 148.11,80.3 149.45,78.97 151.05,78.97 156.97,73.05 156.97,71.66 159.3,69.32 159.3,61.93 161.18,60.05 161.21,60.05 161.46,59.79 161.46,59.77 162.36,58.87 162.36,58.27 164.55,56.09 176.34,56.09 178.1,57.85 188.76,57.85 189.5,58.59 194.43,58.59 194.8,58.23 196.55,58.23 197.82,56.96 197.82,53.18 200.33,50.67 200.33,49.53 201.46,48.41 201.46,45.13 200.93,44.6 200.93,43.81 202.1,42.64 203.7,42.64 203.8,42.55 203.8,42.36 v1(203.5,42.06)
  BOTTOM w0.102: C1613.1 114.34,89.78 114.34,90.4 v1(114.54,90.6) ; IOBD1.37 217.32,34.75 217.18,34.89 211.9,34.89 211.02,35.77 206.08,35.77 204.34,37.51 204.34,40.17 203.78,40.73 203.78,41.78 v1(203.5,42.06)
LAN_PCIE_TX_P: length 149.8
  L6 w0.089: v1(113.76,90.58) 113.96,90.58 114.06,90.67 114.06,91.21 114.38,91.53 120.98,91.53 121.46,91.05 121.46,89.11 123.51,87.05 125.28,87.05 126.2,87.98 130.87,87.98 131.01,87.84 138.83,87.84 141.29,85.37 141.29,82.82 142.03,82.08 145.13,82.08 146.72,80.5 148.19,80.5 149.53,79.16 151.13,79.16 157.16,73.13 157.16,71.74 159.49,69.4 159.49,62.01 161.26,60.24 161.29,60.24 161.65,59.87 161.65,59.85 162.55,58.95 162.55,58.35 164.62,56.28 176.26,56.28 178.02,58.04 188.68,58.04 189.42,58.78 194.51,58.78 194.87,58.42 196.63,58.42 198.01,57.04 198.01,53.26 200.52,50.74 200.52,49.61 201.65,48.49 201.65,45.05 201.12,44.52 201.12,43.88 202.18,42.83 203.78,42.83 203.99,42.62 203.99,42.36 v1(204.25,42.1)
  BOTTOM w0.102: C1614.1 114.11,89.93 114.11,90.4 113.94,90.58 v1(113.76,90.58) ; v1(204.25,42.1) 204.01,41.86 204.01,40.82 204.57,40.26 204.57,37.6 206.18,35.99 211.11,35.99 211.99,35.11 217.18,35.11 217.32,35.25 IOBD1.36
LAN_WAKE#: length 118.3
  TOP w0.127: v1(121.75,56.39) 120.99,57.15 120.99,62.22 120.49,62.72 120.49,63.77 119.9,64.36 v1(119.89,64.36) 119.89,64.37 120.34,64.82 120.34,65.81 120.33,65.82 120.33,65.86 120.09,66.1 120.05,66.1 R1707.2 ; R2435.1 54.13,37.35 58.88,37.35 v2(58.92,37.38) 60.27,38.74 61.16,38.74 61.42,38.48 61.42,38.11 61.3,37.99 61.3,36.58 64.08,33.8 65.17,33.8 66.78,35.41 66.8,35.41 66.82,35.44 67.51,35.44 69.89,33.05 123.23,33.05 131.15,40.96 v1(131.15,41.4)
  L6 w0.127: v1(121.75,56.39) 121.8,56.34 122.24,56.34 125.72,52.86 125.72,52.58 126.26,52.05 126.26,50.8 126.69,50.37 126.69,46.43 126.71,46.41 126.71,46.38 131.15,41.95 v1(131.15,41.4)
  BOTTOM w0.127: v1(119.89,64.36) 119.72,64.36 CPU1.BU32 ; R2407.2 v1(121.75,56.39)
LANWAKE#: length 107.5
  TOP w0.127: v1(123.9,48.8) 123.9,48.52 124.3,48.11 124.3,47.88 124.73,47.45 124.73,46.05 124.58,45.9 124.58,42.47 124.5,42.4 124.5,42.29 124.45,42.24 124.45,39.37 121.96,36.88 108.66,36.88 v2(108.45,37.09) 108.2,37.34 101.75,37.34 100.76,36.35 77.16,36.35 71.29,42.22 66.97,42.22 62.59,46.6 v1(62.59,46.75) ; v1(44.9,49.76) 44.9,50.24 44.78,50.37 U2401.35
  BOTTOM w0.127: R2407.1 122.19,55.53 121.8,55.13 121.8,54.52 121.99,54.33 121.99,53.79 124.21,51.57 124.21,49.87 123.9,49.55 v1(123.9,48.8) ; v1(62.59,46.75) 62.19,47.15 61.64,47.15 59.68,49.1 59.68,49.16 58.8,50.04 58.72,50.04 58.39,50.37 57.19,50.37 56.66,50.91 50.57,50.91 49.72,50.07 45.13,50.07 44.9,49.84 v1(44.9,49.76)
LANWAKE#_IC: length 198.6
  TOP w0.102: v1(170.48,34.11) 170,34.11 v2(169.84,33.96)
  TOP w0.127: v1(52.25,36.58) 52.95,37.29 R2435.2 52.83,37.8 51,37.8 R2406.1
  L6 w0.127: v1(216.83,30.18) 216.64,29.99 206.38,29.99 205.76,30.61 202.25,30.61 201.63,29.99 194.78,29.99 193.4,31.36 191.46,31.36 190.52,32.3 185.46,32.3 184.06,33.7 179.84,33.7 178.94,34.6 177.59,34.6 176.37,35.82 172.49,35.82 171.47,34.8 171.17,34.8 v1(170.48,34.11)
  BOTTOM w0.127: v1(216.83,30.18) 216.83,30.94 217.55,31.65 218.53,31.65 220.15,33.27 220.15,48.66 219.06,49.75 IOBD1.7 ; v1(170.48,34.11) 169.85,34.11 168.79,33.06 154.45,33.06 153.7,32.3 70.56,32.3 67.33,35.52 58.62,35.52 58.01,36.13 52.69,36.13 v1(52.25,36.58)
LCD_BRIGHTNESS: length 4.7
  BOTTOM w0.114: v2(49.04,88.12) 49.04,88.21 RN5503.4 48.2,89.41 EC5504.1 47.75,90.9 48.06,91.21 LCD1.21
LCD_TST: length 60.3
  TOP w0.102: v1(45.52,48.1) 46.3,47.31 U2401.26 ; v1(42.82,84) 42.39,83.57 42.39,83.16 42.72,82.83 43,82.83 43.25,82.58 43.25,80.93 42.77,80.45 42.77,78.62 42.82,78.57 42.82,78.41 43.2,78.03 43.2,76.91 42.62,76.33 41.79,76.33 40.68,75.23 40.68,69.34 35,63.66 35,62.51 34.39,61.9 34.39,60.45 34.28,60.35 34.28,59.44 35.76,57.97 v2(39.34,57.97) 40.05,57.97 v1(40.43,57.58)
  L3 w0.102: v1(45.52,48.1) 45.72,48.1 46.37,48.75 46.37,49.74 44.55,51.56 44.55,52.63 44.29,52.89 44.11,52.89 43.4,53.6 43.4,55.2 43.05,55.55 43.05,57.13 42.14,58.04 41.73,58.04 41.37,57.69 40.53,57.69 v1(40.43,57.58)
  BOTTOM w0.102: v1(42.82,84) 42.82,84.94 43.53,85.65 45.36,85.65 45.66,85.95 46.37,85.95 D5503.2 47.55,87.13 RN5503.2
LCD_TST_C: length 6.5
  BOTTOM w0.102: LCD1.20 47.56,91.54 47.29,91.26 47.29,89.69 47.55,89.42 RN5503.3 47.55,88.89 47.19,88.52 47.19,87.63 46.2,86.64 v2(46.2,86.44)
LCD_VCC_TEST_EN: length 1.5
  TOP w0.102: U2401.113 39.58,35.04 39.29,34.75 R2419.1
LCD_VCC_TEST_EN_R: length 57.4
  TOP w0.102: v1(38.2,79.73) 38.2,80.27 v2(38.63,80.7) ; v1(40.18,32.78) 40.01,32.95 40.01,34.1 40.15,34.24 R2419.2
  L3 w0.102: v1(40.18,32.78) 39.95,33.02 39.95,36.76 39.69,37.01 39.69,38.71 40.13,39.14 40.13,45.95 40.8,46.62 40.8,47.74 38.67,49.87 38.67,53.31 39.34,53.98 39.34,56.9 38.68,57.56 37.47,57.56 35.48,59.55 35.48,61.32 35.05,61.75 35.05,71.38 37.87,74.2 37.87,75.57 37.38,76.05 37.38,78.92 v1(38.2,79.73)
  BOTTOM w0.102: v1(38.2,79.73) 38.2,79.28 37.8,78.88 D5502.2
LCDVDD_EN: length 3.7
  BOTTOM w0.127: v2(42.21,76.56) 41.74,77.03 U5501.1 41.6,77.75 R5506.1 39.63,77.75 D5502.3
LDO1_CAP: length 5.4
  TOP w0.203: v1(20.54,18.77) 20.54,18.65 20.64,18.54 20.64,18.47 21.31,17.8 U2701.21
  BOTTOM w0.254: v1(20.54,18.77) 20.01,19.31 v2(20.01,19.81) 20.01,20.32 R2702.1 18.05,20.68 C2703.1
LDO2_CAP: length 4
  TOP w0.203: U2701.32 22.57,13.21 22.3,12.93 21.23,12.93
  TOP w0.254: C2711.1 20.09,12.63 20.11,12.6 v2(20.16,12.6) 20.49,12.93 21.23,12.93
LDO3_CAP: length 5.5
  TOP w0.203: U2701.6 27.29,16.2
  TOP w0.254: C2722.1 30.68,14.48 v2(30.19,14.96) 29.97,15.19 28.29,15.19 27.83,15.65 27.83,15.66 27.29,16.2
LID_CL_SIO#: length 263.2
  TOP w0.102: U2401.66 32.94,49.31 33.03,49.4 33.13,49.4 v1(33.14,49.4) ; v1(215.11,25.68) 215.24,25.68 216.02,26.46 216.02,29.39 213.63,31.78 213.63,35.02 214.62,36.01 214.62,36.47 214.62,36.48 214.62,36.77 214.62,37.09 215.03,37.49 RN6401.1 ; v1(31.43,58.75) 31.26,58.75 31.07,58.94 U6402.1 ; v1(54.58,53.44) 54.86,53.16 54.86,52.53 55.24,52.15 55.24,50.04 54.58,49.38 D2402.K ; RN2405.3 51.89,34.88 51.81,34.8 51.81,33.15 52.88,32.08 v2(53.03,32.08) 54.12,32.08 54.25,32.21 54.71,32.21 55.01,31.91 55.01,31.55 54.76,31.3 52.62,31.3 52.09,30.76 52.09,30 52.01,29.92 v1(52.01,29.9)
  L3 w0.102: v1(52.01,29.9) 52.01,29.92 52.09,30 52.09,34.65 53.94,36.5 53.94,36.95 47.69,43.21 47.69,51.06 v1(47.99,51.36) ; v1(31.43,58.75) 31.43,58.62 32.38,57.66 33.16,57.66 33.41,57.41 33.41,55.9 32.43,54.91 32.43,53.17 33.07,52.53 33.09,52.53 33.55,52.07 33.55,49.81 v1(33.14,49.4)
  L6 w0.102: v1(215.11,25.68) 212.94,25.68 211.12,23.86 211.12,23.85 210.99,23.73 209.21,23.73 208.1,22.61 207.05,22.61 206.19,21.75 204.12,21.75 203.92,21.95 201.26,21.95 199.28,23.93 199.28,24.53 198.03,25.78 190.24,25.78 187.6,28.43 178.99,28.43 178.76,28.2 v1(178.81,28.2)
  BOTTOM w0.102: v1(54.58,53.44) 54.53,53.5 54.27,53.5 54.07,53.7 53.11,53.7 52.88,53.47 52.88,53.47 51.68,52.26 50.25,52.26 49.35,51.36 v1(47.99,51.36) 47.99,51.47 47.32,52.14 45.34,52.14 44.6,52.88 43.73,52.88 42.34,51.49 34.31,51.49 33.06,50.23 33.06,49.48 v1(33.14,49.4) ; v1(52.01,29.9) 52.01,29.85 52.11,29.75 155.1,29.75 155.45,30.1 176.22,30.1 178.12,28.2 v1(178.81,28.2)
LID_CL_SIO_TAB#: length 219.9
  TOP w0.102: R2440.2 214.57,26.7 214.95,26.32 v1(215.18,26.32) 215.77,26.9 215.77,28.81 v2(215.54,29.03) 215.54,29.53 213.43,31.63 213.43,35.11 214.42,36.1 214.42,37.74 214.22,37.94 214.22,39.69 216.3,41.77 216.3,42.7 216.48,42.88 R6601.2 ; v1(41.5,40.67) 41.98,40.67 42.59,41.28 42.59,41.91 41.98,42.52 41.98,48.77 42.29,49.08 42.29,50.04 42.38,50.14 U2401.41
  L4 w0.102: v1(46.65,33.69) 46.63,33.69 45.82,34.5 45.82,37.8 46.27,38.26 46.27,39.63 46.04,39.86 44.37,39.86 43.56,40.67 v1(41.5,40.67)
  L6 w0.102: v1(215.18,26.32) 213.29,26.32 210.9,23.93 209.11,23.93 208.02,22.84 206.98,22.84 206.17,22.02 204.13,22.02 204.01,22.15 201.37,22.15 199.56,23.95 199.56,24.54 198.11,25.99 190.34,25.99 187.7,28.63 179.7,28.63 179.47,28.86 v1(178.89,28.86)
  BOTTOM w0.102: v1(46.65,33.69) 46.68,33.69 47.21,33.15 48.85,33.15 49.63,32.36 50.62,32.36 51.83,31.15 53.35,31.15 54.52,29.97 155.04,29.97 155.36,30.3 177.27,30.3 178.71,28.86 v1(178.89,28.86)
LID_CLOSE#_C: length 13.5
  TOP w0.102: v1(218.87,42.88) 218.87,42.88 219.37,42.37 219.37,42.15 218.89,41.66 217.37,41.66 v2(216.49,40.78) 215.69,39.98 EC6401.1 215.32,38.87 RN6401.4
  BOTTOM w0.102: v1(218.87,42.88) 219.25,43.27 219.25,47.52 219.02,47.75 IOBD1.11
LINE1-L_C: length 2.3
  TOP w0.254: C2907.2 20.69,22.13 v2(19.4,22.13) 19.15,22.38 R2922.1
LINE1-L_R: length 2.1
  TOP w0.254: C2908.2 21.91,22.21 21.91,23.17 v2(21.86,23.22) 21.08,23.22 R2921.1
LINE1_L: length 3.7
  TOP w0.203: 22.14,19.64 22.22,19.64 22.97,18.88 U2701.18
  TOP w0.254: C2907.1 20.71,20.46 21.41,19.76 21.91,19.76 v2(21.97,19.71) 22.07,19.71 22.14,19.64
LINE1_R: length 4.1
  TOP w0.203: 22.37,19.97 23.37,18.97 U2701.17
  TOP w0.254: 22.37,19.97 21.98,20.36 C2908.1 23.04,20.82 23.06,20.81 v2(23.13,20.81)
LINE1_VREFO: length 4.1
  TOP w0.203: 20.09,17.43 20.91,16.6 U2701.24
  TOP w0.254: v1(18.84,17.78) v2(19.4,17.78) 19.73,17.78 20.09,17.43
  BOTTOM w0.254: v1(18.84,17.78) 18.65,17.59 D2901.3
LINE1_VREFO_D1: length 3.8
  TOP w0.254: v1(14.68,16.41) 15.46,16.41 R2912.1
  BOTTOM w0.254: D2901.1 16.07,15.42 v2(15.54,15.42) 15.28,15.67 15.28,16 14.88,16.41 v1(14.68,16.41)
LINE1_VREFO_D2: length 3.5
  TOP w0.254: v1(17.55,16.69) 17.27,16.97 R2913.1
  BOTTOM w0.254: v1(17.55,16.69) 17.55,16.79 D2901.2 16.17,18.16 v2(15.51,18.16)
LPS_SW: length 18.6
  TOP w0.254: R7402.2 R7403.1 35.4,81.99 35.15,82.25 33.15,82.25 v1(32.51,82.88) ; v1(24.96,87.61) 24.96,87.53 24.82,87.39 U7418.4
  L3 w0.254: v1(32.51,82.88) 32.33,83.07 32.33,83.39 28.62,87.1 v1(28.62,87.49)
  L6 w0.254: v1(24.96,87.61) 25.09,87.61 25.43,87.95 28.16,87.95 v1(28.62,87.49)
  BOTTOM w0.254: v1(24.96,87.61) 24.25,86.9 v2(24.25,86.67) 24.25,86.62 24.12,86.49 C7401.1 24.15,85.75 R7404.1
LPS_SW_A: length 2.7
  TOP w0.254: Q7406.3 32.03,82.47 32.18,82.32 32.46,82.32 v2(32.79,81.99) 33.27,81.51 R7402.1
LPS_SW_B: length 4.2
  TOP w0.254: Q8612.D 38.12,78.95 37.56,79.5 37.56,81.03 v2(37.21,81.38) 36.75,81.38 36.62,81.51 R7403.2
LPS_SW_C: length 4.6
  TOP w0.254: Q8612.G 36.33,79.9 35.6,80.62 v2(35.2,80.62) 34.91,80.91 34.45,80.91 33.85,80.32 R7406.2 R7405.1
LPS_SW_D: length 5.7
  TOP w0.254: Q7406.6 29.7,80.84 29.76,80.77 29.76,79.81 30.02,79.56 31.19,79.56 v2(31.59,79.96) 31.59,80.39 31.92,80.72 31.95,80.72 32.01,80.79 32.41,80.79 32.99,80.21 R7405.2
M2_SSD_PEDET: length 158.5
  TOP w0.102: v1(216.33,35.55) 216.34,35.55 219.81,32.08 219.81,29.74 219.38,29.31 218.54,29.31 217.37,28.14 217.37,26.47 216.66,25.76 216.66,24.59 216.2,24.13 216.2,22.94 214.78,21.52 214.78,20.14 214.29,19.66 214.29,18.9 216.22,16.97 216.22,10.68 212.28,6.73 209.72,6.73 209.29,6.3 R6339.2 209.29,4.35 AFTP6303.1 208.5,4.27 v1(207.87,4.9)
  L6 w0.102: v1(133.85,78.18) 136.42,75.62 139.77,75.62 140.28,76.13 144.37,76.13 145.92,74.58 145.92,73.31 146.96,72.27 149.45,72.27 149.83,71.88 151.48,71.88 155.33,68.03 155.33,58.92 163.71,50.55 164.03,50.55 164.97,49.61 174.15,49.61 181.43,42.33 183.66,42.33 184.44,41.55 197.15,41.55 198.34,40.36 198.34,38.31 199.09,37.56 205.94,37.56 207.23,36.27 211.63,36.27 213.88,34.02 215.7,34.02 216.33,34.65 v1(216.33,35.55)
  BOTTOM w0.076: CPU1.CP10 129.77,78.87 129.82,78.9 130.27,78.9 130.32,78.84
  BOTTOM w0.102: SSD1.69 208.41,5.45 v1(207.87,4.9) ; 130.32,78.84 132.83,78.84 133.49,78.18 v1(133.85,78.18)
M_A_A0: length 71.6
  L6 w0.142: v1(95.82,55.89) 95.37,55.44 95.37,52.1 94.29,51.01 94.29,44.26 89.3,39.28 89.06,39.28 88.84,39.5 88.61,39.5 88.44,39.33 88.44,39.09 88.66,38.87 88.66,38.64 88.49,38.47 88.26,38.47 88.04,38.69 87.8,38.69 87.64,38.52 87.64,38.29 87.86,38.07 87.86,37.83 87.69,37.67 87.45,37.67 87.23,37.89 87,37.89 86.83,37.72 86.83,37.48 87.05,37.26 87.05,37.03 86.88,36.86 86.65,36.86 86.43,37.08 86.19,37.08 86.03,36.92 86.03,36.68 86.25,36.46 86.25,36.22 86.08,36.06 85.84,36.06 85.63,36.28 85.39,36.28 85.22,36.11 85.22,35.87 85.44,35.66 85.44,35.42 85.28,35.25 85.04,35.25 84.82,35.47 84.58,35.47 84.42,35.31 84.42,35.07 84.64,34.85 84.64,34.62 83.96,33.94 72.87,33.94 64.36,25.43 64.36,22 64.6,21.75 65.05,21.75 65.22,21.92 65.22,22.16 65.38,22.33 65.62,22.33 65.79,22.16 65.79,21.92 65.95,21.75 67.33,21.75 v1(67.77,21.31)
  BOTTOM w0.076: v1(95.82,55.89) 96.76,56.83 96.76,58.71 96.77,58.96 97.12,59.35 98.05,60.28 98.05,61.18 98.05,61.24 98.07,61.27 CPU1.AC37
  BOTTOM w0.14: v1(67.77,21.31) 67.63,21.18 DM1.144
M_A_A1: length 72.4
  L6 w0.142: v1(95.86,55.19) 96.16,55.19 96.3,55.05 96.3,52.27 95.18,51.15 95.18,43 86.18,34 85.95,34 85.74,34.21 85.5,34.21 85.33,34.05 85.33,33.81 85.54,33.6 85.54,33.36 85.23,33.05 83.79,33.05 83.62,32.88 83.62,32.57 83.46,32.4 83.22,32.4 83.06,32.57 83.06,32.88 82.89,33.05 82.65,33.05 82.49,32.88 82.49,32.57 82.32,32.4 82.08,32.4 81.92,32.57 81.92,32.88 81.75,33.05 81.52,33.05 81.35,32.88 81.35,32.57 81.18,32.4 80.95,32.4 80.78,32.57 80.78,32.88 80.61,33.05 80.38,33.05 80.21,32.88 80.21,32.57 80.04,32.4 79.81,32.4 79.64,32.57 79.64,32.88 79.48,33.05 79.24,33.05 79.07,32.88 79.07,32.57 78.91,32.4 78.67,32.4 78.5,32.57 78.5,32.88 78.34,33.05 78.1,33.05 77.93,32.88 77.93,32.57 77.77,32.4 77.53,32.4 77.37,32.57 77.37,32.88 77.2,33.05 76.96,33.05 76.8,32.88 76.8,32.57 76.63,32.4 76.39,32.4 76.23,32.57 76.23,32.88 76.06,33.05 75.83,33.05 75.66,32.88 75.66,32.57 75.49,32.4 75.26,32.4 75.09,32.57 75.09,32.88 74.92,33.05 74.69,33.05 74.52,32.88 74.52,32.57 74.35,32.4 74.12,32.4 73.95,32.57 73.95,32.88 73.79,33.05 73.32,33.05 66.03,25.76 66.03,24.59 65.88,24.44 v1(65.27,24.44)
  BOTTOM w0.076: CPU1.AC36 98.45,61.74 98.45,61.51 98.32,61.33 98.22,61.19 98.22,61.18 98.22,60.21 97.24,59.23 96.96,58.93 96.96,56.3 v1(95.86,55.19)
  BOTTOM w0.14: DM1.133 64.89,26.88 64.63,26.62 64.63,24.98 65.17,24.44 v1(65.27,24.44)
M_A_A2: length 71.5
  L6 w0.142: v1(63.8,22.57) 63.8,25.51 72.68,34.39 83.78,34.39 83.97,34.58 83.97,35.49 88.92,40.44 89.15,40.44 89.37,40.22 89.61,40.22 89.77,40.39 89.77,40.62 89.56,40.84 89.56,41.08 89.72,41.24 89.96,41.24 90.18,41.02 90.41,41.02 90.58,41.19 90.58,41.43 90.36,41.64 90.36,41.88 90.53,42.05 90.76,42.05 90.98,41.83 91.22,41.83 91.38,41.99 91.38,42.23 91.16,42.45 91.16,42.68 91.33,42.85 91.57,42.85 91.79,42.63 92.02,42.63 92.19,42.8 92.19,43.03 91.97,43.25 91.97,43.49 92.14,43.66 92.37,43.66 92.59,43.44 92.83,43.44 92.99,43.6 92.99,43.84 92.77,44.06 92.77,44.29 93.84,45.36 93.84,51 95.12,52.28 95.12,57.17 95.26,57.31 v1(96.04,57.31)
  BOTTOM w0.076: CPU1.AC34 97.94,63.04 97.94,62.22 97.95,62.12 97.96,62.1 97.96,61.9 97.95,61.8 97.9,61.41 97.88,61.19 97.88,61.15 97.88,60.34 97,59.46 96.6,59.03 96.6,58.83 96.6,58.72 96.58,57.86 v1(96.04,57.31)
  BOTTOM w0.14: DM1.132 64.63,21.46 64.79,21.62 65.14,21.62 65.29,21.77 65.29,22.07 65.14,22.22 64.79,22.22 64.63,22.38 64.63,22.66 64.48,22.81 64.04,22.81 v1(63.8,22.57)
M_A_A3: length 73.2
  L6 w0.142: v1(65.25,23.78) 64.91,23.78 64.77,23.92 64.77,25.21 73.06,33.5 84.15,33.5 86.34,35.69 86.58,35.69 86.79,35.48 87.02,35.48 87.19,35.64 87.19,35.88 86.98,36.09 86.98,36.33 87.15,36.49 87.38,36.49 87.59,36.28 87.83,36.28 88.15,36.6 88.15,36.83 87.94,37.04 87.94,37.28 88.1,37.45 88.34,37.45 88.55,37.24 88.78,37.24 88.95,37.4 88.95,37.64 88.74,37.85 88.74,38.08 88.91,38.25 89.14,38.25 89.35,38.04 89.59,38.04 89.75,38.21 89.75,38.44 89.54,38.65 89.54,38.89 89.71,39.06 89.95,39.06 90.16,38.85 90.39,38.85 90.56,39.01 90.56,39.25 90.35,39.46 90.35,39.69 90.52,39.86 90.75,39.86 90.96,39.65 91.2,39.65 91.36,39.82 91.36,40.05 91.15,40.26 91.15,40.5 91.32,40.67 91.56,40.67 91.77,40.46 92,40.46 92.17,40.62 92.17,40.86 91.96,41.07 91.96,41.3 92.13,41.47 92.36,41.47 92.57,41.26 92.81,41.26 92.97,41.43 92.97,41.66 92.76,41.87 92.76,42.11 92.93,42.27 93.17,42.27 93.38,42.06 93.61,42.06 93.78,42.23 93.78,42.47 93.57,42.68 93.57,42.91 93.73,43.08 93.97,43.08 94.18,42.87 94.42,42.87 94.73,43.19 94.73,51.04 95.87,52.18 v1(95.87,53.86)
  BOTTOM w0.076: CPU1.AC35 98.43,62.42 98.56,61.94 98.59,61.81 98.61,61.77 98.61,61.45 98.45,61.24 98.38,61.13 98.38,60.14 97.36,59.12 97.14,58.88 97.14,55.92 96.5,55.27 96.5,54.48 v1(95.87,53.86)
  BOTTOM w0.14: DM1.131 64.38,26.89 64.36,26.86 64.36,24.66 v1(65.25,23.78)
M_A_A4: length 72.6
  L6 w0.142: v1(94.15,54.14) 94.54,53.74 94.54,52.35 92.94,50.76 92.94,46.8 92.05,45.91 92.05,45.67 92.34,45.38 92.34,45.15 92.17,44.98 91.93,44.98 91.65,45.27 91.41,45.27 91.24,45.1 91.24,44.87 91.53,44.58 91.53,44.34 91.36,44.18 91.13,44.18 90.84,44.46 90.61,44.46 90.44,44.3 90.44,44.06 90.73,43.78 90.73,43.54 90.56,43.37 90.32,43.37 90.04,43.66 89.8,43.66 89.64,43.49 89.64,43.26 89.92,42.97 89.92,42.73 89.75,42.57 89.52,42.57 89.23,42.85 89,42.85 88.83,42.69 88.83,42.45 89.12,42.17 89.12,41.93 88.95,41.76 88.71,41.76 88.43,42.05 88.19,42.05 88.03,41.88 88.03,41.65 88.31,41.36 88.31,41.13 88.15,40.96 87.91,40.96 87.62,41.24 87.39,41.24 87.22,41.08 87.22,40.84 87.51,40.56 87.51,40.32 87.34,40.15 87.1,40.15 86.82,40.44 86.58,40.44 81.43,35.28 72.31,35.28 63.19,26.16 63.19,23.88 62.41,23.1 v1(61.96,23.1)
  BOTTOM w0.076: v1(94.15,54.14) 95,54.99 95,56.42 95.38,56.8 95.38,58.83 96.64,60.09 96.68,60.09 97.18,60.59 97.18,61.52 97.18,61.62 97.12,61.81 97.12,62.08 97.15,62.19 97.15,62.41 97.14,62.44 97.12,62.46 97.11,62.48 97.11,62.71 CPU1.AA35
  BOTTOM w0.14: DM1.128 63.63,21.35 63.06,21.92 63.06,22.66 62.58,23.14 62.05,23.14 62,23.1 v1(61.96,23.1)
M_A_A5: length 73.1
  L6 w0.142: v1(61.94,22.46) 62.41,22.46 62.55,22.32 62.55,21.38 62.7,21.24 63.09,21.24 63.26,21.41 63.26,22.71 63.49,22.94 63.49,25.83 72.5,34.84 82.66,34.84 83.31,35.49 83.31,35.73 83.02,36.01 83.02,36.25 83.19,36.41 83.43,36.41 83.71,36.13 83.95,36.13 84.11,36.3 84.11,36.53 83.83,36.82 83.83,37.05 84,37.22 84.23,37.22 84.52,36.93 84.75,36.93 84.92,37.1 84.92,37.34 84.63,37.62 84.63,37.86 84.8,38.02 85.04,38.02 85.32,37.74 85.56,37.74 85.72,37.9 85.72,38.14 85.44,38.43 85.44,38.66 85.6,38.83 85.84,38.83 86.13,38.54 86.36,38.54 86.53,38.71 86.53,38.95 86.24,39.23 86.24,39.47 86.41,39.63 86.65,39.63 86.93,39.35 87.17,39.35 93.39,45.57 93.39,50.88 94.86,52.35 94.86,57.51 95.3,57.95 v1(96,57.95)
  BOTTOM w0.076: CPU1.AB35 97.75,62.15 97.8,62.06 97.8,61.9 97.79,61.82 97.71,61.3 97.71,60.41 96.88,59.58 96.44,59.09 96.43,58.97 96.39,58.33 v1(96,57.95)
  BOTTOM w0.14: DM1.126 63.14,21.44 62.56,22.02 62.56,22.04 62.29,22.3 62.27,22.3 62.12,22.46 61.95,22.46 v1(61.94,22.46)
M_A_A6: length 72.2
  L6 w0.142: v1(62.05,24.41) 61.74,24.41 61.6,24.55 61.6,25.9 72.1,36.4 78.31,36.4 78.87,36.96 80.49,36.96 85.17,41.64 85.4,41.64 85.78,41.27 86.01,41.27 86.18,41.44 86.18,41.67 85.81,42.05 85.81,42.28 85.97,42.45 86.21,42.45 86.58,42.07 86.82,42.07 86.99,42.24 86.99,42.48 86.61,42.85 86.61,43.09 86.78,43.25 87.01,43.25 87.39,42.88 87.62,42.88 87.79,43.05 87.79,43.28 87.42,43.66 87.42,43.89 87.58,44.06 87.82,44.06 88.19,43.68 88.43,43.68 88.6,43.85 88.6,44.09 88.22,44.46 88.22,44.7 88.39,44.86 88.62,44.86 89,44.49 89.23,44.49 89.4,44.65 89.4,44.89 89.03,45.26 89.03,45.5 89.19,45.67 89.43,45.67 89.8,45.29 90.04,45.29 90.2,45.46 90.2,45.69 89.83,46.07 89.83,46.3 90,46.47 90.23,46.47 90.61,46.1 90.84,46.1 91.01,46.26 91.01,46.5 90.64,46.87 90.64,47.11 90.8,47.28 91.04,47.28 91.41,46.9 91.65,46.9 91.81,47.07 91.81,47.3 91.44,47.68 91.44,47.91 92.05,48.52 92.05,50.81 93.62,52.38 93.62,54.63 93.76,54.77 v1(94.15,54.77)
  BOTTOM w0.076: v1(94.15,54.77) 94.74,55.37 94.74,56.73 95.22,57.2 95.22,58.9 96.57,60.26 96.61,60.26 97.02,60.66 97.02,61.31 97.02,61.34 96.89,61.46 CPU1.AA37
  BOTTOM w0.14: DM1.127 63.39,27.95 63.39,27.09 63.54,26.93 63.54,26.04 63.53,26.03 63.53,25.72 62.22,24.41 v1(62.05,24.41)
