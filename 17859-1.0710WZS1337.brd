# Allegro board 17859-1.0710WZS1337.brd (continued)
## Nets (continued)
DP2_AUX_CPU_P: C7301.2 CPU1.AD3
DP2_DDI_TX_N0: C7313.1 CPU1.AC4
DP2_DDI_TX_N1: C7307.1 CPU1.AC1
DP2_DDI_TX_N2: C7308.1 CPU1.AE4
DP2_DDI_TX_N3: C7310.1 CPU1.AE1
DP2_DDI_TX_P0: C7312.1 CPU1.AC3
DP2_DDI_TX_P1: C7314.1 CPU1.AC2
DP2_DDI_TX_P2: C7309.1 CPU1.AE3
DP2_DDI_TX_P3: C7311.1 CPU1.AE2
DP2_DDI_TX_RE_C_N0: C7313.2 U7301.10
DP2_DDI_TX_RE_C_N1: C7307.2 U7301.13
DP2_DDI_TX_RE_C_N2: C7308.2 U7301.16
DP2_DDI_TX_RE_C_N3: C7310.2 U7301.19
DP2_DDI_TX_RE_C_P0: C7312.2 U7301.9
DP2_DDI_TX_RE_C_P1: C7314.2 U7301.12
DP2_DDI_TX_RE_C_P2: C7309.2 U7301.15
DP2_DDI_TX_RE_C_P3: C7311.2 U7301.18
DPEQ0_A1: R7341.2 R7342.1 U7301.14
DPEQ1: R7325.2 R7340.1 U7301.2
EC_AGND: C2407.1 C2408.1 C2416.2 C2421.2 C2422.2 C2431.2 C2436.2 R2441.2 R2444.2 R2445.2 U2401.112
EDP_AUX_CON_N: C5533.2 LCD1.11 R5529.1
EDP_AUX_CON_P: C5531.2 LCD1.10 R5528.1
EDP_AUX_CPU_N: C5533.1 CPU1.AH4
EDP_AUX_CPU_P: C5531.1 CPU1.AH3
EDP_BKLT_CTRL: D5503.1 R5524.1 R5530.2
EDP_HPD_CONN: LCD1.19 RN5504.3(B)
EDP_HPD_CPU: CPU1.CM7 RN5502.3(A) RN5504.2(A)
EDP_RCOMP_CPU: CPU1.AM6 R401.2
EDP_TX_CON_N0: C5508.2 LCD1.16
EDP_TX_CON_N1: C5534.2 LCD1.13
EDP_TX_CON_P0: C5532.2 LCD1.17
EDP_TX_CON_P1: C5537.2 LCD1.14
EDP_TX_CPU_N0: C5508.1 CPU1.AG4
EDP_TX_CPU_N1: C5534.1 CPU1.AG2
EDP_TX_CPU_P0: C5532.1 CPU1.AG3
EDP_TX_CPU_P1: C5537.1 CPU1.AG1
EDP_VDD_EN: CPU1.CG11 D5502.1
EMMC_RCOMP: CPU1.CK15 R2108.1
EN1: R4019.1 U4003.3
EN2: R4048.1 U4001.5
EN_VCCSFR_OC: C4047.1 R4039.2 U4004.4
EQ0: R7320.2 R7321.1 U7301.38
EQ1: R7318.2 R7319.1 U7301.35
ESPI_ALERT#: CPU1.BV28 R1821.2
ESPI_CLK: DBG1.2 EC1801.1 R1805.2 U2401.57
ESPI_CS#: CPU1.CA28 DBG1.5 U2401.58
ESPI_IO0: DBG1.9 RN1806.8(B) U2401.59
ESPI_IO1: DBG1.8 RN1806.6(B) U2401.60
ESPI_IO2: DBG1.7 RN1806.7(B) U2401.61
ESPI_IO3: DBG1.6 RN1806.5(B) U2401.62
ESPI_RESET#: CPU1.CA27 DBG1.4 U2401.53
EXT_PWR_GATE#: CPU1.CC37 R1731.2
FALL_INT2: Q7001.2 Q7001.3 R7018.2
FAN1_PWM: AFTP2602.1 FAN1.4 RN2603.1(A) U2401.47
FAN1_TACH: AFTP2601.1 FAN1.3 RN2603.2(A) U2401.40
FB_CAL_PD_VDDQ: GPU1.D22 R7805.1
FB_CAL_PU_GND: GPU1.C24 R7807.1
FB_CAL_TERM_GND: GPU1.B25 R7806.1
FB_CLAM: GPU1.F3 R7818.1
FB_VREF: GPU1.D23 TP7801.1
FBA0_MF: R8112.2 VRAM1.J1
FBA0_SEN: R8109.2 VRAM1.J10
FBA0_VREFC: C8136.1 R8101.2 R8102.2 R8103.1 VRAM1.J14
FBA0_ZQ1: R8107.1 VRAM1.J13
FBA1_MF: R8111.1 VRAM4.J1
FBA1_SEN: R8110.2 VRAM4.J10
FBA1_VREFC: C8140.1 R8104.2 R8105.2 R8106.1 VRAM4.J14
FBA1_ZQ3: R8108.1 VRAM4.J13
FBA_CLK0_MIDPT: C8142.1 R8113.2 R8114.2
FBA_CLK0N: GPU1.D25 R8113.1 VRAM1.J11
FBA_CLK0P: GPU1.D24 R8114.1 VRAM1.J12
FBA_CLK1_MIDPT: C8141.1 R8115.2 R8116.2
FBA_CLK1N: GPU1.M22 R8115.1 VRAM4.J11
FBA_CLK1P: GPU1.N22 R8116.1 VRAM4.J12
FBA_CMD0: GPU1.C27 VRAM1.G12
FBA_CMD1: GPU1.C26 VRAM1.H10
FBA_CMD2: GPU1.E24 VRAM1.H11
FBA_CMD3: GPU1.F24 VRAM1.K11
FBA_CMD4: GPU1.D27 VRAM1.K10
FBA_CMD5: GPU1.D26 VRAM1.L12
FBA_CMD6: GPU1.F25 VRAM1.K4
FBA_CMD7: GPU1.F26 VRAM1.K5
FBA_CMD8: GPU1.F23 VRAM1.J4
FBA_CMD9: GPU1.G22 VRAM1.J5
FBA_CMD10: GPU1.G23 VRAM1.H4
FBA_CMD11: GPU1.G24 VRAM1.H5
FBA_CMD12: GPU1.F27 VRAM1.G3
FBA_CMD13: GPU1.G25 R7820.2 VRAM1.J2
FBA_CMD14: GPU1.G27 R7816.1 VRAM1.J3
FBA_CMD15: GPU1.G26 VRAM1.L3
FBA_CMD16: GPU1.M24 VRAM4.L12
FBA_CMD17: GPU1.M23 VRAM4.K10
FBA_CMD18: GPU1.K24 VRAM4.K11
FBA_CMD19: GPU1.K23 VRAM4.H11
FBA_CMD20: GPU1.M27 VRAM4.H10
FBA_CMD21: GPU1.M26 VRAM4.G12
FBA_CMD22: GPU1.M25 VRAM4.H4
FBA_CMD23: GPU1.K26 VRAM4.H5
FBA_CMD24: GPU1.K22 VRAM4.J4
FBA_CMD25: GPU1.J23 VRAM4.J5
FBA_CMD26: GPU1.J25 VRAM4.K4
FBA_CMD27: GPU1.J24 VRAM4.K5
FBA_CMD28: GPU1.K27 VRAM4.L3
FBA_CMD29: GPU1.K25 R7821.2 VRAM4.J2
FBA_CMD30: GPU1.J27 R7824.1 VRAM4.J3
FBA_CMD31: GPU1.J26 VRAM4.G3
FBA_D0: GPU1.E18 VRAM1.A4
FBA_D1: GPU1.F18 VRAM1.A2
FBA_D2: GPU1.E16 VRAM1.B4
FBA_D3: GPU1.F17 VRAM1.B2
FBA_D4: GPU1.D20 VRAM1.E4
FBA_D5: GPU1.D21 VRAM1.E2
FBA_D6: GPU1.F20 VRAM1.F4
FBA_D7: GPU1.E21 VRAM1.F2
FBA_D8: GPU1.E15 VRAM1.A11
FBA_D9: GPU1.D15 VRAM1.A13
FBA_D10: GPU1.F15 VRAM1.B11
FBA_D11: GPU1.F13 VRAM1.B13
FBA_D12: GPU1.C13 VRAM1.E11
FBA_D13: GPU1.B13 VRAM1.E13
FBA_D14: GPU1.E13 VRAM1.F11
FBA_D15: GPU1.D13 VRAM1.F13
FBA_D16: GPU1.B15 VRAM1.U11
FBA_D17: GPU1.C16 VRAM1.U13
FBA_D18: GPU1.A13 VRAM1.T11
FBA_D19: GPU1.A15 VRAM1.T13
FBA_D20: GPU1.B18 VRAM1.N11
FBA_D21: GPU1.A18 VRAM1.N13
FBA_D22: GPU1.A19 VRAM1.M11
FBA_D23: GPU1.C19 VRAM1.M13
FBA_D24: GPU1.B24 VRAM1.U4
FBA_D25: GPU1.C23 VRAM1.U2
FBA_D26: GPU1.A25 VRAM1.T4
FBA_D27: GPU1.A24 VRAM1.T2
FBA_D28: GPU1.A21 VRAM1.N4
FBA_D29: GPU1.B21 VRAM1.N2
FBA_D30: GPU1.C20 VRAM1.M4
FBA_D31: GPU1.C21 VRAM1.M2
FBA_D32: GPU1.R22 VRAM4.U4
FBA_D33: GPU1.R24 VRAM4.U2
FBA_D34: GPU1.T22 VRAM4.T4
FBA_D35: GPU1.R23 VRAM4.T2
FBA_D36: GPU1.N25 VRAM4.N4
FBA_D37: GPU1.N26 VRAM4.N2
FBA_D38: GPU1.N23 VRAM4.M4
FBA_D39: GPU1.N24 VRAM4.M2
FBA_D40: GPU1.V23 VRAM4.U11
FBA_D41: GPU1.V22 VRAM4.U13
FBA_D42: GPU1.T23 VRAM4.T11
FBA_D43: GPU1.U22 VRAM4.T13
FBA_D44: GPU1.Y24 VRAM4.N11
FBA_D45: GPU1.AA24 VRAM4.N13
FBA_D46: GPU1.Y22 VRAM4.M11
FBA_D47: GPU1.AA23 VRAM4.M13
FBA_D48: GPU1.AD27 VRAM4.A11
FBA_D49: GPU1.AB25 VRAM4.A13
FBA_D50: GPU1.AD26 VRAM4.B11
FBA_D51: GPU1.AC25 VRAM4.B13
FBA_D52: GPU1.AA27 VRAM4.E11
FBA_D53: GPU1.AA26 VRAM4.E13
FBA_D54: GPU1.W26 VRAM4.F11
FBA_D55: GPU1.Y25 VRAM4.F13
FBA_D56: GPU1.R26 VRAM4.A4
FBA_D57: GPU1.T25 VRAM4.A2
FBA_D58: GPU1.N27 VRAM4.B4
FBA_D59: GPU1.R27 VRAM4.B2
FBA_D60: GPU1.V26 VRAM4.E4
FBA_D61: GPU1.V27 VRAM4.E2
FBA_D62: GPU1.W27 VRAM4.F4
FBA_D63: GPU1.W25 VRAM4.F2
FBA_DEBUG0: GPU1.F22 R7801.1
FBA_DEBUG1: GPU1.J22 R7803.1
FBA_DQM0: GPU1.D19 VRAM1.D2
FBA_DQM1: GPU1.D14 VRAM1.D13
FBA_DQM2: GPU1.C17 VRAM1.P13
FBA_DQM3: GPU1.C22 VRAM1.P2
FBA_DQM4: GPU1.P24 VRAM4.P2
FBA_DQM5: GPU1.W24 VRAM4.P13
FBA_DQM6: GPU1.AA25 VRAM4.D13
FBA_DQM7: GPU1.U25 VRAM4.D2
FBA_EDC0: GPU1.E19 VRAM1.C2
FBA_EDC1: GPU1.C15 VRAM1.C13
FBA_EDC2: GPU1.B16 VRAM1.R13
FBA_EDC3: GPU1.B22 VRAM1.R2
FBA_EDC4: GPU1.R25 VRAM4.R2
FBA_EDC5: GPU1.W23 VRAM4.R13
FBA_EDC6: GPU1.AB26 VRAM4.C13
FBA_EDC7: GPU1.T26 VRAM4.C2
FBA_PLL_AVDD: C7805.1 C7806.1 C7808.1 C7809.1 C7818.1 GPU1.F16 GPU1.H22 GPU1.P22 L7801.1
FBA_VREF_FET_L: Q8101.D R8102.1 R8105.1
FBA_WCK01: GPU1.D18 VRAM1.D4
FBA_WCK01#: GPU1.C18 VRAM1.D5
FBA_WCK23: GPU1.D17 VRAM1.P4
FBA_WCK23#: GPU1.D16 VRAM1.P5
FBA_WCK45: GPU1.T24 VRAM4.P4
FBA_WCK45#: GPU1.U24 VRAM4.P5
FBA_WCK67: GPU1.V24 VRAM4.D4
FBA_WCK67#: GPU1.V25 VRAM4.D5
FFS_INT1: CPU1.CG22 R7011.1
FFS_INT2: CPU1.CH12 D7001.3 R2044.2 R7008.2
FFS_INT2_Q: Q7001.6 R6016.1
FFS_INT2_Q_R: HDD1.12 R6016.2
FP_USB20_N: CPU1.CG5 IOBD1.15
FP_USB20_P: CPU1.CG6 IOBD1.14
FPR_SCAN#: IOBD1.1 R2429.1 U2401.42
GC6_FB_EN: D8601.1 Q7907.3 R2004.1 R7940.2 R7953.2
GC6_FB_EN_GPU: Q7907.2 R7927.1 R7940.1 R7958.2 R7959.2
GC6_FB_EN_GPU_L: Q7907.5 Q7907.6 R7952.1
GC6_FB_EN_MCP: CPU1.CE28 R2004.2
GC6_PWR_EN: R8648.2 U8605.2
GC6_THM_DIS#: CPU1.CL35 R2480.2
GC6_THM_DIS#_EC: R2426.2 R2477.1 R2480.1 U2401.23
GFX_CLK_CPU_N: CPU1.AW2 GPU1.AD8
GFX_CLK_CPU_P: CPU1.AY3 GPU1.AE8
GFX_PCIE_RX_C_N0: C7602.2 GPU1.AB9
GFX_PCIE_RX_C_N1: C7604.2 GPU1.AC10
GFX_PCIE_RX_C_N2: C7606.2 GPU1.AC11
GFX_PCIE_RX_C_N3: C7608.2 GPU1.AB12
GFX_PCIE_RX_C_P0: C7601.2 GPU1.AC9
GFX_PCIE_RX_C_P1: C7603.2 GPU1.AB10
GFX_PCIE_RX_C_P2: C7605.2 GPU1.AD11
GFX_PCIE_RX_C_P3: C7607.2 GPU1.AC12
GFX_PCIE_RX_N0: C7602.1 CPU1.BW9
GFX_PCIE_RX_N1: C7604.1 CPU1.BU6
GFX_PCIE_RX_N2: C7606.1 CPU1.BT7
GFX_PCIE_RX_N3: C7608.1 CPU1.BU9
GFX_PCIE_RX_P0: C7601.1 CPU1.BW8
GFX_PCIE_RX_P1: C7603.1 CPU1.BU5
GFX_PCIE_RX_P2: C7605.1 CPU1.BT6
GFX_PCIE_RX_P3: C7607.1 CPU1.BU8
GFX_PCIE_TX_C_N0: C1606.2 CPU1.BW4
GFX_PCIE_TX_C_N1: C1608.2 CPU1.BU4
GFX_PCIE_TX_C_N2: C1610.2 CPU1.BU2
GFX_PCIE_TX_C_N3: C1612.2 CPU1.BT4
GFX_PCIE_TX_C_P0: C1605.2 CPU1.BW3
GFX_PCIE_TX_C_P1: C1607.2 CPU1.BU3
GFX_PCIE_TX_C_P2: C1609.2 CPU1.BU1
GFX_PCIE_TX_C_P3: C1611.2 CPU1.BT3
GFX_PCIE_TX_N0: C1606.1 GPU1.AG7
GFX_PCIE_TX_N1: C1608.1 GPU1.AE7
GFX_PCIE_TX_N2: C1610.1 GPU1.AF9
GFX_PCIE_TX_N3: C1612.1 GPU1.AG10
GFX_PCIE_TX_P0: C1605.1 GPU1.AG6
GFX_PCIE_TX_P1: C1607.1 GPU1.AF7
GFX_PCIE_TX_P2: C1609.1 GPU1.AE9
GFX_PCIE_TX_P3: C1611.1 GPU1.AG9
GPCPLL_AVDD: C8037.1 C8047.1 C8048.1 GPU1.F11 L8001.2
GPD7: CPU1.BV35 R1524.1 R1525.2
GPD11/LANPHYPC: CPU1.BU34 R1721.2
GPIO0_CORE_VID: GPU1.C6 R7959.1 R7960.1
GPIO1_GC6_FB_EN_GPU: GPU1.B2 R7958.1
GPIO2_EVEN_GPU#: GPU1.D6 R7964.1
GPIO4_GC6_PWR_EN_GPU: GPU1.F9 R7962.1
GPIO5_FRAME_LOCK#: GPU1.A3 R7963.1
GPIO5_GC6_NVVDD_OR: Q8509.5 R8545.1
GPIO5_GC6_PWR_1V: R8651.1 U8605.4
GPIO5_GC6_PWR_1V_A: R8651.2 U8604.1
GPIO5_GC6_PWR_B: Q8601.D R8635.1 R8648.1
GPIO5_GC6_PWR_EN: Q8601.S Q8606.5 R7933.2 R7962.2 R7963.2 R8545.2
GPIO6_VGA_CORE_PSI: GPU1.A4 R7965.1 R7966.1
GPIO8_OVERT: C7909.1 GPU1.A6 Q7904.S RN7910.2(A)
GPIO8_OVERT#_EC: D8602.K Q7904.D R7934.2
GPIO9_ALERT: GPU1.F8 RN7910.1(A)
GPIO10_FBVREF: GPU1.C5 Q8101.G R7910.1
GPIO11_LCD_VDD: GPU1.E7 R7961.1
GPIO12_PWR_LEVEL: D7902.A GPU1.D7 R7905.1
GPIO13_LCD_BLEN: GPU1.B4 R7967.1
GPP_B22_GSPI1_MOSI: CPU1.CA30 R1553.1
GPP_E3/CPU_GP0: CPU1.CE9 TP304.1
GPP_E23: CPU1.CN4 TP402.1
GPP_H17_STRAP: CPU1.CP26 R1527.1
GPP_H21: CPU1.CF25 R1522.2 R1523.1
GPP_H23: CPU1.CM26 R1513.2 R1514.1
GPPC_H18_BOOTMPC: CPU1.CN27 R4020.1
GPU_CLKREQ#: GPU1.AC6 Q7601.S R7603.1 R7618.2
GPU_EVENT#: Q7906.D R2003.1 R7944.1 R7948.1
GPU_EVENT_GPU#: Q7906.S R7944.2 R7949.1 R7964.2 R7965.2
GPU_EVENT_MCP#: CPU1.CC27 R2003.2
GPU_I2C: R7977.2 R7978.1 RN7904.1(A) RN7904.2(A) RN7905.1(A) RN7905.2(A)
GPU_I2CA_SCL: GPU1.B7 RN7701.1(A)
GPU_I2CA_SDA: GPU1.A7 RN7701.2(A)
GPU_PEX_RST#: C7903.1 GPU1.AC7 Q7904.G R7613.2 R7614.2 R7615.1
GPU_PEX_RST_D#: D7601.3 R7615.2
GPU_PEX_RST_HOLD: D7601.1 R7931.2 R7973.2
GPU_PEX_RST_HOLD_GPU#: GPU1.C4 R7973.1
GPU_PWR_LEVEL: R2420.2 R2422.2 U2401.10
GPU_ROM: R7912.2 R7913.2 R7918.1 R7920.1 R7935.1
GPU_ROM_SCLK: GPU1.C12 R7920.2 R7921.1
GPU_ROM_SI: GPU1.B12 R7924.1 R7935.2
GPU_ROM_SO: GPU1.A12 R7918.2 R7932.1
GPU_THM_SMBCLK: R2438.1 U2401.12
GPU_THM_SMBDAT: R2439.1 U2401.11
GSEN2_INT1: IOBD1.4 R7009.2 R7011.2 U7001.12
GSEN2_INT1_C: R2025.2 R7009.1
GSEN2_INT1_ISH: CPU1.CA36 R2025.1
GSEN2_INT2: IOBD1.5 R7010.2 R7012.2 U7001.11
GSEN2_INT2_C: R2026.2 R7010.1
GSEN2_INT2_ISH: CPU1.CA35 R2026.1
GSEN_INT1: CPU1.BW34 SBD1.4
GSEN_INT2: CPU1.CA37 SBD1.3
GSENSOR_CS: R7006.1 U7001.2
GSENSOR_SDO: R7005.2 R7007.2 U7001.3
GYRO_DRDY: R2028.2 SBD1.1
GYRO_DRDY_ISH: CPU1.BW37 R2028.1 R2051.1 R2052.2
GYRO_INT: R7002.2 R7003.2 SBD1.2
GYRO_INT_C: R2027.2 R7003.1
GYRO_INT_ISH: CPU1.CA34 R2027.1
GYRO_INT_P11: D7001.1 R7002.1
H_CPUPWRGD: CPU1.AR2 ED301.2 R1714.1 TP1705.1
H_PECI: C2405.1 R2437.1 U2401.94
H_PROCHOT#_R: Q2408.D R2416.1 R2418.2
HDA_BITCLK_CODEC: EC1901.2 EC2710.1 R1920.1 R2723.1
HDA_BITCLK_CODEC_R: R2723.2 U2701.5
HDA_BITCLK_CPU: CPU1.BN37 R1920.2
HDA_CODEC_SDIN0: R2724.2 U2701.7
HDA_RST_N_CPU: CPU1.BL35 TP1903.1
HDA_SDIN0_CPU: CPU1.BN35 R2724.1
HDA_SDOUT_CODEC: EC1903.1 EC2709.1 R1921.1 R2722.1
HDA_SDOUT_CODEC_R: R2722.2 U2701.4
HDA_SDOUT_CPU: CPU1.BN36 R1512.2 R1909.2 R1921.2
HDA_SPKR_R: D2703.1 R2741.2
HDA_SYNC_CODEC: R1908.1 U2701.9
HDA_SYNC_CPU: CPU1.BN34 R1908.2
HDD_DEVSLP: CPU1.CP8 R6002.1
HDD_DEVSLP_R: HDD1.8 R6002.2
HDD_SATA_RX_CON_N: C6004.2 ED6001.4 ED6001.7 HDD1.5
HDD_SATA_RX_CON_P: C6003.2 ED6001.5 ED6001.6 HDD1.6
HDD_SATA_RX_N: C6004.1 CPU1.BN10
HDD_SATA_RX_P: C6003.1 CPU1.BN8
HDD_SATA_TX_CON_N: C6006.2 ED6001.2 ED6001.9 HDD1.3
HDD_SATA_TX_CON_P: C6005.2 ED6001.1 ED6001.10 HDD1.2
HDD_SATA_TX_N: C6006.1 CPU1.BN4
HDD_SATA_TX_P: C6005.1 CPU1.BN3
HDMI_DDI_TX_CMC_N0: C5705.2 R5713.1 RN5701.8(B)
HDMI_DDI_TX_CMC_N1: C5707.2 R5715.1 RN5703.5(B)
HDMI_DDI_TX_CMC_N2: C5708.2 R5717.1 RN5703.7(B)
HDMI_DDI_TX_CMC_N3: C5701.2 R5721.1 RN5701.6(B)
HDMI_DDI_TX_CMC_P0: C5703.2 R5714.1 RN5701.7(B)
HDMI_DDI_TX_CMC_P1: C5706.2 R5716.1 RN5703.6(B)
HDMI_DDI_TX_CMC_P2: C5709.2 R5720.1 RN5703.8(B)
HDMI_DDI_TX_CMC_P3: C5704.2 R5722.1 RN5701.5(B)
HDMI_DDI_TX_CON_N0: ED5702.5 ED5702.6 ER5701.1 HDMI1.9 R5713.2
HDMI_DDI_TX_CON_N1: ED5701.5 ED5701.6 ER5702.1 HDMI1.6 R5715.2
HDMI_DDI_TX_CON_N2: ED5701.2 ED5701.9 ER5703.1 HDMI1.3 R5717.2
HDMI_DDI_TX_CON_N3: ED5702.2 ED5702.9 ER5704.1 HDMI1.12 R5721.2
HDMI_DDI_TX_CON_P0: ED5702.4 ED5702.7 ER5701.2 HDMI1.7 R5714.2
HDMI_DDI_TX_CON_P1: ED5701.4 ED5701.7 ER5702.2 HDMI1.4 R5716.2
HDMI_DDI_TX_CON_P2: ED5701.1 ED5701.10 ER5703.2 HDMI1.1 R5720.2
HDMI_DDI_TX_CON_P3: ED5702.1 ED5702.10 ER5704.2 HDMI1.10 R5722.2
HDMI_DDI_TX_N0: C5705.1 CPU1.AF6
HDMI_DDI_TX_N1: C5707.1 CPU1.AJ5
HDMI_DDI_TX_N2: C5708.1 CPU1.AL5
HDMI_DDI_TX_N3: C5701.1 CPU1.AE5
HDMI_DDI_TX_P0: C5703.1 CPU1.AF5
HDMI_DDI_TX_P1: C5706.1 CPU1.AJ6
HDMI_DDI_TX_P2: C5709.1 CPU1.AL6
HDMI_DDI_TX_P3: C5704.1 CPU1.AE6
HDMI_DET_CON: ED5703.1 ED5703.10 HDMI1.19 R5710.2 R5711.1
HDMI_HPD_B: Q5703.B R5710.1
HDMI_HPD_CPU: CPU1.CN6 R5712.1
HDMI_HPD_E: Q5703.E R5709.1 R5712.2
HDMI_PLL_GND: Q5701.D R5707.2 RN5701.1(A) RN5701.2(A) RN5701.3(A) RN5701.4(A) RN5703.1(A) RN5703.2(A) RN5703.3(A) RN5703.4(A)
HDMI_SCL_CON: ED5703.4 ED5703.7 HDMI1.15 Q5702.3 RN5702.1(A)
HDMI_SCL_CPU: CPU1.CC8 Q5702.4 RN401.3(B)
HDMI_SCL_R: D5701.2 RN5702.4(B)
HDMI_SDA_CON: ED5703.2 ED5703.9 HDMI1.16 Q5702.6 RN5702.2(A)
HDMI_SDA_CPU: CPU1.CC9 Q5702.1 RN401.4(B)
HDMI_SDA_R: D5701.1 RN5702.3(B)
HOST_DEBUG_TX: DBG3.5 R2478.2 R6801.1 U2401.81
HOST_DEBUG_TX_CON: DBG1.11 R6801.2
HPDIN: R7307.2 U7301.32
HVA_GATE1: R7230.1 U7204.B9
HVA_GATE2: R7231.1 U7204.A9
HW_ACAV_IN: R2469.1 U2401.128
HW_ACAVIN_NB: D4308.A Q4349.5 R4311.2 R4315.2 R4378.2 U2401.24 U4302.1
I2C1_SCL_R: AFTP6528.1 Q6503.6 R6515.2 R6518.2 RN6502.4(B) TPAD1.6
I2C1_SDA_R: AFTP6527.1 Q6503.3 R6511.2 R6519.2 RN6502.3(B) TPAD1.7
I2C_CLK_PD: R7304.2 RN7206.3(B) U7204.D2
I2C_CLK_PD_MUX: R7304.1 U7301.21
I2C_DATA_PD: R7305.2 RN7206.4(B) U7204.D1
I2C_DATA_PD_MUX: R7305.1 U7301.22
I2C_IRQ1#: R7240.2 U7204.C1
I2CB_SCL: GPU1.C9 RN7905.3(B)
I2CB_SDA: GPU1.C8 RN7905.4(B)
I2CC_SCL: GPU1.A9 RN7904.4(B)
I2CC_SDA: GPU1.B9 RN7904.3(B)
I2CEN: R7343.1 R7344.2 U7301.17
I_ADP: C2436.1 R2423.1 U2401.110
I_BATT: C2431.1 R2483.1 U2401.114
IC_DELAY: C4344.1 U4302.4
ICSP_CLK: DBG3.2 U2401.101
ICSP_CLR: DBG3.6 R2414.1 U2401.87
ICSP_DAT: DBG3.3 U2401.102
ILIM_HI: R3604.2 U3601.16
ILIM_LO: R3603.2 U3601.15
ILIM_SEL: R3605.2 U3601.4
INPUT3VSEL: CPU1.BT27 R1520.2 R1521.1
INT2_SELECT: D7001.2 Q7001.5 R7008.1 R7012.1
INT#_TYPEC_R: R7238.2 U7204.B6
IR_CAM_DET#: CPU1.CM22 R2046.2
IRQ1#: R7240.1 R7241.2
ISH_KB_DISABLE: CPU1.BW35 Q2001.2
IST_TRIG: CPU1.CP36 TP620.1
ITP_PMODE: CPU1.W4 TP618.1
JACK_PLUG: AUD1.5 ED2909.1 R2923.1
JACK_PLUG_DET: AUD1.6 ED2907.1 R2914.1
JGND: AFTP4301.1 AFTP4302.1 DCIN1.1 DCIN1.2 DCIN1.3 EC4301.2 EC4302.2 EC4312.2 EC4313.2 EL4303.1 EL4304.1
JIO3_PCIE_WAKE#: AFTP6608.1 R1822.2 R1843.2 R6105.2
JIO3_PCIE_WAKE#_R: R6105.1 WLAN1.55
KB_BL_CTRL#: AFTP6607.1 KB_BL1.4 Q6501.D
KB_DET#: AFTP6519.1 CPU1.CM12 KB1.30 R2045.2
KB_DISABLE_CPU_R: Q2001.5 Q2001.6 R2001.2
KB_LED_BL_DET: AFTP6606.1 CPU1.CK36 R6503.1 R6507.1
KB_LED_DET_C: C6502.1 KB_BL1.2 R6503.2
KB_LED_PWM: Q6501.G R6505.1 U2401.44
KBC_BEEP_R: D2703.2 R2734.2
KBC_PWRBTN#: R2432.1 RN6401.2(A) TP9954.1
KBC_PWRBTN#_C: EC6403.1 ED6401.1 G6401.1 G6402.1 IOBD1.9 RN6401.3(B)
KSI0: AFTP6507.1 KB1.22 RN2404.8(B) U2401.98
KSI1: AFTP6540.1 KB1.24 RN2403.5(B) U2401.99
KSI2: AFTP6533.1 KB1.26 RN2403.6(B) U2401.6
KSI3: AFTP6502.1 KB1.23 RN2404.7(B) U2401.7
KSI4: AFTP6521.1 KB1.27 RN2403.7(B) U2401.104
KSI5: AFTP6513.1 KB1.25 RN2404.6(B) U2401.105
KSI6: AFTP6511.1 KB1.28 RN2404.5(B) U2401.107
KSI7: AFTP6523.1 KB1.29 RN2403.8(B) U2401.108
KSO0: AFTP6520.1 KB1.13 RN2415.7(B) U2401.2
KSO1: AFTP6517.1 KB1.15 RN2415.8(B) U2401.14
KSO2: AFTP6510.1 KB1.14 RN2415.5(B) U2401.15
KSO3: AFTP6518.1 KB1.16 RN2416.8(B) U2401.16
KSO4: AFTP6522.1 KB1.20 RN2416.6(B) U2401.37
KSO5: AFTP6536.1 KB1.21 RN2412.8(B) U2401.38
KSO6: AFTP6512.1 KB1.18 RN2416.5(B) U2401.39
KSO7: AFTP6534.1 KB1.19 RN2412.7(B) U2401.50
KSO8: AFTP6505.1 KB1.17 RN2416.7(B) U2401.46
KSO9: AFTP6516.1 KB1.7 R2449.1 R2450.2 U2401.68
KSO10: AFTP6503.1 KB1.5 RN2414.5(B) U2401.72
KSO11: AFTP6506.1 KB1.6 RN2414.6(B) U2401.74
KSO12: AFTP6538.1 KB1.12 RN2412.6(B) U2401.75
KSO13: AFTP6535.1 KB1.9 RN2414.7(B) U2401.76
KSO14: AFTP6539.1 KB1.8 RN2415.6(B) U2401.77
KSO15: AFTP6515.1 KB1.10 RN2414.8(B) U2401.86
KSO16: AFTP6508.1 KB1.11 RN2412.5(B) U2401.92
L_BKLT_CTRL: CPU1.CH11 R5530.1
L_BKLT_EN: CPU1.CK11 R2401.2 R2405.1 R2436.1
L_BKLT_EN_L: D2401.2 R2405.2
LAN_CLK_CPU_N: CPU1.BD3 IOBD1.35
LAN_CLK_CPU_P: CPU1.BC3 IOBD1.34
LAN_CLKREQ_CPU_N: CPU1.CF30 IOBD1.8 RN1813.7(B)
LAN_PCIE_RX_N: CPU1.BP5 IOBD1.40
LAN_PCIE_RX_P: CPU1.BP6 IOBD1.39
LAN_PCIE_TX_C_N: C1613.2 CPU1.BR2
LAN_PCIE_TX_C_P: C1614.2 CPU1.BR1
LAN_PCIE_TX_N: C1613.1 IOBD1.37
LAN_PCIE_TX_P: C1614.1 IOBD1.36
LAN_WAKE#: CPU1.BU32 R1707.2 R2407.2 R2435.1
LANWAKE#: R2407.1 U2401.35
LANWAKE#_IC: IOBD1.7 R2406.1 R2435.2
LCD_BRIGHTNESS: EC5504.1 LCD1.21 RN5503.4(B)
LCD_TST: D5503.2 RN5503.2(A) U2401.26
LCD_TST_C: LCD1.20 RN5503.3(B)
LCD_VCC_TEST_EN: R2419.1 U2401.113
LCD_VCC_TEST_EN_R: D5502.2 R2419.2
LCDVDD_EN: D5502.3 R5506.1 U5501.1
LDO1_CAP: C2703.1 R2702.1 U2701.21
LDO2_CAP: C2711.1 U2701.32
LDO3_CAP: C2722.1 U2701.6
LID_CL_SIO#: D2402.K RN2405.3(A) RN6401.1(A) U2401.66 U6402.1
LID_CL_SIO_TAB#: R2440.2 R6601.2 U2401.41
LID_CLOSE#_C: EC6401.1 IOBD1.11 RN6401.4(B)
LINE1-L_C: C2907.2 R2922.1
LINE1-L_R: C2908.2 R2921.1
LINE1_L: C2907.1 U2701.18
LINE1_R: C2908.1 U2701.17
LINE1_VREFO: D2901.3 U2701.24
LINE1_VREFO_D1: D2901.1 R2912.1
LINE1_VREFO_D2: D2901.2 R2913.1
LPS_SW: C7401.1 R7402.2 R7403.1 R7404.1 U7418.4
LPS_SW_A: Q7406.3 R7402.1
LPS_SW_B: Q8612.D R7403.2
LPS_SW_C: Q8612.G R7405.1 R7406.2
LPS_SW_D: Q7406.6 R7405.2
M2_SSD_PEDET: AFTP6303.1 CPU1.CP10 R6339.2 SSD1.69
M_A_A0: CPU1.AC37 DM1.144
M_A_A1: CPU1.AC36 DM1.133
M_A_A2: CPU1.AC34 DM1.132
M_A_A3: CPU1.AC35 DM1.131
M_A_A4: CPU1.AA35 DM1.128
M_A_A5: CPU1.AB35 DM1.126
M_A_A6: CPU1.AA37 DM1.127
M_A_A7: CPU1.AA36 DM1.122
M_A_A8: CPU1.AB34 DM1.125
M_A_A9: CPU1.W36 DM1.121
M_A_A10: CPU1.Y31 DM1.146
M_A_A11: CPU1.W34 DM1.120
M_A_A12: CPU1.AA34 DM1.119
M_A_A13: CPU1.AC32 DM1.158
M_A_A14: CPU1.AC31 DM1.151
M_A_A15: CPU1.AB32 DM1.156
M_A_A16: CPU1.Y32 DM1.152
M_A_ACT_N: CPU1.V35 DM1.114
M_A_ALERT_N: CPU1.W37 DM1.116
M_A_BA0: CPU1.W32 DM1.150
M_A_BA1: CPU1.AB31 DM1.145
M_A_BG0: CPU1.V34 DM1.115
M_A_BG1: CPU1.W35 DM1.113
M_A_CKE0: CPU1.U36 DM1.109
M_A_CKE1: CPU1.U37 DM1.110
M_A_CLK0: CPU1.V31 DM1.137
M_A_CLK1: CPU1.T31 DM1.138
M_A_CLK#0: CPU1.V32 DM1.139
M_A_CLK#1: CPU1.T32 DM1.140
M_A_CS#0: CPU1.AE32 DM1.149
M_A_CS#1: CPU1.AF32 DM1.157
M_A_DIMA_ODT0: CPU1.AE31 DM1.155
M_A_DIMA_ODT1: CPU1.AF31 DM1.161
M_A_DQ0: CPU1.A26 DM1.24
M_A_DQ1: CPU1.D26 DM1.29
M_A_DQ2: CPU1.D28 DM1.42
M_A_DQ3: CPU1.C28 DM1.41
M_A_DQ4: CPU1.B26 DM1.25
M_A_DQ5: CPU1.C26 DM1.28
M_A_DQ6: CPU1.B28 DM1.37
M_A_DQ7: CPU1.A28 DM1.38
M_A_DQ8: CPU1.B30 DM1.50
M_A_DQ9: CPU1.D30 DM1.46
M_A_DQ10: CPU1.B33 DM1.59
M_A_DQ11: CPU1.D32 DM1.63
M_A_DQ12: CPU1.A30 DM1.49
M_A_DQ13: CPU1.C30 DM1.45
M_A_DQ14: CPU1.B32 DM1.62
M_A_DQ15: CPU1.C32 DM1.58
M_A_DQ16: CPU1.J22 DM1.67
M_A_DQ17: CPU1.H25 DM1.80
M_A_DQ18: CPU1.G22 DM1.71
M_A_DQ19: CPU1.H22 DM1.66
M_A_DQ20: CPU1.F25 DM1.83
M_A_DQ21: CPU1.J25 DM1.84
M_A_DQ22: CPU1.G25 DM1.79
M_A_DQ23: CPU1.F22 DM1.70
M_A_DQ24: CPU1.D22 DM1.7
M_A_DQ25: CPU1.C22 DM1.3
M_A_DQ26: CPU1.C24 DM1.20
M_A_DQ27: CPU1.D24 DM1.21
M_A_DQ28: CPU1.A22 DM1.8
M_A_DQ29: CPU1.B22 DM1.4
M_A_DQ30: CPU1.A24 DM1.16
M_A_DQ31: CPU1.B24 DM1.17
M_A_DQ32: CPU1.H37 DM1.211
M_A_DQ33: CPU1.H34 DM1.212
M_A_DQ34: CPU1.K34 DM1.229
M_A_DQ35: CPU1.K35 DM1.228
M_A_DQ36: CPU1.H36 DM1.216
M_A_DQ37: CPU1.H35 DM1.215
M_A_DQ38: CPU1.K36 DM1.224
M_A_DQ39: CPU1.K37 DM1.225
M_A_DQ40: CPU1.N36 DM1.232
M_A_DQ41: CPU1.N34 DM1.236
M_A_DQ42: CPU1.R37 DM1.246
M_A_DQ43: CPU1.R34 DM1.250
M_A_DQ44: CPU1.N37 DM1.233
M_A_DQ45: CPU1.N35 DM1.237
M_A_DQ46: CPU1.R36 DM1.249
M_A_DQ47: CPU1.R35 DM1.245
M_A_DQ48: CPU1.G31 DM1.183
M_A_DQ49: CPU1.G32 DM1.186
M_A_DQ50: CPU1.H29 DM1.174
M_A_DQ51: CPU1.H28 DM1.173
M_A_DQ52: CPU1.G28 DM1.169
M_A_DQ53: CPU1.G29 DM1.170
M_A_DQ54: CPU1.H31 DM1.182
M_A_DQ55: CPU1.H32 DM1.187
M_A_DQ56: CPU1.L31 DM1.190
M_A_DQ57: CPU1.L32 DM1.194
M_A_DQ58: CPU1.N29 DM1.204
M_A_DQ59: CPU1.N28 DM1.208
M_A_DQ60: CPU1.L28 DM1.191
M_A_DQ61: CPU1.L29 DM1.195
M_A_DQ62: CPU1.N31 DM1.207
M_A_DQ63: CPU1.N32 DM1.203
M_A_DQS_DN0: CPU1.C27 DM1.32
M_A_DQS_DN1: CPU1.D31 DM1.53
M_A_DQS_DN2: CPU1.H24 DM1.74
M_A_DQS_DN3: CPU1.C23 DM1.11
M_A_DQS_DN4: CPU1.J35 DM1.219
M_A_DQS_DN5: CPU1.P34 DM1.240
M_A_DQS_DN6: CPU1.G30 DM1.177
M_A_DQS_DN7: CPU1.L30 DM1.198
M_A_DQS_DP0: CPU1.D27 DM1.34
M_A_DQS_DP1: CPU1.C31 DM1.55
M_A_DQS_DP2: CPU1.G24 DM1.76
M_A_DQS_DP3: CPU1.D23 DM1.13
M_A_DQS_DP4: CPU1.J34 DM1.221
M_A_DQS_DP5: CPU1.P35 DM1.242
M_A_DQS_DP6: CPU1.H30 DM1.179
M_A_DQS_DP7: CPU1.N30 DM1.200
M_A_PARITY: CPU1.W31 DM1.143
M_B_A0: CPU1.AG36 DM2.144
M_B_A1: CPU1.AG35 DM2.133
M_B_A2: CPU1.AF34 DM2.132
M_B_A3: CPU1.AG37 DM2.131
M_B_A4: CPU1.AE35 DM2.128
M_B_A5: CPU1.AF35 DM2.126
M_B_A6: CPU1.AE37 DM2.127
M_B_A7: CPU1.AC29 DM2.122
M_B_A8: CPU1.AE36 DM2.125
M_B_A9: CPU1.AB29 DM2.121
M_B_A10: CPU1.AG34 DM2.146
M_B_A11: CPU1.AC28 DM2.120
M_B_A12: CPU1.AB28 DM2.119
M_B_A13: CPU1.AK35 DM2.158
M_B_A14: CPU1.AJ35 DM2.151
M_B_A15: CPU1.AK34 DM2.156
M_B_A16: CPU1.AJ34 DM2.152
M_B_ACT_N: CPU1.W28 DM2.114
M_B_ALERT_N: CPU1.Y29 DM2.116
M_B_BA0: CPU1.AJ37 DM2.150
M_B_BA1: CPU1.AJ36 DM2.145
M_B_BG0: CPU1.W29 DM2.115
M_B_BG1: CPU1.Y28 DM2.113
M_B_CKE0: CPU1.T28 DM2.109
M_B_CKE1: CPU1.T29 DM2.110
M_B_CLK0: CPU1.AF29 DM2.137
M_B_CLK1: CPU1.AE29 DM2.138
M_B_CLK#0: CPU1.AF28 DM2.139
M_B_CLK#1: CPU1.AE28 DM2.140
M_B_CS#0: CPU1.AL37 DM2.149
M_B_CS#1: CPU1.AL35 DM2.157
M_B_DIMB_ODT0: CPU1.AL36 DM2.155
M_B_DIMB_ODT1: CPU1.AL34 DM2.161
M_B_DQ0: CPU1.AN35 DM2.4
M_B_DQ1: CPU1.AN34 DM2.8
M_B_DQ2: CPU1.AR35 DM2.17
M_B_DQ3: CPU1.AR34 DM2.21
M_B_DQ4: CPU1.AN37 DM2.3
M_B_DQ5: CPU1.AN36 DM2.7
M_B_DQ6: CPU1.AR36 DM2.16
M_B_DQ7: CPU1.AR37 DM2.20
M_B_DQ8: CPU1.AU35 DM2.25
M_B_DQ9: CPU1.AU34 DM2.37
M_B_DQ10: CPU1.AW35 DM2.38
M_B_DQ11: CPU1.AW34 DM2.29
M_B_DQ12: CPU1.AU37 DM2.28
M_B_DQ13: CPU1.AU36 DM2.24
M_B_DQ14: CPU1.AW36 DM2.41
M_B_DQ15: CPU1.AW37 DM2.42
M_B_DQ16: CPU1.AJ29 DM2.170
M_B_DQ17: CPU1.AJ30 DM2.174
M_B_DQ18: CPU1.AM32 DM2.187
M_B_DQ19: CPU1.AM31 DM2.186
M_B_DQ20: CPU1.AM30 DM2.183
M_B_DQ21: CPU1.AM29 DM2.182
M_B_DQ22: CPU1.AJ31 DM2.173
M_B_DQ23: CPU1.AJ32 DM2.169
M_B_DQ24: CPU1.AR31 DM2.195
M_B_DQ25: CPU1.AR32 DM2.191
M_B_DQ26: CPU1.AV30 DM2.207
M_B_DQ27: CPU1.AV29 DM2.204
M_B_DQ28: CPU1.AR30 DM2.194
M_B_DQ29: CPU1.AR29 DM2.190
M_B_DQ30: CPU1.AV32 DM2.208
M_B_DQ31: CPU1.AV31 DM2.203
M_B_DQ32: CPU1.BA35 DM2.45
M_B_DQ33: CPU1.BA34 DM2.58
M_B_DQ34: CPU1.BC35 DM2.59
M_B_DQ35: CPU1.BC34 DM2.46
M_B_DQ36: CPU1.BA37 DM2.49
M_B_DQ37: CPU1.BA36 DM2.50
M_B_DQ38: CPU1.BC36 DM2.62
M_B_DQ39: CPU1.BC37 DM2.63
M_B_DQ40: CPU1.BE35 DM2.66
M_B_DQ41: CPU1.BE34 DM2.70
M_B_DQ42: CPU1.BG35 DM2.84
M_B_DQ43: CPU1.BG34 DM2.83
M_B_DQ44: CPU1.BE37 DM2.71
M_B_DQ45: CPU1.BE36 DM2.67
M_B_DQ46: CPU1.BG36 DM2.79
M_B_DQ47: CPU1.BG37 DM2.80
M_B_DQ48: CPU1.BA32 DM2.215
M_B_DQ49: CPU1.BA31 DM2.216
M_B_DQ50: CPU1.BD31 DM2.228
M_B_DQ51: CPU1.BD32 DM2.224
M_B_DQ52: CPU1.BA30 DM2.211
M_B_DQ53: CPU1.BA29 DM2.212
M_B_DQ54: CPU1.BD29 DM2.225
M_B_DQ55: CPU1.BD30 DM2.229
M_B_DQ56: CPU1.BG31 DM2.237
M_B_DQ57: CPU1.BG32 DM2.233
M_B_DQ58: CPU1.BK32 DM2.250
M_B_DQ59: CPU1.BK31 DM2.246
M_B_DQ60: CPU1.BG29 DM2.232
M_B_DQ61: CPU1.BG30 DM2.236
M_B_DQ62: CPU1.BK30 DM2.249
M_B_DQ63: CPU1.BK29 DM2.245
M_B_DQS_DN0: CPU1.AP35 DM2.11
M_B_DQS_DN1: CPU1.AV34 DM2.32
M_B_DQS_DN2: CPU1.AL31 DM2.177
M_B_DQS_DN3: CPU1.AU31 DM2.198
M_B_DQS_DN4: CPU1.BB35 DM2.53
M_B_DQS_DN5: CPU1.BF34 DM2.74
M_B_DQS_DN6: CPU1.BC31 DM2.219
M_B_DQS_DN7: CPU1.BH31 DM2.240
M_B_DQS_DP0: CPU1.AP34 DM2.13
M_B_DQS_DP1: CPU1.AV35 DM2.34
M_B_DQS_DP2: CPU1.AL30 DM2.179
M_B_DQS_DP3: CPU1.AU30 DM2.200
M_B_DQS_DP4: CPU1.BB34 DM2.55
M_B_DQS_DP5: CPU1.BF35 DM2.76
M_B_DQS_DP6: CPU1.BC30 DM2.221
M_B_DQS_DP7: CPU1.BH30 DM2.242
M_B_PARITY: CPU1.AE34 DM2.143
M_VREF_CA_DIMMA: C1229.1 DM1.164 R1206.1 RN1201.3(B) RN1201.4(B)
M_VREF_CA_DIMMB: C1301.1 DM2.164 R1305.1 RN1301.3(B) RN1301.4(B)
MASK_BASE_LEDS#: Q6402.2 Q6402.5 R6419.2 U6402.4
MASK_SATA_LED#: Q6401.G R6401.2 U2401.56
ME_FWP: R9806.1 U2401.80
ME_FWP_SW: R1909.1 R9806.2
ME_SUS_PWR_ACK_R: CPU1.BV34 R1708.1 R1738.2
MEC_XTAL1_R: C2425.2 U2401.123 X2401.1
MEC_XTAL2: R2428.1 R2458.1 U2401.125
MIC2_VREFO: RN2901.1(A) RN2901.2(A) U2701.23
MIC_CAP: C2715.1 U2701.15
MIC_GND: LCD1.29 R5531.1
MODEL_ID: C2407.2 R2441.1 R2442.2 U2401.109
MSATA_RST#: R6308.2 SSD1.50
MUX_HPD_PD: R7326.1 U7301.23
N12P_JTAG_TCK: GPU1.AE5 TP7906.1
N12P_JTAG_TDI: GPU1.AE6 TP7905.1
N12P_JTAG_TDO: GPU1.AF6 TP7901.1
N12P_JTAG_TMS: GPU1.AD6 TP7902.1
N12P_JTAG_TRST: GPU1.AG4 R7975.1
N12P_XTAL_OUTBUFF: GPU1.C10 R7902.1 R7917.2
NAZ_GND1: R9137.2 U9101.2
NAZ_GND2: R9142.1 U9101.9
NB_MODE#: Q2001.3 R2002.2 R2050.1 U2401.34
NB_MUTE#: R2712.1 R2717.2 U2401.119
NC_AUX_EN_WOWL_EC: R2427.2 U2401.97
NCT7718_DXN: C2606.2 C2607.2 Q2603.E THM261.3
NCT7718_DXP: C2606.1 C2607.1 Q2603.B Q2603.C THM261.2
NRB_BIT: CPU1.CE29 R1502.2 R1503.1
NZ_VHIO: R9139.1 U9101.14
P2800_VGA_DXN: GPU1.E12 TP7903.1
P2800_VGA_DXP: GPU1.F12 TP7904.1
PANEL_BKEN_EC: D2401.1 U2401.117
PBAT_CHG_SMBCLK: D4306.3 EC4309.1 PU4401.22 RN2402.3(B) RN4302.2(A) U2401.9
PBAT_CHG_SMBDAT: D4305.3 EC4310.1 PU4401.21 RN2402.4(B) RN4302.1(A) U2401.8
PBAT_PRES1#: AFTP4309.1 BATT1.6 R4310.2
PBAT_PRES#: D4304.3 EC4306.2 PR4409.2 R2415.2 R4310.1 U2401.29
PBAT_SMBCLK1: AFTP4311.1 BATT1.4 RN4302.3(B)
PBAT_SMBDAT1: AFTP4310.1 BATT1.5 RN4302.4(B)
PCH_BATLOW#: CPU1.BV36 R1722.2 R1723.1
PCH_DPWROK: CPU1.BP30 R1704.2
PCH_ESPI_CLK: CPU1.BV32 R1805.1
PCH_ESPI_IO0: CPU1.CA29 RN1806.1(A)
PCH_ESPI_IO1: CPU1.BY29 RN1806.3(A)
PCH_ESPI_IO2: CPU1.BY27 RN1806.2(A)
PCH_ESPI_IO3: CPU1.BV27 RN1806.4(A)
PCH_JTAG_TCK: CPU1.W6 R318.1
PCH_JTAG_TDI: CPU1.U5 R312.1 R9995.2
PCH_JTAG_TDO: CPU1.W5 R313.1 R9994.2
PCH_JTAG_TMS: CPU1.P5 R314.1 R9992.2
PCH_PLTRST#: CPU1.BJ35 R1713.2
PCH_POPIRCOMP: CPU1.BW25 R305.1
PCH_RSMRST#: EC1712.1 R1702.2 TP2402.1 U2401.27
PCH_SMBCLK: DM1.253 DM2.253 EC6505.1 Q1801.4 R6515.1 RN1810.3(B)
PCH_SMBDATA: DM1.254 DM2.254 EC6506.1 Q1801.1 R6511.1 RN1810.4(B)
PCIE_RCOMPN: CPU1.CE6 R1604.1
PCIE_RCOMPP: CPU1.CE5 R1604.2
PCIE_WAKE#: R2406.2 R2476.2 U2401.4
PCIE_WAKE#_CPU: CPU1.BU30 RN1704.4(B)
PD4403_A: PD4404.A PQ4408.B
PD4403_K: PD4404.K PR4466.1 PR4477.1
PD_EE_WP_N: R7253.2 U7205.3
PD_HOLD_N: R7252.2 U7205.7
PD_OVP_TRIP_P1: R7246.2 R7249.1 U7204.E10
PD_VBUS_C_CTRL1: Q7405.2 Q7406.5 U7204.G10
PD_VBUS_C_CTRL1_A: Q7404.3 Q7405.1
PD_VBUS_C_CTRL1_R: Q7405.5 Q7405.6 R7408.1 R7426.2
PD_VBUS_C_EN: Q7407.3 R7422.1 R7427.2 U7419.A3
PD_VBUS_C_EN_A: Q7405.3 Q7407.5 Q7407.6 R7407.1 R7425.2
PDB_R: R2712.2 U2701.40
PECI_CPU: CPU1.AR1 R2437.2
PEX_PLLVDD: C7632.1 C7633.1 C7634.1 GPU1.AA14 GPU1.AA15 L7602.1
PEX_SVDD: C7615.1 C7624.1 GPU1.AB8 R7616.1
PEX_TERMP: GPU1.AF25 R7601.1
PEX_TSTCLK_OUT: GPU1.AF22 R7605.1
PEX_TSTCLK_OUT#: GPU1.AE22 R7605.2
PIRQA#: CPU1.CC32 R2053.2 R9152.2
PLT_RST#: AFTP6108.1 C1701.1 ED1701.1 IOBD1.10 R1713.1 R1715.1 R2616.1 R6308.1 R9110.1 U7601.2 WLAN1.52
PLT_RST#_Q_TPM: R9110.2 U9101.17
PM_LAN_ENABLE: R2491.1 R6602.2
PM_LAN_ENABLE_R: IOBD1.6 R6601.1 R6602.1
PM_PCH_PWROK: CPU1.BP31 R1706.2 RN1703.3(B)
PM_RSMRST#: CPU1.BR36 Q1701.3 Q1702.2 R1702.1 R1704.1 RN1703.4(B) TP1707.1
PM_RSMRST#_M: Q1702.5 Q1702.6 R1737.2
PM_SLP_S0#: CPU1.BJ37 R1724.2 R2476.1 R4018.1 R9121.2 TP1709.1 TP9956.1
PM_SLP_S3#: CPU1.BU36 D4003.K D4004.K Q4001.2 R2740.1 R4010.1 R4017.1 TP1710.1 TP9952.1 U4007.1
PM_SLP_S4#: CPU1.BU27 IOBD1.12 PR5116.1 R4024.1 TP1711.1 TP9950.1
PM_SLP_S5#: CPU1.BT29 TP1712.1 TP9949.1
POWER_SW_IN#: C2426.1 R2432.2 R2451.2 U2401.127
PQ3802_1: Q4302.B R4302.1 R4309.2
PQ4348_D: Q4348.D R4368.2
PQ4405_2: PQ4405.2 PR4462.1 PR4463.1
PQ4405_3: PQ4405.3 PR4476.1
PQ4405_5: PC4438.1 PQ4405.5 PR4474.2
PQ4405_6: PC4438.2 PQ4405.6 PR4450.1
PQ4408_C: PQ4408.C PR4462.2 PR4475.1
PQ4408_E: PQ4408.E PR4436.1 PR4473.2
PQ4417_D: PQ4417.D PR4430.2 PR4431.2
PQ4418_2: PQ4418.2 PR4431.1 PR4432.1
PQ4418_3: PQ4418.3 PR4433.1
PQ4418_5: PC4446.1 PQ4418.5 PR4465.2
PQ4418_6: PC4446.2 PQ4418.6 PR4464.1
PRIM_PWRGD: ED4001.1 PR5301.1 R4030.1 U2401.30
PROCHOT: Q2408.G R2417.1 R2418.1 U2401.83
PROCHOT#_CPU: PQ4416.3 PR4433.2 PR4476.2 PR4603.2 PR4607.1 R301.2 R302.1 R2416.2
PROCHOT#_CPU_R: CPU1.Y4 R302.2
PROJECT_ID0: CPU1.CH23 R2113.2 R2114.1
PROJECT_ID1: CPU1.CK19 R2111.2 R2112.1
PROJECT_ID2: CPU1.CG17 R2117.2 R2118.1
PROJECT_ID3: CPU1.CN20 R2115.2 R2116.1
PS_ID: D4302.3 R4304.2 R4305.2 U2401.36
PS_ID_R: AFTP4304.1 DCIN1.4 EC4311.1 R4317.1
PS_ID_R1: Q4301.S R4305.1 R4306.2
PS_ID_R2: D4303.1 D4303.2 Q4301.D R4306.1 R4309.1 R4317.2
PS_S3CNTRL: Q4001.5 Q4001.6 R4004.2
PSID_DISABLE#_R_C: Q4301.G Q4302.C R4303.2
PTP_DIS#: D2405.K U2401.90
PU4348_G: Q4348.G R4369.1 R4370.2
PURE_HW_SHUTDOWN#: C2610.1 D4001.K ED4001.2 Q2602.D R2615.1 R4007.2
PWR_1D0V_BT: PC5204.1 PU5201.20
PWR_1D0V_EN: PC5215.1 PR5207.2 PU5201.2
PWR_1D0V_FB: PC5212.2 PR5202.2 PR5204.1 PU5201.5
PWR_1D0V_FB_A: PC5212.1 PG5223.1 PR5202.1
PWR_1D0V_PFM: PR5203.1 PU5201.3
PWR_1D0V_PG: PR5206.2 PR5208.2 PU5201.1
PWR_1D0V_PH: PC5204.2 PL5201.1 PU5201.10 PU5201.11 PU5201.16 PU5201.17 PU5201.18
PWR_1D0V_SS: PC5213.1 PU5201.22
PWR_1D0V_TON: PR5201.2 PU5201.6
PWR_1D8V_EN: PC5304.1 PR5305.2 PR5306.1 PU5301.8
PWR_1D8V_POK: PR5301.2 PR5304.2 PU5301.7
PWR_1D35V_BOOT: PR8633.1 PU8602.1
PWR_1D35V_BOOT_R: PC8619.1 PR8633.2
PWR_1D35V_BYP: PC8618.1 PR8634.1 PU8602.15
PWR_1D35V_EN: PC8616.1 PR8631.2 PU8602.11
PWR_1D35V_IMAX: PR8632.2 PU8602.13
PWR_1D35V_LDO_P5: PC8617.1 PU8602.16 PU8602.17
PWR_1D35V_PGOOD: PR8635.2 PR8636.2 PU8602.9 PU8602.10
PWR_1D35V_PHASE: PC8619.2 PL8603.1 PU8602.6 PU8602.19 PU8602.20
PWR_1D35V_VFB: PC8602.2 PR8626.1 PR8627.2 PU8602.14
PWR_1D35V_VFB1: PC8602.1 PG8613.2 PR8627.1
PWR_1V: PC8628.1 PC8631.1 PC8632.1 PG8607.1 PG8608.1 PL8602.2 PR8613.1
PWR_1V_FB: PC8632.2 PR8613.2 PR8620.1 PU8603.1
PWR_1V_PHASE: PL8602.1 PU8603.6
PWR_1V_PVDD: PC8627.1 PC8629.1 PC8630.1 PG8605.2 PG8606.2 PU8603.3
PWR_2D5V: PC5126.1 PC5127.1 PC5128.1 PG5122.1 PG5123.1 PR5112.1 PU5102.3 PU5102.4
PWR_2D5V_EN: PC5129.1 PR5115.1 PR5116.2 PU5102.8
PWR_2D5V_FB: PC5126.2 PR5112.2 PR5113.1 PU5102.2
PWR_2D5V_PG: PR5105.1 PR5114.2 PU5102.7
PWR_3D3V: PC4509.1 PC4510.1 PC4511.1 PC4512.1 PC4513.1 PC4525.1 PG4519.1 PG4520.1 PG4521.1 PG4522.1 PG4523.1 PG4524.1 PG4530.2 PL4501.2
PWR_3D3V_BOOT: PR4501.1 PU4501.1
PWR_3D3V_BOOT_A: PC4506.1 PR4501.2
PWR_3D3V_EN: PC4508.1 PR4508.1 PR4509.2 PU4501.11
PWR_3D3V_EN1: PC4532.1 PR4514.1 PR4516.2 PU4501.12
PWR_3D3V_FB: PC4533.1 PU4501.13
PWR_3D3V_FB2: PC4533.2 PR4506.2
PWR_3D3V_LDO: PC4507.1 PG4532.1 PU4501.16 PU4501.17
PWR_3D3V_PH: PC4506.2 PL4501.1 PU4501.6 PU4501.19 PU4501.20
PWR_3D3V_VOUT: PG4530.1 PR4506.1 PU4501.14
PWR_3V_PG: PG4531.2 PR4505.2 PU4501.9 PU4501.10
PWR_5V: PC4514.1 PC4515.1 PC4516.1 PC4517.1 PC4518.1 PC4527.1 PC4529.1 PG4507.1 PG4508.1 PG4509.1 PG4510.1 PG4511.1 PG4512.1 PG4513.1 PG4514.1 PG4527.2 PL4502.1
PWR_5V_BOOT: PR4502.1 PU4502.1
PWR_5V_BOOT_A: PC4521.1 PR4502.2
PWR_5V_EN: PC4530.1 PR4511.2 PR4512.1 PU4502.11
PWR_5V_EN1: PC4531.1 PR4504.2 PR4513.1 PU4502.12
PWR_5V_EN1_R: PR4503.2 PR4504.1 PR4515.2 PR4530.2
PWR_5V_FB: PC4526.1 PR4551.1 PU4502.13
PWR_5V_FB_A: PC4526.2 PR4507.1
PWR_5V_LDO: PC4520.1 PG4528.1 PU4502.15
PWR_5V_PG: PG4529.2 PR4510.1 PU4502.9 PU4502.10
PWR_5V_PH: PC4521.2 PL4502.2 PU4502.6 PU4502.19 PU4502.20
PWR_5V_VCC: PC4524.1 PU4502.16 PU4502.17
PWR_5V_VOUT: PG4527.1 PR4507.2 PU4502.14
PWR_CHG_ACIN: PR4484.2 PR4485.1 PU4401.19
PWR_CHG_ACOK: PG4408.1 PR4426.1 PR4429.2 PR4432.2 PR4463.2 PU4401.24
PWR_CHG_ADP/ACIN: PR4434.1 PR4437.1 PU4401.16
PWR_CHG_AIN: PD4408.3 PR4404.1
PWR_CHG_AIN_R: PC4420.2 PR4404.2 PR4406.1 PR4437.2 PR4484.1
PWR_CHG_AMON: PC4432.1 PR4412.2 PU4401.29
PWR_CHG_ASGATE: PR4490.2 TP4401.1
PWR_CHG_ASGATE22: PC4442.2 PR4445.1
PWR_CHG_ASGATE/NTC: PR4490.1 PR4491.2 PU4401.13
PWR_CHG_BATGONE: PC4430.1 PR4409.1 PU4401.25
PWR_CHG_BGATE: PC4429.1 PR4443.1 PU4412.4
PWR_CHG_BGATE/HG2: PC4445.2 PR4443.2 PU4401.32
PWR_CHG_BGATE_22: PD4409.K PD4411.K PR4495.1
PWR_CHG_BGATE_22_R: PC4443.2 PR4494.1 PR4495.2 PU4413.4
PWR_CHG_BOOT1: PR4402.2 PU4401.12
PWR_CHG_BOOT2: PC4423.1 PU4401.4
PWR_CHG_BT1_R: PC4436.2 PR4402.1
PWR_CHG_BT2_R: PC4423.2 PR4444.1
PWR_CHG_CMRSC: PC4442.1 PR4438.1 PR4439.2
PWR_CHG_COMP: PC4433.1 PR4411.1 PU4401.28
PWR_CHG_COMP_R: PC4431.1 PR4411.2
PWR_CHG_CSIN: PC4415.1 PC4417.2 PR4489.2 PU4401.14
PWR_CHG_CSIN_R: PG4402.2 PR4423.1
PWR_CHG_CSIN_RR: PR4423.2 PR4489.1
PWR_CHG_CSIP: PC4415.2 PC4416.2 PR4488.2 PU4401.15
PWR_CHG_CSIP_R: PG4401.2 PR4422.1
PWR_CHG_CSIP_RR: PR4422.2 PR4488.1
PWR_CHG_CSON: PC4425.2 PC4426.2 PR4487.1 PU4401.1
PWR_CHG_CSON_R: PG4406.2 PR4425.1
PWR_CHG_CSON_RR: PR4425.2 PR4487.2
PWR_CHG_CSOP: PC4424.2 PC4425.1 PR4486.1 PU4401.2
PWR_CHG_CSOP_R: PG4405.2 PR4424.1
PWR_CHG_CSOP_RR: PR4424.2 PR4486.2
PWR_CHG_DCIN: PC4419.1 PR4403.1 PU4401.17
PWR_CHG_DCIN_R: PD4401.3 PD4407.K PR4403.2
PWR_CHG_HG1_R: PR4414.2 PU4403.4
PWR_CHG_HG2_R: PR4420.2 PU4405.4
PWR_CHG_LGATE1: PU4401.9 PU4404.4
PWR_CHG_LGATE2: PR4446.1 PU4406.4
PWR_CHG_LGATE2/ASGATE: PR4445.2 PR4446.2 PU4401.7
PWR_CHG_NGATE: PC4439.2 PR4453.2 PR4480.1 PU4401.3
PWR_CHG_NTC: PR4491.1 PR4492.1
PWR_CHG_OTGEN: PR4417.2 PR4449.2 PR4451.1 PU4401.20
PWR_CHG_OTGPG: PR4447.1 PR4448.2 PU4401.26 TP4411.1
PWR_CHG_PHASE1: PC4436.1 PL4401.1 PR4416.1 PU4401.10 PU4403.1 PU4403.2 PU4403.3 PU4404.5 PU4404.6 PU4404.7 PU4404.8
PWR_CHG_PHASE2: PL4401.2 PR4440.1 PR4441.1 PU4405.1 PU4405.2 PU4405.3 PU4406.5 PU4406.6 PU4406.7 PU4406.8
PWR_CHG_PHASE2_R: PR4441.2 PR4444.2 PU4401.6
PWR_CHG_PROCHOT#: PQ4416.2 PR4435.2 PU4401.23
PWR_CHG_PROCHOT#_R: PQ4402.G PQ4416.5 PQ4416.6 PR4472.2
PWR_CHG_PROG: PC4441.1 PR4410.2 PR4493.1 PU4401.27
PWR_CHG_SNB: PC4435.1 PR4416.2
PWR_CHG_UGATE1: PR4414.1 PU4401.11
PWR_CHG_UGATE2: PR4420.1 PR4438.2 PU4401.5
PWR_CHG_VBAT1: PC4440.2 PC4445.1 PR4478.1 PU4401.31
PWR_CHG_VBATIN: PC4427.1 PC4447.1 PG4406.1 PR4407.2 PR4483.1 PU4412.1 PU4412.2 PU4412.3
PWR_CHG_VBATIN_R: PG4405.1 PR4407.1 PR4440.2 PR4480.2 PR4496.2 PU4413.5 PU4413.6 PU4413.7 PU4413.8
PWR_CHG_VDDP: PC4421.1 PR4405.1 PU4401.8
PWR_DCBATOUT_1D0V: PC5209.1 PC5210.1 PC5211.1 PC5214.1 PC5216.1 PG5210.2 PG5212.2 PG5214.2 PR5201.1 PU5201.7 PU5201.8 PU5201.9
PWR_DCBATOUT_1D35V: PC8609.1 PC8610.1 PC8615.1 PG8614.2 PG8615.2 PG8616.2 PG8617.2 PU8602.2 PU8602.3 PU8602.4 PU8602.5
PWR_DCBATOUT_3D3V: PC4501.1 PC4502.1 PC4503.1 PC4504.1 PG4515.2 PG4516.2 PG4517.2 PG4518.2 PU4501.2 PU4501.3 PU4501.4 PU4501.5
PWR_DCBATOUT_5V: PC4505.1 PC4519.1 PC4522.1 PC4523.1 PG4501.2 PG4502.2 PG4503.2 PG4504.2 PG4505.2 PG4506.2 PG4533.2 PG4534.2 PU4502.2 PU4502.3 PU4502.4 PU4502.5
PWR_DCBATOUT_VCCGTA: PC4802.1 PC4803.1 PC4804.1 PC4805.1 PC4814.1 PC4815.1 PC4816.1 PC4817.1 PG4816.2 PG4817.2 PG4818.2 PG4819.2 PG4820.2 PG4821.2 PG4822.2 PG4823.2 PG4824.2 PG4825.2 PT4805.1 PU4801.8 PU4801.9 PU4801.10 PU4801.11 PU4801.33 PU4802.8 PU4802.9 PU4802.10 PU4802.11 PU4802.33
PWR_DCBATOUT_VCCSA: PC5002.1 PC5003.1 PC5004.1 PG5002.1 PG5003.1 PU5002.5 PU5002.6 PU5002.7 PU5002.8
PWR_DCBATOUT_VCORE: PC4701.1 PC4702.1 PC4703.1 PC4704.1 PG4709.2 PG4710.2 PG4711.2 PG4712.2 PG4713.2 PG4714.2 PG4715.2 PG4716.2 PG4717.2 PG4718.2 PT4702.1 PU4701.8 PU4701.9 PU4701.10 PU4701.11 PU4701.33
PWR_DCBATOUT_VDDQ: PC5111.1 PC5115.1 PC5116.1 PD5101.K PG5101.2 PG5102.2 PG5103.2 PR5103.1 PU5101.21 PU5101.22 PU5101.23 PU5101.24 PU5101.34
PWR_VCCGT_BOOTA: PR4804.2 PU4801.5
PWR_VCCGT_BOOTA_RC: PC4808.1 PR4804.1
PWR_VCCGT_BOOTB: PR4810.2 PU4802.5
PWR_VCCGT_BOOTB_RC: PC4811.1 PR4810.1
PWR_VCCGT_BOOTRA: PC4808.2 PU4801.7
PWR_VCCGT_BOOTRB: PC4811.2 PU4802.7
PWR_VCCGT_COMP: PC4610.2 PR4626.2 PU4601.4
PWR_VCCGT_COMP1: PC4612.1 PC4651.1 PR4626.1
PWR_VCCGT_FB: PR4630.2 PR4633.2 PR4636.2 PR4671.2 PU4601.5
PWR_VCCGT_FB1: PC4614.1 PR4630.1
PWR_VCCGT_FB2: PC4615.2 PC4618.1 PC4619.1 PR4631.1 PR4633.1 PR4665.2 PR4671.1
PWR_VCCGT_FB_RC: PC4618.2 PR4636.1
PWR_VCCGT_FCCM#: PR4806.2 PR4812.2 PU4601.11
PWR_VCCGT_FCCM#_RA: PR4806.1 PU4801.2
PWR_VCCGT_FCCM#_RB: PR4812.1 PU4802.2
PWR_VCCGT_IMON: PC4604.2 PR4608.2 PR4672.2 PU4601.2
PWR_VCCGT_ISEN1: PC4625.1 PR4669.2 PR4821.1 PR4824.2 PU4601.9
PWR_VCCGT_ISEN2: PC4626.1 PR4635.2 PR4669.1 PR4822.2 PR4823.1 PU4601.10
PWR_VCCGT_ISUMN: PC4625.2 PC4626.2 PC4630.2 PC4633.1 PR4642.2 PR4643.2 PR4645.2 PR4646.2 PR4647.1 PR4670.2 PR4809.2 PR4815.2
PWR_VCCGT_ISUMN_GA: PG4809.1 PR4809.1 PR4822.1
PWR_VCCGT_ISUMN_GB: PG4815.1 PR4815.1 PR4824.1
PWR_VCCGT_ISUMN_P_1: PC4609.2 PC4628.2 PC4653.2 PR4647.2
PWR_VCCGT_ISUMN_P_2: PR4641.2 PR4646.1
PWR_VCCGT_ISUMN_RC: PC4623.1 PR4645.1
PWR_VCCGT_ISUMNB: PC4623.2 PR4642.1 PR4670.1 PU4601.8
PWR_VCCGT_ISUMP: PC4609.1 PC4628.1 PC4630.1 PC4653.1 PR4641.1 PR4643.1 PR4808.1 PR4816.1 PU4601.7
PWR_VCCGT_ISUMP_GA: PG4808.1 PR4808.2 PR4821.2
PWR_VCCGT_ISUMP_GB: PG4813.1 PR4816.2 PR4823.2
PWR_VCCGT_NTC: PR4616.1 PU4601.3
PWR_VCCGT_NTC1: PR4616.2 PR4617.1 PR4621.2
PWR_VCCGT_PWMA: PR4802.2 PU4601.12
PWR_VCCGT_PWMA_RA: PR4802.1 PR4817.1 PU4801.1
PWR_VCCGT_PWMB: PR4811.2 PU4601.13
PWR_VCCGT_PWMB_RB: PR4811.1 PR4818.1 PU4802.1
PWR_VCCGT_RTN: PC4619.2 PC4622.1 PR4639.1 PR4666.2 PU4601.6
PWR_VCCGT_SNB1: PC4810.1 PR4805.2
PWR_VCCGT_SNB2: PC4813.1 PR4814.2
PWR_VCCGT_SWA: PG4808.2 PL4801.1 PR4805.1 PU4801.16 PU4801.17 PU4801.18 PU4801.19 PU4801.20 PU4801.21 PU4801.22 PU4801.23 PU4801.24 PU4801.25 PU4801.26
PWR_VCCGT_SWB: PG4813.2 PL4802.1 PR4814.1 PU4802.16 PU4802.17 PU4802.18 PU4802.19 PU4802.20 PU4802.21 PU4802.22 PU4802.23 PU4802.24 PU4802.25 PU4802.26
PWR_VCCGT_VCCDA: PC4809.1 PR4803.1 PU4801.3
PWR_VCCGT_VCCDB: PC4812.1 PR4813.1 PU4802.3
PWR_VCCSA_BST: PR5001.2 PU5001.2
PWR_VCCSA_BST_RC: PC5005.1 PR5001.1
PWR_VCCSA_COMP: PC4624.1 PR4640.1 PU4601.24
PWR_VCCSA_COMP_RC: PC4601.1 PR4640.2
PWR_VCCSA_DRVH: PU5001.1 PU5002.4
PWR_VCCSA_DRVL: PU5001.5 PU5003.4
PWR_VCCSA_FB: PR4632.2 PR4637.1 PR4638.2 PU4601.25
PWR_VCCSA_FB1: PC4621.2 PR4638.1
PWR_VCCSA_FB2: PC4616.2 PC4617.2 PC4620.1 PR4601.1 PR4637.2
PWR_VCCSA_FB_RC: PC4617.1 PR4632.1
PWR_VCCSA_FCCM: PU4601.29 PU5001.7
PWR_VCCSA_IMON: PC4629.2 PR4644.1 PU4601.23
PWR_VCCSA_ISUMN: PC4603.2 PC4605.1 PR4611.1 PR4613.1 PR4615.1 PR4618.2 PR4620.1 PR5004.2
PWR_VCCSA_ISUMN_P_1: PC4608.2 PR4613.2
PWR_VCCSA_ISUMN_P_2: PR4611.2 PR4625.2
PWR_VCCSA_ISUMN_R: PG5001.1 PR5004.1
PWR_VCCSA_ISUMN_RC: PC4611.2 PR4615.2
PWR_VCCSA_ISUMNB: PC4611.1 PR4620.2 PU4601.28
PWR_VCCSA_ISUMP: PC4605.2 PC4608.1 PR4618.1 PR4625.1 PR5003.2 PU4601.27
PWR_VCCSA_ISUMP_R: PG5011.1 PR5003.1
PWR_VCCSA_PWM: PU4601.30 PU5001.3
PWR_VCCSA_RTN: PC4613.1 PC4616.1 PR4602.1 PR4627.2 PU4601.26
PWR_VCCSA_SW: PC5005.2 PG5011.2 PL5001.1 PU5001.8 PU5002.1 PU5002.2 PU5002.3 PU5003.5 PU5003.6 PU5003.7 PU5003.8
PWR_VCORE_ALERT#: PR4623.2 PU4601.36
PWR_VCORE_BOOT: PR4705.2 PU4701.5
PWR_VCORE_BOOT_RC: PC4707.1 PR4705.1
PWR_VCORE_BOOTR: PC4707.2 PU4701.7
PWR_VCORE_COMP: PC4639.1 PR4656.1 PU4601.16
PWR_VCORE_COMP1: PC4640.1 PR4656.2
PWR_VCORE_FB: PR4657.1 PR4658.1 PR4660.1 PU4601.17
PWR_VCORE_FB1: PC4641.1 PR4657.2
PWR_VCORE_FB2: PC4642.2 PC4643.2 PC4644.1 PR4660.2 PR4663.2 PR4667.2
PWR_VCORE_FB_RC: PC4643.1 PR4658.2
PWR_VCORE_FCCM#: PR4706.2 PU4601.21
PWR_VCORE_FCCM#_R: PR4706.1 PU4701.2
PWR_VCORE_IMON: PC4638.1 PR4661.1 PU4601.14
PWR_VCORE_ISUMN: PC4631.1 PC4634.1 PR4648.2 PR4649.2 PR4650.1 PR4651.2 PR4652.2 PR4701.2
PWR_VCORE_ISUMN_G: PG4708.1 PR4701.1
PWR_VCORE_ISUMN_P_1: PC4635.1 PC4652.1 PR4649.1
PWR_VCORE_ISUMN_P_2: PR4650.2 PR4653.2
PWR_VCORE_ISUMN_RC: PC4632.1 PR4651.1
PWR_VCORE_ISUMNA: PC4632.2 PR4648.1 PU4601.20
PWR_VCORE_ISUMP: PC4634.2 PC4635.2 PC4652.2 PR4652.1 PR4653.1 PR4708.2 PU4601.19
PWR_VCORE_ISUMP_G: PG4707.1 PR4708.1
PWR_VCORE_NTC: PR4662.1 PU4601.15
PWR_VCORE_NTC1: PR4654.1 PR4655.2 PR4662.2
PWR_VCORE_PROG1: PR4629.1 PU4601.32
PWR_VCORE_PROG2: PR4628.1 PU4601.31
PWR_VCORE_PWM: PR4702.2 PU4601.22
PWR_VCORE_PWM_R: PR4702.1 PR4712.1 PU4701.1
PWR_VCORE_RTN: PC4637.1 PC4642.1 PR4659.2 PR4668.2 PU4601.18
PWR_VCORE_SCLK: PR4624.2 PU4601.37
PWR_VCORE_SDIO: PR4622.2 PU4601.35
PWR_VCORE_SNB: PC4706.1 PR4703.2
PWR_VCORE_SW: PG4707.2 PL4701.1 PR4703.1 PU4701.16 PU4701.17 PU4701.18 PU4701.19 PU4701.20 PU4701.21 PU4701.22 PU4701.23 PU4701.24 PU4701.25 PU4701.26
PWR_VCORE_VCC: PC4607.1 PR4610.2 PU4601.34
PWR_VCORE_VCC_R: PC4708.1 PR4704.1 PU4701.3
PWR_VCORE_VIN: PC4606.1 PR4612.2 PU4601.33
PWR_VCORE_VRHOT#: PR4607.2 PU4601.38
PWR_VDDQ: PC5104.1 PC5105.1 PC5107.1 PC5109.1 PG5106.1 PG5107.1 PG5108.1 PG5109.1 PG5111.1 PG5113.2 PG5115.1 PL5101.2
PWR_VDDQ_BOOT: PR5111.1 PU5101.27
PWR_VDDQ_BOOTA: PC5114.2 PR5111.2
PWR_VDDQ_BOOTB: PC5114.1 PU5101.25
PWR_VDDQ_CS: PR5102.2 PU5101.10
PWR_VDDQ_EN: PR5105.2 PU5101.6
PWR_VDDQ_FB: PR5101.1 PR5107.2 PU5101.3
PWR_VDDQ_PG: PR5104.2 PR5109.2 PU5101.8
PWR_VDDQ_PH: PL5101.1 PR5110.1 PU5101.17 PU5101.18 PU5101.19 PU5101.20 PU5101.35
PWR_VDDQ_SNB: PC5118.1 PR5110.2
PWR_VDDQ_TON: PR5103.2 PU5101.7
PWR_VDDQ_VCC: PC5108.1 PR5102.1 PR5108.2 PU5101.9
PWR_VDDQ_VDDQ: PG5113.1 PR5107.1 PU5101.2
PWR_VDDQ_VLDOIN: PC5122.1 PG5110.2 PG5116.2 PU5101.28
PWR_VDDQ_VTT: PC5117.1 PC5124.1 PG5120.2 PG5121.2 PU5101.29 PU5101.31
PWR_VDDQ_VTTREF: PC5113.1 PU5101.1
PWR_VGA_CORE_BOOT1: PR8506.1 PU8514.1
PWR_VGA_CORE_BOOT1_1: PC8509.1 PR8506.2
PWR_VGA_CORE_BOOT2: PR8509.1 PU8514.15
PWR_VGA_CORE_BOOT2_1: PC8517.1 PR8509.2
PWR_VGA_CORE_EN: C8501.2 D8602.A PC8526.2 PR8522.2 PR8523.2 PU8514.3 R8529.1 R8546.2
PWR_VGA_CORE_LGATE1: PR8508.1 PU8510.8 PU8512.8 PU8514.19
PWR_VGA_CORE_LGATE2: PU8514.17 PU8515.8 PU8516.8
PWR_VGA_CORE_PHASE1: PC8509.2 PL8508.1 PR8501.1 PU8510.9 PU8512.9 PU8514.20
PWR_VGA_CORE_PHASE2: PC8517.2 PL8509.1 PR8513.1 PU8514.16 PU8515.9 PU8516.9
PWR_VGA_CORE_PSI: PC8522.2 PR8515.2 PR8516.2 PR8517.1 PU8514.4
PWR_VGA_CORE_REFADJ: PR8511.1 PU8514.6
PWR_VGA_CORE_REFIN: PC8521.1 PR8512.1 PR8514.1 PU8514.7
PWR_VGA_CORE_REFIN_R: PR8514.2 PR8561.2
PWR_VGA_CORE_RGND: PC8514.1 PC8519.2 PC8521.2 PC8524.2 PC8525.1 PR8520.1 PR8521.1 PR8561.1 PU8514.10
PWR_VGA_CORE_SS: PC8518.1 PR8526.1 PR8527.1 PR8577.1
PWR_VGA_CORE_SS/VSEN: PR8526.2 PR8576.2 PU8514.11
PWR_VGA_CORE_TON: PR8504.2 PU8514.9
PWR_VGA_CORE_TON_1: PC8507.2 PR8503.2 PR8504.1
PWR_VGA_CORE_UGATE1: PU8510.1 PU8512.1 PU8514.2
PWR_VGA_CORE_UGATE2: PU8514.14 PU8515.1 PU8516.1
PWR_VGA_CORE_VID: PC8510.2 PR8507.2 PU8514.5
PWR_VGA_CORE_VREF: PC8514.2 PR8510.1 PU8514.8
PWR_VGA_CORE_VREF_R: PC8519.1 PR8510.2 PR8511.2 PR8512.2
PWR_VGA_CORE_VSNS: PC8523.1 PC8524.1 PR8518.2 PR8519.1 PR8525.2 PR8576.1
PWR_VGA_CORE_VSNS/SS: PR8525.1 PR8527.2 PU8514.12
PWR_VGA_NVVDD_OR: Q8504.D R8546.1
PWR_VGA_NVVDD_OR#: Q8504.G Q8509.3 Q8509.6 Q8605.G R8541.2
PWR_VGA_NVVDD_PG: C8630.1 PR8505.2 PU8514.13 R8532.1 R8638.2 R8650.1
PWR_VGA_NVVDD_PG#: Q8607.5 Q8607.6 R8640.2
PWR_VGA_NVVDD_PG_OR: Q8606.2 R8638.1
PWR_VGA_S0_PG: PR8623.1 PR8625.2 PU8603.2
PWR_VGA_SNUB1: PC8508.1 PR8501.2
PWR_VGA_SNUB2: PC8520.1 PR8513.2
PWR_VTT_EN: PR5106.2 PU5101.5
Q501_G: Q501.G Q502.D R507.1
Q4009_G: Q2705.G R2737.2 R2740.2
Q6204_G: Q6503.2 Q6503.5 R6512.2
Q6205_Q: Q6505.D R6522.2
Q7601_G: Q7901.2 Q7901.5 R7957.2
RESET_OUT#: ED1703.2 Q4001.3 R1706.1 R2617.1 U2401.73
RESET_OUT#_G: Q2602.G R2616.2 R2617.2
RING2_HPMIC1: AUD1.3 ED2908.1 R2906.2
RSMRST_PWRGD#: D4002.K R4029.2 R4030.2 R4031.2 R4032.2 R4033.2
RT8812_PVCC: PC8506.1 PR8502.2 PU8514.18
RTC_3P3_EN_G: C2517.1 D2502.A Q2510.G R2567.2
RTC_AUX_S5: Q2507.D R1730.1 R2204.1 R2505.2 R2512.2 RN1801.1(A) RN1801.2(A)
RTC_DET#: CPU1.CP22 Q2501.D R1519.1 R1554.2
RTC_RST#: C1806.1 CPU1.BR34 ED1801.1 G1801.2 Q1802.D RN1801.4(B) TP9953.1
RTCRST_ON: D2502.K EC1804.1 Q1802.G Q2507.G R1816.1 R2518.1 R2567.1 U2401.31
RUNPWROK: R2421.2 U2401.48
SATA_LED#: CPU1.CN7 D6401.1 R1606.2 R6408.1
SATA_LED#_D: D6401.3 Q6401.S R6408.2
SD_RCOMP: CPU1.CK33 CPU1.CM34 R1901.1
SENSOR_DB_DET#: CPU1.BW36 R1912.1 R1913.2
SENSOR_I2C_SCL: R2020.2 R7013.1 SBD1.6
SENSOR_I2C_SCL_2G: IOBD1.2 R7013.2 U7001.1
SENSOR_I2C_SDA: R2021.2 R7014.1 SBD1.7
SENSOR_I2C_SDA_2G: IOBD1.3 R7014.2 U7001.4
SIO_EXT_SCI#: CPU1.CR8 R1608.2
SIO_EXT_SMI#: CPU1.CP7 R402.1
SIO_EXT_WAKE#: CPU1.CN12 R2041.2 U2401.116
SIO_PWRBTN#: CPU1.BU28 TP1714.1 U2401.52
SIO_RCIN#: CPU1.BV29 R1820.2
SIO_SLP_A#: CPU1.BU37 TP1713.1 TP9951.1
SKTOCC#: CPU1.E1 TP619.1
SLEEVE_R: AUD1.4 ED2912.1 R2911.2
SM_DRAMRST#: DM1.108 DM2.108 ED1217.1 ED1302.1 R504.2
SM_DRAMRST#_CPU: CPU1.BU31 ED502.1 ED502.2 R504.1 R505.2
SM_INTRUDER#: CPU1.BR35 R1730.2
SM_PGCNTL: CPU1.C35 Q502.G
SM_PGCNTL_R: PR5106.1 Q501.D R506.2
SM_RCOMP_0: CPU1.BN28 R501.1
SM_RCOMP_1: CPU1.BN27 R502.1
SM_RCOMP_2: CPU1.BN29 R503.1
SMBC_THERM_NV: GPU1.D9 Q7901.1 RN7901.1(A)
SMBD_THERM_NV: GPU1.D8 Q7901.4 RN7901.2(A)
SPI_CLK_CPU: CPU1.CH37 R1814.2
SPI_CLK_ROM: R1814.1 R2568.2 R9138.1
SPI_CLK_ROM_R: R2568.1 SKT251.6 U2501.6
SPI_CLK_ROM_TPM: R9138.2 U9101.19
SPI_CS2#_IC: R9122.2 R9130.2 R9140.2 R9148.2 U9101.20
SPI_CS_ROM_N0: CPU1.CG36 R2501.2 SKT251.1 U2501.1
SPI_CS_ROM_N2: CPU1.CH34 R9130.1
SPI_HOLD_CPU: CPU1.CG34 R1845.2
SPI_HOLD_ROM: R1510.1 R1511.1 R1845.1 R2570.2
SPI_HOLD_ROM_R: R2570.1 RN2501.2(A) SKT251.7 U2501.7
SPI_IRQ#_TPM2: R9152.1 R9153.2 R9154.1 U9101.18
SPI_SI_CPU: CPU1.CF36 R1823.2
SPI_SI_ROM: R1506.2 R1507.1 R1823.1 R2569.2 R9133.1
SPI_SI_ROM_R: R2569.1 SKT251.5 U2501.5
SPI_SI_ROM_TPM: R9133.2 U9101.21
SPI_SO_CPU: CPU1.CF37 R1819.2
SPI_SO_ROM: R1819.1 R2507.1 R9132.1
SPI_SO_ROM_R: R2507.2 SKT251.2 U2501.2
SPI_SO_ROM_TPM: R9132.2 U9101.24
SPI_WP_CPU: CPU1.CF34 R1824.2
SPI_WP_ROM: R1508.1 R1509.1 R1824.1 R2571.2
SPI_WP_ROM_R: R2571.1 RN2501.1(A) SKT251.3 U2501.3
SPKR: CPU1.CF35 R1501.2 R2741.1
SRTC_RST#: C1805.1 CPU1.BR37 ED1801.2 RN1801.3(B)
SSD_CLK_CPU_N: CPU1.BA1 SSD1.53
SSD_CLK_CPU_P: CPU1.BA2 SSD1.55
SSD_CLKREQ_CPU_N: CPU1.CE30 ED7307.1 RN1813.6(B) SSD1.52
SSD_DEVSLP: CPU1.CM8 R6301.1 R6303.2 R6304.1
SSD_DEVSLP_R: AFTP6301.1 R6301.2 SSD1.38
SSD_LED#: D6401.2 R6402.2 SSD1.10
SSD_PCIE_RX_N1: CPU1.BK6 SSD1.5
SSD_PCIE_RX_N2: CPU1.BJ6 SSD1.17
SSD_PCIE_RX_N3: CPU1.BG5 SSD1.29
SSD_PCIE_RX_P1: CPU1.BK5 SSD1.7
SSD_PCIE_RX_P2: CPU1.BJ5 SSD1.19
SSD_PCIE_RX_P3: CPU1.BG6 SSD1.31
SSD_PCIE_TX_CON_N1: C6312.1 SSD1.11
SSD_PCIE_TX_CON_N2: C6314.1 SSD1.23
SSD_PCIE_TX_CON_N3: C6316.1 SSD1.35
SSD_PCIE_TX_CON_P1: C6311.1 SSD1.13
SSD_PCIE_TX_CON_P2: C6313.1 SSD1.25
SSD_PCIE_TX_CON_P3: C6315.1 SSD1.37
SSD_PCIE_TX_N1: C6312.2 CPU1.BM4
SSD_PCIE_TX_N2: C6314.2 CPU1.BL2
SSD_PCIE_TX_N3: C6316.2 CPU1.BL4
SSD_PCIE_TX_P1: C6311.2 CPU1.BM3
SSD_PCIE_TX_P2: C6313.2 CPU1.BL1
SSD_PCIE_TX_P3: C6315.2 CPU1.BL3
SSD_SATA_C_TX_N: C6303.2 R6313.1 R6317.1
SSD_SATA_C_TX_P: C6302.2 R6314.1 R6318.1
SSD_SATA_RX_CON_N: ED6301.2 ED6301.9 R6311.1 R6316.1 SSD1.43
SSD_SATA_RX_CON_P: ED6301.1 ED6301.10 R6312.1 R6315.1 SSD1.41
SSD_SATA_RX_N: CPU1.BE5 R6311.2
SSD_SATA_RX_N1: CPU1.BL6 R6316.2
SSD_SATA_RX_P: CPU1.BE6 R6312.2
SSD_SATA_RX_P1: CPU1.BL5 R6315.2
SSD_SATA_TX_CON_N: C6303.1 ED6301.4 ED6301.7 SSD1.47
SSD_SATA_TX_CON_P: C6302.1 ED6301.5 ED6301.6 SSD1.49
SSD_SATA_TX_N: CPU1.BJ4 R6317.2
SSD_SATA_TX_N1: CPU1.BN2 R6313.2
SSD_SATA_TX_P: CPU1.BJ3 R6318.2
SSD_SATA_TX_P1: CPU1.BN1 R6314.2
SSD_SCP#: R2430.2 R2490.2 U2401.21
SSD_SCP#_M2: R2430.1 SSD1.8
SSEQ0_A0: R7323.2 R7324.1 U7301.11
SSEQ1: R7322.1 R7327.2 U7301.3
STRAP0: GPU1.D1 R7908.1 R7919.2
STRAP1: GPU1.D2 R7909.2 R7911.1
STRAP2: GPU1.E4 R7914.2 R7915.1
STRAP3: GPU1.E3 R7925.2 R7926.1
STRAP4: GPU1.D3 R7928.2 R7929.1
STRAP5: GPU1.C1 R7976.2
STRAP5_L: R7938.2 R7939.1 R7976.1
STRAP_REF0_GND_N9: GPU1.F6 R7907.2
SUS_CLK: CPU1.BT32 EC1803.2 FC1801.2 R2428.2 R6135.1
SUSACK#_R: CPU1.BY32 R1708.2
SUSCLK_WLAN: R6135.2 WLAN1.50
SVID_ALERT#_CPU: PR4605.2 PR4623.1 R727.2 R728.1
SVID_ALERT#_CPU_R: CPU1.AA3 R728.2
SVID_CLK_CPU: PR4606.2 PR4624.1 R723.2 R732.2
SVID_CLK_CPU_R: CPU1.AA1 R732.1
SVID_DATA_CPU: PR4604.2 PR4622.1 R709.2
SVID_DATA_CPU_R: CPU1.AA2 R709.1 R726.2
SYS_LED_MASK#: C2430.1 R2403.2 R2404.1 R2431.1 U2401.55
SYS_LED_MASK#_R: R2431.2 R2497.1 R6419.1 U6402.2
SYS_PEX_RST_MON#: D7601.2 R7604.2 R7606.1 R7613.1 R7943.1 R7974.2 U7601.4
SYS_PEX_RST_MON_GPU#: GPU1.E9 R7974.1
SYS_PRES1#: AFTP4315.1 BATT1.7 R4301.2
SYS_PWROK: CPU1.CR10 ED1702.1 R1717.1 U2401.28
SYSPWR_PRES: R2453.2 R2455.1 U2401.120
T_CRIT#: R2601.1 R2604.2 THM261.4
TBTA_SENSEN: R7235.2 U7204.A10
TBTA_SENSEP: R7234.2 U7204.B10
TESTMODE: GPU1.AD9 R7602.1
THERM_SYS_SHDN#: Q2602.S R2601.2 R2602.1
THERMTRIP#_CPU: CPU1.BJ1 ED301.1 R308.2
THM_SML1_CLK: C2608.1 Q2601.4 RN2602.4(B) THM261.8
THM_SML1_DATA: C2609.1 Q2601.1 RN2602.3(B) THM261.7
TOP_MUX_N: ED7304.2 EL7301.2 USB1.A7
TOP_MUX_N_L: EL7301.1 U7204.L6
TOP_MUX_P: ED7304.1 EL7301.3 USB1.A6
TOP_MUX_P_L: EL7301.4 U7204.K6
TOUCH_DETECT: CPU1.CN14 R2119.2 R2120.1
TOUCH_PAD_INTR#: CPU1.CB34 R303.2 R319.2
TOUCH_PANEL_INTR#: CPU1.CN3 R5537.1 R5551.2 R5553.2
TOUCH_PANEL_PD#: CPU1.CC35 R5538.1
TOUCH_REPORT_SW: D2402.A LCD1.34
TP_EN#: R6516.1 RN2405.2(A) U2401.49
TP_LOCK#: AFTP6526.1 D2405.A R6509.1 TPAD1.3
TP_ON#_GATE: C6503.2 Q6504.G Q6505.G R6516.2
TP_RESET: C5540.1 EC5505.1 EC5505.10 LCD1.35 R5538.2
TP_RS: C5541.1 EC5505.2 EC5505.9 LCD1.36 R5537.2
TP_WAKE_KBC#: AFTP6525.1 R319.1 R6502.1 TPAD1.4 U2401.33
TPCLK_C: AFTP6530.1 RN6503.4(B) TPAD1.1
TPDATA_C: AFTP6524.1 RN6503.3(B) TPAD1.2
TPM_GPIO0: R9121.1 U9101.29
TPM_GPIO1: TP9102.1 U9101.30
TPM_GPIO2: R9120.1 U9101.3
TPM_GPIO3: TP9101.1 U9101.6
TPM_GPIO4: R9122.1 U9101.13
TPM_ID: CPU1.CK25 R1910.2 R1911.1
TPM_PP: TP9104.1 U9101.7
TPM_SPI_IRQ#: CPU1.CF20 R9154.2
TS#_DIMM0_1: DM1.134 R1215.2
TS#_DIMM1_1: DM2.134 R1312.2
TYPEC_DCIN_EN#: Q7406.2 Q7407.2 R7428.1 U2401.63
TYPEC_SMBCLK: Q2417.1 R2468.1 RN2413.4(B) U2401.91
TYPEC_SMBCLK_Q: Q2417.6 R2468.2 R7218.1 U7204.B5
TYPEC_SMBDA: Q2417.4 R2467.1 RN2413.3(B) U2401.89
TYPEC_SMBDA_Q: Q2417.3 R2467.2 R7219.1 U7204.A5
U5503_OUT: R5548.1 R5558.2 R5559.2 R5560.1 U5502.5
UART1_CTS#: CPU1.CG14 TP2002.1
UART1_RTS#: CPU1.CF12 TP2001.1
UART_2_CRXD_DTXD: CPU1.CR12 R2048.2 R6803.1
UART_2_CRXD_DTXD_CON: DBG1.14 R6803.2
UART_2_CTXD_DRXD: CPU1.CP12 R2049.2 R6802.1
UART_2_CTXD_DRXD_CON: DBG1.13 R6802.2
UPD1_SMBINT#: R7238.1 R7239.2 U2401.32
USB1_CC1: C7220.1 ED7306.2 R7225.2 U7204.L9 USB1.A5
USB1_CC2: C7221.1 ED7306.1 R7224.2 U7204.L10 USB1.B5
USB1_PN1_R: EL3501.1 R3608.1 U3601.11
USB1_PP1_R: EL3501.4 R3607.1 U3601.10
USB1_SBU1: ED7303.2 R7308.1 U7301.27 USB1.A8
USB1_SBU2: ED7303.1 R7309.1 U7301.26 USB1.B8
USB1_SSRX_C_N1: C7332.1 U7301.31
USB1_SSRX_C_N2: C7334.1 U7301.39
USB1_SSRX_C_P1: C7331.1 U7301.30
USB1_SSRX_C_P2: C7333.1 U7301.40
USB1_SSRX_CMC_N1: C7332.2 R7313.1
USB1_SSRX_CMC_N2: C7334.2 R7315.1
