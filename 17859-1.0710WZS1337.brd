# Allegro board 17859-1.0710WZS1337.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BATT_WHITE_LED#: length 110.4
  TOP w0.089: Q6402.3 22.76,99.51 R6404.1 22.88,99.22 22.45,98.79 22.45,97.48 v2(22.55,97.39) 22.55,96.99 22.08,96.52 18.99,96.52 18.26,95.79 v1(18.26,94.57) ; v1(56.23,33.68) 56.02,33.9 Q2412.6
  L3 w0.089: v1(18.26,94.57) 18.31,94.52 19.09,94.52 19.53,94.08 19.53,89.01 18.59,88.07 18.59,86.79 20.16,85.23 20.16,83.33 19.1,82.28 19.1,80.79 22.26,77.63 22.26,74.49 20.64,72.88 20.64,69.83 19.98,69.17 19.98,68.53 18.87,67.42 18.87,63.86 18.43,63.43 18.43,56.29 19.45,55.27 19.45,54.03 18.08,52.66 18.08,50.24 19.45,48.87 19.45,43.77 21.48,41.73 v1(21.48,41.68)
  L4 w0.089: v1(30.17,38.56) 29.82,38.21 25.74,38.21 24.43,39.52 24.43,40.3 23,41.73 21.53,41.73 v1(21.48,41.68)
  BOTTOM w0.089: v1(30.17,38.56) 30.23,38.5 35.31,38.5 35.66,38.15 37.54,38.15 39.87,35.82 42.06,35.82 42.26,36.02 47.34,36.02 47.39,36.07 48.71,36.07 48.79,35.99 49.55,35.99 51.38,34.17 55.75,34.17 v1(56.23,33.68)
BATT_WHITE_LED_R#: length 20.2
  TOP w0.089: v1(13.43,96.09) 13.67,96.33 13.67,96.34 13.69,96.37 13.69,96.88 14.01,97.2 15.51,97.2 17.81,99.51 Q6402.4 20.54,99.93 23.3,99.93 23.74,99.48 R6404.2 24.12,99.39 24.4,99.12 Q6401.D
  BOTTOM w0.089: v1(13.43,96.09) 13.43,96.11 14.05,96.73 v2(14.4,96.73) 14.57,96.55 14.57,94.95 15.26,94.26 16.28,94.26 16.51,94.5 Q6404.B
BEEP: length 43.9
  TOP w0.203: U2401.45 40.78,50.06 v1(40.2,49.48)
  BOTTOM w0.254: v1(40.2,49.48) 39.86,49.48 39.07,50.27 36.7,50.27 34.41,47.98 31.77,47.98 30.88,48.87 30.06,48.87 29.71,48.52 29.71,47.96 28.36,46.6 28.36,43.07 23.78,38.49 23.56,38.49 22.65,37.58 22.65,37.26 22.24,36.86 22.24,34.19 22.52,33.91 22.6,33.91 22.7,33.81 22.8,33.81 23.9,32.72 v2(23.9,32.57) 26,32.57 27.15,31.42 27.15,26.77 26.79,26.42 R2734.1
BKLT_CTRL: length 11.1
  BOTTOM w0.114: v2(43.63,84.25) 44.09,83.8 44.09,83.49 44.24,83.34 RN5502.1 44.55,83.42 R5524.2 45.49,84.15 47.37,84.15 47.93,84.72 47.93,85.74 48.18,85.98 D5503.3 49.47,86.4 48.97,86.9 48.69,86.9 48.2,87.38 RN5503.1
BKLT_IN_EC: length 18.8
  TOP w0.102: U2401.67 30.69,48.91 30.19,49.41 29.79,49.41 v1(29.76,49.38) ; R2401.1 24.23,38.12 24.79,38.12 25.2,37.71 v2(25.66,37.71) 26,37.71 27,38.72 28.46,38.72 v1(28.51,38.67)
  L3 w0.102: v1(29.76,49.38) 29.76,48.92 29.15,48.31 29.15,47.2 28.7,46.75 28.7,44.96 28.85,44.81 28.85,39.77 28.87,39.74 28.87,39.07 28.51,38.7 v1(28.51,38.67)
BLON_OUT: length 63
  L3 w0.102: v1(38.32,81.97) 38.32,81.16 36.98,79.81 36.98,75.85 37.1,75.72 37.1,75.72 37.31,75.52 37.31,74.25 34.23,71.17 34.23,67.36 34.31,67.29 34.31,66.88 34.23,66.8 34.23,64.9 34.39,64.75 34.39,60.45 34.23,60.3 34.23,59.46 34.84,58.85 34.84,55.98 34.64,55.78 34.64,51.01 35.3,50.35 35.3,49.69 34.44,48.82 34.44,48.8 34.18,48.54 34.18,45.45 v1(34.74,44.9)
  L6 w0.102: v1(38.32,81.97) 37.45,82.84 37.45,83.96 37.71,84.21 38.28,84.21 40.27,82.22 42.36,82.22 v1(42.82,81.77)
  BOTTOM w0.102: v1(42.82,81.77) 42.41,82.17 RN5504.1 ; D2401.3 25.46,39.16 v2(25.61,39.31) 26.66,40.36 27.71,40.36 32.19,44.85 32.84,44.85 33.36,45.37 34.28,45.37 34.51,45.14 34.51,45.12 v1(34.74,44.9)
BLON_OUT_C: length 19.6
  L6 w0.102: v1(45.23,83.31) 44.19,83.31 43.07,84.43 42.64,84.43 42.02,83.81 v1(42.02,83.8)
  BOTTOM w0.102: v1(45.23,83.31) 45.23,83.37 45.66,83.8 48.61,83.8 50.06,85.25 50.06,86.67 v2(49.67,87.06) 49.67,88.1 49.17,88.6 49.17,90.05 49.32,90.2 49.32,90.66 48.56,91.42 LCD1.22 ; RN5502.7 43.2,82.75 43.12,82.83 42.48,82.83 RN5504.4 42.23,83.58 v1(42.02,83.8)
BLUETOOTH_EN: length 163.1
  TOP w0.102: D6101.K 201.67,57.71 201.87,57.51 R6113.2 203.1,58.2 v2(203.47,58.2) v1(204.21,58.2)
  L6 w0.102: v1(218.74,29.97) 218.63,30.09 218.63,31.84 217.32,33.15 217.32,33.25 216.99,33.58 213.35,33.58 212.3,34.62 207.82,34.62 205.3,37.14 198.94,37.14 197.35,38.72 197.35,39.5 196.03,40.82 184.09,40.82 183.48,41.43 181.15,41.43 174.28,48.3 170.13,48.3 170.12,48.29 168.98,48.29 168.65,48.62 161.64,48.62 160.12,50.14 158.45,50.14 158.05,49.73 152.9,49.73 144.7,57.93 144.7,64.28 142.48,66.51 142.48,67.21 140.84,68.85 140.84,71.56 139.96,72.44 135.2,72.44 132.6,75.04 v1(132.38,75.04)
  BOTTOM w0.076: 131.52,75.59 131.01,75.59 130.45,75.73 130.39,75.79 130.29,75.79 130.13,75.81 130.1,75.84 129.87,75.87 129.84,75.87 129.77,75.89 129.75,75.89 129.73,75.92 129.7,75.93 CPU1.CP14
  BOTTOM w0.102: v1(204.21,58.2) 205.55,58.2 206.81,56.94 215.24,56.94 216.77,55.41 217.73,55.41 221,52.15 221,32.67 219.3,30.97 219.3,30.58 218.76,30.05 218.76,30 v1(218.74,29.97) ; 131.52,75.59 132.07,75.04 v1(132.38,75.04) 132.75,75.04 R2109.2
BLUETOOTH_EN_R: length 6.7
  TOP w0.102: v1(200.99,55.36) 200.81,55.17 AFTP6107.1 200.27,55.98 200.68,56.39 D6101.A 201.62,56.64 R6113.1 202.69,56.64 202.91,56.42 R6102.2
  BOTTOM w0.102: v1(200.99,55.36) 200.46,54.82 WLAN1.54
BMON22: length 158.9
  TOP w0.254: PR4493.2 156.13,9.45 155.16,10.42 155.16,10.82 154.88,11.1 154.88,11.84 154.1,12.63 154.1,14.43 154.3,14.63 154.3,16.26 v2(154.22,16.33) 154.03,16.53 v1(154.03,17.76) ; v1(28.8,33.86) 28.82,33.84 R2483.2
  L3 w0.254: v1(28.8,33.86) 28.8,29.49 28.65,29.34 28.65,28.88 28.92,28.6 29.79,28.6 30.75,27.64 36.93,27.64 38.55,26.02 38.55,20.91 39.64,19.81 v1(39.64,18.32)
  L4 w0.254: v1(55.04,17.85) 56.56,16.33 59.05,16.33 60.62,14.76 62.02,14.76 62.07,14.71 65.73,14.71 67.43,13.01 69.87,13.01 70.9,11.98 73.72,11.98 73.88,12.14 75.58,12.14 76.64,11.09 89.94,11.09 90.01,11.15 93.29,11.15 94.66,12.52 98.6,12.52 98.9,12.83 101.98,12.83 103.4,14.24 103.4,14.87 103.77,15.24 107.69,15.24 110.51,18.06 134.72,18.06 135.12,17.66 136.29,17.66 137.28,18.65 153.2,18.65 154.03,17.82 v1(154.03,17.76)
  L6 w0.254: v1(55.04,17.85) 54.72,17.53 51.76,17.53 50.26,19.03 40.35,19.03 v1(39.64,18.32)
BOARD_ID: length 2.9
  TOP w0.102: U2401.111 38.78,35.28 38.32,34.83 38.09,34.83 v2(37.87,34.6) 37.66,34.39 R2474.1
BOARD_ID1: length 5.5
  TOP w0.102: R2010.2 128.65,79.56 R2009.1 127.86,78.77 127.1,78.77 v2(126.87,78.54) 126.84,78.54 126.64,78.34 125.48,78.34 v1(125,77.85)
  BOTTOM w0.089: v1(125,77.85) 125,77.69 CPU1.CG12
BOARD_ID2: length 8.7
  TOP w0.102: v2(128.87,72.42) 128.98,72.42 129.03,72.37 129.66,72.37 R2005.2 129.76,73.38 R2008.1 130.17,73.79 130.52,73.79 131.09,74.35 131.34,74.35 v1(131.72,74.73)
  BOTTOM w0.076: 130.45,75.49 130.32,75.62 130.28,75.62 130.01,75.66 129.95,75.66 129.74,75.73 129.65,75.73 128.52,75.79 CPU1.CM14
  BOTTOM w0.102: v1(131.72,74.73) 131.72,75.01 131.36,75.37 131.12,75.41 130.53,75.41 130.45,75.49
BOARD_ID_R: length 2.7
  TOP w0.102: R2444.1 38.07,31.71 C2408.2 37.87,31.91 R2443.2 37.23,32.31 R2474.2
BOT_MUX_N: length 9.4
  TOP w0.102: v2(9.93,88.42) 10.05,88.55 v1(10.84,88.55) 11.3,89 12.24,89 12.26,89.03 ED7305.1
  L6 w0.089: USB1.B7 6.22,88.9 8.44,88.9 8.92,88.42 10.26,88.42 10.36,88.52 10.79,88.52 10.81,88.55 v1(10.84,88.55)
  BOTTOM w0.102: v1(10.84,88.55) 11.17,88.88 EL7302.3
BOT_MUX_N_L: length 83.1
  TOP w0.102: 72.87,107.53 72.68,107.53 72.45,107.76 72.45,108.04 72.13,108.36 v1(71.88,108.36) ; 72.87,107.53 74.97,107.53 75.43,107.07 75.43,105.04 75.91,104.56 75.91,102.86 76.37,102.41 76.37,102.21 76.51,102.07 U7204.L7 ; 72.87,107.53 v2(72.87,107.37)
  L6 w0.089: v1(14.4,88.8) 14.4,89.01 14.02,89.38 13.88,89.38 13.61,89.65 13.61,92.28 15.23,93.91 15.23,94.8 19.63,99.19 23.67,99.19 23.96,99.48 33.18,99.48 33.8,98.86 35.94,98.86 36.35,99.27 61.92,99.27 68.35,105.69 68.35,106.57 69.64,107.86 71.9,107.86 71.98,107.94 71.98,108.26 v1(71.88,108.36)
  BOTTOM w0.102: v1(14.4,88.8) 14.01,89.18 13.24,89.18 12.93,88.88 12.67,88.88 12.67,88.88 EL7302.4
BOT_MUX_P: length 8.9
  TOP w0.102: 11.55,89.23 12.11,89.23 12.31,89.44 ED7305.2 ; 11.55,89.23 v2(11.55,89.44) ; 11.55,89.23 10.8,89.23 v1(10.76,89.19)
  L6 w0.089: v1(10.76,89.19) 10.18,88.61 9,88.61 8.51,89.1 6.22,89.1 USB1.B6
  BOTTOM w0.102: v1(10.76,89.19) 11.21,89.64 11.81,89.64 EL7302.2
BOT_MUX_P_L: length 82.8
  TOP w0.089: 76.75,101.94 76.75,101.51 U7204.K7
  TOP w0.102: v2(75.43,107.62) 75.32,107.51 ; 75.32,107.51 75.07,107.76 72.78,107.76 72.68,107.86 72.68,108.3 v1(72.74,108.36) ; 75.32,107.51 75.66,107.17 75.66,105.13 76.14,104.65 76.14,102.96 76.6,102.5 76.6,102.3 76.75,102.15 76.75,101.94
  L6 w0.089: v1(72.74,108.36) 72.69,108.36 72.19,107.86 72.17,107.86 71.98,107.67 69.72,107.67 68.54,106.49 68.54,105.61 62,99.08 36.43,99.08 36.01,98.67 33.72,98.67 33.1,99.29 24.04,99.29 23.75,99 19.71,99 15.42,94.72 15.42,93.83 13.8,92.2 13.8,89.73 13.96,89.57 14.3,89.57 v1(14.4,89.66)
  BOTTOM w0.102: EL7302.1 12.67,89.64 13,89.64 13.23,89.41 14.14,89.41 v1(14.4,89.66)
BPM_CPU_N0: length 5.7
  BOTTOM w0.089: TP307.1 92.66,88.25 92.66,87.04 94.61,85.09 94.61,84.4 CPU1.U1
BPM_CPU_N1: length 5.8
  BOTTOM w0.089: CPU1.U2 94.43,83.93 94.43,84.94 92.42,86.95 92.42,87.99 TP308.1
BPM_CPU_N2: length 5.4
  BOTTOM w0.089: TP302.1 93.24,86.95 94.79,85.39 95.04,84.4 95.07,83.57 CPU1.U3
BPM_CPU_N3: length 5.8
  BOTTOM w0.089: TP303.1 94.18,84.91 94.18,83.78 94.43,83.53 94.44,83.39 94.49,82.85 CPU1.U4
BT+: length 45.4
  TOP w0.508: v1(154.73,12.98) 154.73,12.91 155.52,12.12 155.52,11.38 155.8,11.1 155.8,10.7 156.38,10.11 156.41,10.11 157.78,8.74 157.78,7.74 157.38,7.34 157.14,7.34 157.12,7.32 157.07,7.32 155.54,5.79 v1(155.04,5.79)
  L3 w0.508: v1(155.04,5.79) 154.86,5.97 154.14,5.97 153.56,5.39 153.56,4.27 153.05,3.76 126.92,3.76 v1(123.74,6.94)
  BOTTOM w0.406: PR4478.2 154.5,13.92 154.5,13.21 v1(154.73,12.98)
  vias: v3(120.44,14.81) v3(121.28,14.84) v3(122.3,14.84) v3(123.18,14.84)
BT_PCMFRM_CRF_RST_N: length 130.5
  TOP w0.102: R6134.1 R1923.1 143.05,63.12 v1(142.82,62.89)
  L6 w0.102: v1(218.05,30.91) 218.05,32.11 217.11,33.05 217.11,33.15 216.88,33.38 213.23,33.38 212.87,33.73 208.02,33.73 204.92,36.83 196.84,36.83 193.85,39.83 183.66,39.83 183.13,40.36 180.34,40.36 175.62,45.09 164.03,45.09 162.33,46.79 159.69,46.79 158.85,45.95 154.13,45.95 142.82,57.26 v1(142.82,62.89)
  BOTTOM w0.102: v1(218.05,30.91) 218.48,30.91 220.59,33.02 220.59,51.98 218.19,54.38 214.27,54.38 213.61,55.04 211.98,55.04 211.46,54.52 WLAN1.10 ; v2(142.21,63.32) 142.64,62.89 v1(142.82,62.89)
BT_PCMFRM_CRF_RST_N_R: length 25.5
  TOP w0.102: R1923.2 142.92,63.99 141.98,63.05 141.98,62.26 v1(142.13,62.1)
  L4 w0.102: v1(126.31,64.9) 126.77,64.44 128.77,64.44 130.51,62.7 133.59,62.7 135.53,64.65 141.65,64.65 142.21,64.08 142.21,62.18 v1(142.13,62.1)
  BOTTOM w0.102: v1(142.13,62.1) 142.79,62.1 v2(142.89,62) ; CPU1.CJ32 126.48,64.9 v1(126.31,64.9)
BT_PCMOUT_CLKREQ0: length 4.8
  TOP w0.102: v1(209.85,52.2) 209.65,52.4 v2(209.65,52.91) 210.08,52.91 210.56,52.43 R6133.1 R1922.1
  BOTTOM w0.102: v1(209.85,52.2) 209.85,52.3 210.46,52.91 WLAN1.14
BT_PCMOUT_CLKREQ0_R: length 137.9
  TOP w0.102: v1(213.3,47.02) 213.51,47.02 213.95,47.46 v2(213.95,48.17) 212.98,49.14 212.76,49.14 211.93,49.96 211.93,51.16 211.63,51.46 R1922.2
  L3 w0.102: v1(213.3,47.02) 213.3,46.03 214.04,45.29 214.04,38.56 214.8,37.8 214.8,35.38 216.68,33.51 v1(216.68,32.95)
  L6 w0.102: v1(216.68,32.95) 216.47,33.16 212.2,33.16 211.91,33.45 209.34,33.45 208.17,32.29 207.69,32.29 206.5,33.48 205.23,33.48 204.82,33.07 201.14,33.07 200.2,34.01 196.21,34.01 195.6,33.4 194.92,33.4 193.62,34.7 193.62,35.44 191.26,37.8 185.62,37.8 185.57,37.75 184.7,37.75 183.97,37.01 180.72,37.01 176.37,41.35 169.62,41.35 169.18,40.92 167.86,40.92 167.3,40.36 157.75,40.36 156.04,42.07 143.05,42.07 142.54,41.56 141.88,41.56 141.65,41.79 141.65,42.19 141.68,42.22 141.68,48.8 140.61,49.86 140.61,51.36 138.81,53.16 138.81,54.29 137.31,55.78 135.71,55.78 133.14,58.35 132.39,58.35 129.03,61.71 129.03,62.74 126.82,64.95 126.82,66.45 v1(126.35,66.92)
  BOTTOM w0.102: v1(126.35,66.92) 126.01,66.58 CPU1.CH29
BT_USB20_CON_N: length 8.6
  TOP w0.102: v1(212.62,63.21) 212.9,62.93 212.9,62.6 212.46,62.16 211.05,60.75 ; 211.05,60.75 210.45,60.15 209.22,60.15 208.94,60.43 R6110.1 ; 211.05,60.75 AFTP6109.1
  BOTTOM w0.102: WLAN1.5 212.71,62.2 212.98,62.47 212.98,63.11 212.88,63.21 v1(212.62,63.21)
BT_USB20_CON_P: length 8.7
  TOP w0.102: 212.51,61.89 213.13,62.51 213.13,62.93 v1(213.41,63.21) ; 212.51,61.89 210.54,59.92 209.21,59.92 208.93,59.64 R6111.1 ; 212.51,61.89 AFTP6110.1
  BOTTOM w0.102: WLAN1.3 213.21,63.02 v1(213.41,63.21)
BT_USB20_N: length 116
  TOP w0.102: 196.72,60.3 196.44,60.3 196.21,60.07 196.21,59.88 v1(195.9,59.57) ; 196.72,60.3 206.04,60.3 206.22,60.12 207.36,60.12 207.67,60.43 R6110.2 ; 196.72,60.3 v2(196.72,60.45)
  L4 w0.102: v1(123.02,89.86) 122.8,89.64 122.49,89.64 122.27,89.42 122.27,87.98 123.36,86.89 126.8,86.89 127.14,87.23 135.43,87.23 136.06,87.86 138.83,87.86 139.95,86.74 146.64,86.74 148.03,88.14 151.7,88.14 153.74,86.1 153.74,84.69 170.28,68.15 172.96,68.15 174.85,66.26 174.85,61.45 177.34,58.96 179.72,58.96 180.28,58.4 188.54,58.4 189.58,59.44 194.38,59.44 195.09,60.15 195.96,60.15 196.06,60.05 196.06,59.73 v1(195.9,59.57)
  BOTTOM w0.076: CPU1.CC3 122.82,83.16 122.81,83.16 122.71,83.39 122.65,83.53 122.66,83.69 122.69,83.84 122.69,84.04 122.66,84.2 122.66,84.39 122.65,84.61
  BOTTOM w0.102: 122.65,84.61 122.65,85.99 123.82,87.15 123.82,89.25 123.58,89.49 123.4,89.49 v1(123.02,89.86)
BT_USB20_P: length 116
  TOP w0.102: v1(196.69,59.57) 196.44,59.83 196.44,59.97 196.54,60.07 205.94,60.07 206.12,59.9 206.39,59.9 ; v2(206.39,59.72) 206.39,59.9 ; 206.39,59.9 207.33,59.9 207.59,59.64 R6111.2
  L4 w0.102: v1(123.02,89) 123.02,89.33 122.92,89.44 122.57,89.44 122.47,89.33 122.47,88.06 123.45,87.09 126.72,87.09 127.06,87.43 135.34,87.43 135.98,88.06 138.91,88.06 140.03,86.95 146.55,86.95 147.95,88.34 151.78,88.34 153.94,86.18 153.94,84.77 170.36,68.35 173.04,68.35 175.05,66.35 175.05,61.53 177.42,59.16 179.8,59.16 180.36,58.6 188.45,58.6 189.5,59.64 194.3,59.64 195.01,60.35 196.04,60.35 196.26,60.13 196.26,59.85 196.53,59.57 v1(196.69,59.57)
  BOTTOM w0.076: 122.43,84.61 122.46,84.13 122.49,84.09 122.51,84.02 122.51,83.87 122.48,83.71 122.47,83.54 122.47,83.49 122.52,83.37 122.67,82.83 CPU1.CC4
  BOTTOM w0.102: v1(123.02,89) 123.28,89.26 123.49,89.26 123.59,89.16 123.59,87.24 122.43,86.08 122.43,84.61
CAD_SNK: length 2.3
  TOP w0.102: v1(29.07,73.31) 29.06,73.3 29.06,73.22 28.92,73.08 U7301.29
  BOTTOM w0.102: R7306.2 28.67,72.91 29.06,73.31 v1(29.07,73.31) v2(28.67,73.71)
CAP_LED: length 16.7
  TOP w0.254: v1(83.31,8) 83.31,8.97 AFTP6532.1
  BOTTOM w0.254: v1(83.31,8) KB1.4 83.31,9.46 84.22,10.37 92.12,10.37 92.98,11.23 93.9,11.23 95.47,12.8 R6506.2
CAP_LED#: length 5.3
  TOP w0.089: R2489.2 28.37,37.75 28.8,38.18 Q2414.S 29.39,37.61 29.64,37.37 v2(30.07,37.37) 30.17,37.47 30.17,37.6 31.08,38.51 U2401.93
CAP_LED#_D: length 92.4
  TOP w0.089: v2(87.85,16.92) 87.38,16.92 v1(87.29,17.01) ; Q2414.D v1(28.44,39.57)
  L3 w0.089: v1(87.29,17.01) 84.16,20.14 75.17,20.14 73.81,21.49 73.81,25.09 72.3,26.61 72.3,36.36 69.37,39.28 v1(69.25,39.28)
  BOTTOM w0.089: v1(87.29,17.01) 88.83,18.54 95.45,18.54 96.41,17.58 97.05,17.58 R6508.1 ; v1(69.25,39.28) 65.56,39.28 64.87,38.59 64.46,38.59 63.52,39.53 59.71,39.53 58.82,40.41 57.25,40.41 56.56,41.1 54.55,41.1 54.3,40.85 53.11,40.85 52.6,41.35 46.29,41.35 45.99,41.05 44.67,41.05 43.73,41.99 40.79,41.99 39.52,40.72 38.65,40.72 37.92,41.45 34.74,41.45 33.78,40.49 30.48,40.49 30.09,40.1 28.98,40.1 v1(28.44,39.57)
CAP_LED#_R: length 2.4
  BOTTOM w0.254: v2(98.39,16.69) 97.99,16.28 R6508.2 96.6,16.28 Q6502.B
CAP_LED_Q: length 3.2
  BOTTOM w0.254: Q6502.C 94.28,15.19 v2(93.42,14.33) 94.3,13.44 R6506.1
CARD1_USB20_N: length 136.7
  TOP w0.102: v2(209.62,40.95) 209.19,40.95 v1(209.04,41.1)
  L6 w0.089: v1(209.04,41.1) 209.04,40.8 208.95,40.72 207.6,40.72 207.2,41.11 206.74,41.11 206.61,40.99 205.18,40.99 205.05,40.86 204.44,40.86 203.76,40.18 202.83,40.18 199.57,43.43 199.57,45.77 198.56,46.79 198.56,48.62 196.49,50.69 193.54,50.69 192.85,49.99 192,49.99 190.79,51.21 190.79,56.35 190.46,56.68 178.61,56.68 176.02,54.09 162.55,54.09 157.97,58.67 157.97,68.37 152.25,74.09 149.77,74.09 149.55,73.87 148.64,73.87 145.44,77.07 145.44,79.74 144.58,80.6 140.34,80.6 140.09,80.85 138.53,80.85 137.03,79.35 135.66,79.35 133.67,81.33 133.67,82.12 132.12,83.67 126.74,83.67 125.06,81.99 125.06,80.65 124.7,80.29 v1(124.7,79.98)
  BOTTOM w0.102: v1(209.04,41.1) 209.13,41.2 209.13,41.43 209.03,41.54 208.68,41.54 208.58,41.64 208.58,41.84 209.19,42.45 209.98,42.45 210.56,41.86 214.27,41.86 216.79,44.39 217.38,44.39 217.52,44.25 IOBD1.18 ; CPU1.CG8 125.21,79.66 125.21,79.81 124.94,80.08 124.8,80.08 v1(124.7,79.98)
CARD1_USB20_P: length 137.3
  TOP w0.102: v1(124.65,79.31) 125.22,78.74 v2(125.65,78.74)
  L6 w0.089: v1(208.35,41.15) 208.35,41 208.26,40.91 207.68,40.91 207.28,41.3 206.66,41.3 206.53,41.18 205.1,41.18 204.97,41.05 204.36,41.05 203.68,40.37 202.91,40.37 199.77,43.51 199.77,45.85 198.75,46.87 198.75,48.69 196.57,50.88 193.47,50.88 192.77,50.18 192.08,50.18 190.98,51.29 190.98,56.43 190.53,56.87 178.53,56.87 175.94,54.28 162.63,54.28 158.16,58.75 158.16,68.45 152.33,74.28 149.69,74.28 149.47,74.06 148.72,74.06 145.63,77.15 145.63,79.82 144.66,80.79 140.42,80.79 140.16,81.04 138.45,81.04 136.95,79.54 135.73,79.54 133.86,81.41 133.86,82.2 132.2,83.86 126.66,83.86 124.87,82.07 124.87,80.73 124.3,80.16 124.3,79.66 v1(124.65,79.31)
  BOTTOM w0.102: v1(124.65,79.31) 124.99,78.97 CPU1.CG9 ; IOBD1.17 217.54,44.75 217.4,44.61 216.7,44.61 214.17,42.09 210.65,42.09 210.07,42.67 209.09,42.67 208.35,41.93 v1(208.35,41.15)
CATERR#_CPU: length 6.7
  BOTTOM w0.089: TP301.1 96.17,87.83 96.17,86.07 96.77,85.47 96.77,83.96 96.93,83.8 96.93,82.86 CPU1.AA4
CBN: length 2
  TOP w0.203: C2708.2 20.24,15.27 20.5,15 U2701.28
CBP: length 2.2
  TOP w0.203: v2(20.7,13.72) 20.72,13.72 21.21,14.2 U2701.30
  TOP w0.254: C2708.1 20.09,13.95 20.31,13.72 v2(20.7,13.72)
CCD_USB20_CON_N: length 5.5
  BOTTOM w0.102: 51.58,89.03 51.92,89.03 52.06,88.88 52.29,88.88 52.55,88.62 EL5501.3 ; 51.58,89.03 51.44,89.03 51.2,89.26 51.2,89.97 52.67,91.44 52.67,91.7 52.56,91.81 LCD1.30 ; 51.58,89.03 v2(51.58,88.85)
CCD_USB20_CON_P: length 5.1
  BOTTOM w0.102: 51.72,90.16 51.43,89.87 51.43,89.36 51.53,89.25 52.01,89.25 52.15,89.11 52.3,89.11 52.57,89.39 EL5501.2 ; 51.72,90.16 v2(51.81,90.07) ; 51.72,90.16 52.9,91.34 52.9,91.7 53.06,91.85 LCD1.31
CCD_USB20_N: length 86.9
  L6 w0.089: v1(54.63,90.48) 54.48,90.63 54.48,91.45 54.84,91.81 62.49,91.81 64.28,90.02 69.26,90.02 70.68,88.6 78.71,88.6 79.06,88.24 94.59,88.24 97.19,90.85 103.31,90.85 103.84,90.31 104.39,90.31 104.48,90.22 104.48,89.95 104.68,89.75 v1(104.8,89.75)
  BOTTOM w0.083: CPU1.CC1 123,84.6 123,84.6 123,85.88 123.85,86.73 123.85,86.77 123.87,86.78
  BOTTOM w0.102: EL5501.4 53.59,88.62 54.38,89.41 54.38,90.22 v1(54.63,90.48) ; 106.84,91.4 105.73,90.3 105.23,90.3 105.15,90.22 105.15,89.98 104.91,89.75 v1(104.8,89.75) ; 106.84,91.4 109.52,94.08 120.54,94.08 124.06,90.56 124.06,86.98 123.87,86.78 ; 106.84,91.4 v2(106.95,91.29)
CCD_USB20_P: length 87.2
  L6 w0.089: v1(104.8,90.5) 103.92,90.5 103.39,91.04 97.11,91.04 94.51,88.43 79.14,88.43 78.79,88.79 70.76,88.79 69.34,90.21 64.36,90.21 62.57,92 54.76,92 54.29,91.53 54.29,90.77 v1(53.99,90.48)
  BOTTOM w0.083: CPU1.CC2 123.18,84.17 123.18,84.59 123.18,85.8 123.98,86.6 124.02,86.6 124.03,86.62
  BOTTOM w0.102: v2(105.79,90.91) 105.9,90.79 ; 105.9,90.79 105.64,90.53 104.83,90.53 v1(104.8,90.5) ; 105.9,90.79 106.82,91.71 109.42,94.31 120.63,94.31 124.29,90.65 124.29,86.88 124.03,86.62 ; v1(53.99,90.48) 54.15,90.32 54.15,89.51 53.79,89.15 53.65,89.15 53.41,89.39 EL5501.1
CFG3: length 10.1
  BOTTOM w0.102: CPU1.R3 93.92,83.55 93.92,84.64 93.36,85.19 91.99,85.19 v2(90.49,86.69) 90.11,87.07 R1517.1 90.11,87.84 90.39,88.12 90.9,88.12 91.98,89.2 TP621.1
CFG4: length 9.6
  BOTTOM w0.089: CPU1.J4 89.61,82.58 89.61,85.22 87.37,87.45 87.37,88.32 86.86,88.83 v2(86.86,89.51) R1518.1
CFG_RCOMP: length 4.1
  TOP w0.508: v1(96.63,82.12) 96.79,82.12 97.53,81.38 v2(97.53,80.67) 97.4,80.55 96.74,80.55 96.54,80.34
  BOTTOM w0.305: v1(96.63,82.12) 97.18,81.57 CPU1.AB5
CHG_AMBER_LED#: length 115
  TOP w0.089: v1(18.71,52.15) 19.35,52.15 20.31,51.18 20.31,47.86 20.09,47.63 20.09,47.62 20.07,47.6 20.07,44.84 19.53,44.3 19.53,43.26 20.59,42.19 v2(20.59,41.97) 21.31,41.25 v1(22.88,41.25) ; Q2412.3 54.72,36.57 54.58,36.71 53.54,36.71 v1(53.51,36.68) ; Q6402.1 21.24,98.21 20.67,97.64 R6405.1 20.75,97.06 22.02,97.06 v1(22.04,97.08)
  L3 w0.089: v1(48.12,41.98) 48.64,41.98 53.51,37.11 v1(53.51,36.68)
  L4 w0.089: v1(21.18,91.24) 20.19,90.25 20.19,89.06 22.04,87.2 22.04,85.42 21.43,84.81 21.43,82.07 20.01,80.65 17.6,80.65 13.86,76.91 13.86,71.71 13.63,71.48 13.63,67.69 13.51,67.57 13.51,66.35 14.07,65.79 14.07,62.13 14.5,61.7 14.5,59.06 14.22,58.78 14.14,58.78 12.74,57.38 12.74,55.7 12.87,55.58 12.87,54.94 15.28,52.53 15.59,52.53 15.62,52.5 15.97,52.5 16,52.53 18.31,52.53 18.69,52.15 v1(18.71,52.15) ; v1(48.12,41.98) 46.9,41.98 46.1,41.18 45.33,41.18 43.02,43.49 41.8,43.49 41.78,43.51 37.46,43.51 36.32,42.37 35.25,42.37 34.99,42.11 34.18,42.11 32.73,40.67 32.16,40.67 31.52,40.03 31.52,39.3 30.23,38.02 25.66,38.02 24,39.69 24,40.13 v1(22.88,41.25)
  L6 w0.089: v1(22.04,97.08) 22.04,97.03 21.86,96.85 21.86,92.81 21.18,92.13 v1(21.18,91.24)
CHG_AMBER_LED_R#: length 10.9
  TOP w0.254: Q6402.6 20.12,97.86 19.81,97.54 R6405.2 17.01,97.13 14.95,95.07 v2(14.95,94.37) v1(14.95,92.2)
  BOTTOM w0.254: Q6403.B 15.25,91.83 14.95,92.13 v1(14.95,92.2)
CHGR_PSYS_IMVP: length 181.4
  TOP w0.127: v1(155.21,15.55) 155.21,15.22 155.37,15.06 155.37,14.13 156.99,12.5 v1(156.99,11.56) ; v1(37.38,63.41) 37.42,63.45 38.04,63.45 PR4614.1 37.66,64.59 v2(37.54,64.59)
  L3 w0.127: v1(44.9,48.26) 44.9,48.87 45.38,49.35 45.38,50.14 43.58,51.95 43.2,51.95 42.77,52.38 42.77,54.84 41.8,55.81 41.78,55.81 41.75,55.83 41.5,55.83 38.07,59.26 38.07,62.97 37.63,63.41 v1(37.38,63.41)
  L4 w0.127: v1(103.07,22.61) 102.38,21.92 102.38,21.29 101.21,20.12 101.21,20.09 99.59,18.47 98.55,18.47 98.06,18.95 79.83,18.95 78.94,18.06 76.19,18.06 75.33,17.2 74.16,17.2 72.93,18.43 71.2,18.43 70.28,19.36 64.36,19.36 63.8,19.92 57.7,19.92 56.69,20.93 56.69,21.82 55.37,23.14 55.37,27 55.49,27.13 55.49,31.37 55.72,31.6 55.77,31.6 56.28,32.11 56.28,32.41 57.09,33.23 57.09,34.6 55.98,35.72 55.98,37.34 56.03,37.39 56.03,38.2 54.53,39.7 54.53,41.86 52.55,43.84 52.55,45.47 51.81,46.21 51.81,46.71 53.03,47.93 53.28,47.93 54.2,48.85 54.2,49.53 53.89,49.84 53.26,49.84 52.9,49.48 50.77,49.48 50.21,48.92 48.46,48.92 48.13,48.59 47.01,48.59 45.99,47.57 45.29,47.57 44.9,47.96 v1(44.9,48.26)
  BOTTOM w0.102: PR4413.1 156.94,11.51 v1(156.99,11.56) 157.32,11.56 157.43,11.45 PU4401.30
  BOTTOM w0.127: v1(103.07,22.61) 103.14,22.61 107.44,18.32 135.1,18.32 135.58,17.83 136.47,17.83 136.93,18.29 138.5,18.29 138.93,17.86 145.64,17.86 146.63,16.87 147.85,16.87 148.74,17.76 151.91,17.76 153.38,16.28 153.38,15.98 153.56,15.8 154.71,15.8 154.96,15.55 v1(155.21,15.55) ; v1(37.38,63.41) 37.76,63.79 37.76,64.31 PU4601.1
CLK_PCIE_PEG_REQ#: length 84.7
  TOP w0.102: v1(156.31,76.76) 156.25,76.71 156.07,76.71 154.8,75.44 153.92,75.44 152.93,74.45 152.75,74.45 152.72,74.42 150.06,74.42 149.8,74.68 v1(149.02,74.68) ; v1(125.44,64.96) 125.44,63.55 127.59,61.4 127.59,56.53 128.06,56.06 128.06,55.07 128.26,54.87 128.26,53.52 127.76,53.01 RN1813.5
  L4 w0.102: v1(125.44,64.96) 125.8,65.32 125.8,65.68 126.14,66.02 126.48,66.02 126.77,65.73 126.77,65.43 127.17,65.03 127.5,65.03 129.18,66.7 129.18,68.22 130.48,69.52 130.61,69.52 131.44,70.35 133.71,70.35 134.99,71.63 136.62,71.63 137.36,72.37 140.63,72.37 140.76,72.49 140.86,72.49 141.3,72.93 144.09,72.93 145.35,74.2 145.36,74.2 145.99,74.83 146.03,74.83 146.06,74.86 147.95,74.86 148.03,74.78 148.43,74.78 148.51,74.86 148.84,74.86 v1(149.02,74.68)
  BOTTOM w0.102: R7618.1 173.5,92.92 173.17,93.24 Q7601.D 172.66,92.56 172.51,92.41 170.5,92.41 170.28,92.64 168.93,92.64 168.52,92.23 168.52,92.21 165.47,89.16 162.07,89.16 161.44,89.79 160.7,89.79 159.35,88.45 159.35,86.9 160.6,85.65 v2(160.6,85.44) 160.6,84.81 160.37,84.58 160.37,84.12 156.38,80.13 156.38,76.84 v1(156.31,76.76) ; CPU1.CF32 125.11,64.63 v1(125.44,64.96)
CLK_TP_SIO: length 181.5
  TOP w0.089: v1(33.27,44.66) 33.12,44.51 U2401.78 ; RN6504.4 179.9,10.45 180.01,10.56 RN6503.1 179.32,10.95 EC6503.1 178.38,10.8 v1(178.35,10.82) 178.2,10.98 v2(178.2,11.41)
  L4 w0.114: v1(178.35,10.82) 177.77,10.82 175.81,12.79 175.11,12.79 174.37,13.53 174.37,15.73 172,18.09 172,18.12 170.17,19.95 109.63,19.95 107.69,18.01 101.54,18.01 99.99,16.46 95.29,16.46 94.93,16.82 88.49,16.82 87.81,16.14 84.23,16.14 82.67,14.58 73.3,14.58 73.27,14.56 68.04,14.56 66.24,16.36 62.45,16.36 60.93,17.88 57.89,17.88 53.98,21.8 53.98,27.27 53.74,27.51 53.74,30.81 53.24,31.31 53.24,32.47 53.56,32.79 53.56,33.23 52.95,33.84 52.95,37.32 51.68,38.59 51.68,40.8 48.76,43.72 48.61,43.72 47.67,44.66 44.06,44.66 43.89,44.83 42.34,44.83 41.8,45.37 41.4,45.37 40.58,46.19 37.94,46.19 37.4,45.65 34.33,45.65 34.07,45.39 33.9,45.39 33.62,45.11 33.62,45.09 33.27,44.73 v1(33.27,44.66)
CLKIN_XTAL_LCP: length 37.3
  TOP w0.102: R1842.1 156.86,85.3 v2(156.05,85.3) 154.71,85.3 v1(151.33,81.92)
  L4 w0.102: v1(131.82,82.15) 131.82,81.41 132.1,81.13 133.37,81.13 134.03,80.47 134.03,79.78 135.93,77.88 137.28,77.88 137.69,77.47 142.26,77.47 142.62,77.83 142.62,79.94 143.76,81.08 150.47,81.08 150.5,81.1 150.57,81.1 151.33,81.87 v1(151.33,81.92)
  BOTTOM w0.102: CPU1.CM3 127.99,83.09 128.43,82.65 129.51,82.65 129.66,82.81 130.06,82.81 130.47,82.4 130.62,82.4 130.63,82.4 130.63,82.4 130.65,82.39 130.66,82.39 131.23,81.82 131.49,81.82 v1(131.82,82.15)
CLKIN_XTAL_LCP_R: length 69.1
  TOP w0.102: R1842.2 158.7,85.4 v2(158.81,85.5) v1(159.2,85.9)
  L3 w0.102: v1(192.55,50.73) 180.6,50.73 177.54,53.78 177.54,58.08 178.68,59.22 178.68,62.28 177.54,63.43 177.49,63.43 176.52,64.39 176.52,65.26 176.5,65.28 176.5,65.38 176.22,65.66 176.12,65.66 174.19,67.59 174.19,68.68 173.96,68.91 173.6,68.91 172.56,69.95 172.56,71.46 170.59,73.44 170.59,74.62 167.48,77.73 167.27,77.73 162.1,82.9 161.54,82.9 159.2,85.25 v1(159.2,85.9)
  L4 w0.102: v1(192.55,50.73) 192.55,51.41 195.98,54.84 195.98,55.64 196.25,55.91 196.79,55.91 v1(197.38,55.32)
  BOTTOM w0.102: WLAN1.64 197.96,54.44 197.45,54.94 197.45,55.25 v1(197.38,55.32)
CLKRUN#: length 25.4
  TOP w0.102: R1818.1 v2(136.01,52.83) 136.01,53.39 136.11,53.5 v1(136.11,53.6)
  L6 w0.102: v1(120.81,65.68) 120.81,65.65 121.23,65.24 121.23,65.22 121.23,65.22 121.23,64.88 121.18,64.83 121.18,64.57 121.21,64.53 121.21,64.2 121.18,64.17 121.18,63.61 121.05,63.48 121.05,63.03 124.64,59.44 124.64,58.23 129.66,53.22 135.19,53.22 135.55,53.57 136.09,53.57 v1(136.11,53.6)
  BOTTOM w0.102: v1(120.81,65.68) 120.83,65.67 120.97,65.67 121.23,65.93 CPU1.BY30
CMP_VIN0: length 3.7
  TOP w0.089: U2401.20 47.67,44.91 48.33,45.57 48.51,45.57 v2(48.71,45.77) 48.99,46.05 49.96,46.05 R2470.1
CMP_VIN0_R: length 144.3
  TOP w0.089: R2608.2 R2609.2 58.77,44.63 C2612.1 C2613.1 58.52,46.43 58.25,46.43 ; R2470.2 51.02,45.37 51.77,44.62 53.29,44.62 54.49,45.82 56.43,45.82 56.47,45.79 57.85,45.79 58.25,46.19 58.25,46.43 ; 58.25,46.43 v1(58.24,46.43)
  L3 w0.127: v1(33.12,89.68) 29.05,89.68 27.08,87.71 27.08,86.57 29.15,84.49 29.15,82.53 27.81,81.18 27.81,77.83 27.71,77.73 27.71,76.41 27.07,75.77 26.59,75.77 25.95,75.14 25.95,72.19 25.03,71.26 25.03,67.91 25.6,67.34 25.6,66.32 26.82,65.1 26.82,64.59 26.44,64.21 26.44,59.79 24.45,57.81 24.45,54.94 22.71,53.2 22.71,51.04 v1(23.26,50.5)
  L4 w0.127: v1(33.19,46.89) 32.58,46.89 30.54,48.94 28.04,48.94 27.99,48.88 26.74,48.88 24.69,50.93 23.74,50.93 23.31,50.5 v1(23.26,50.5)
  BOTTOM w0.089: R2610.1 67.02,88.22 64.97,88.22 64.43,87.68 62.25,87.68 61.94,87.99 61.94,87.99 v2(60.91,89.03) 60.27,89.67 60.27,92.35 56.9,95.72 37.26,95.72 36.37,94.82 36.37,93.75 35.91,93.3 35.91,92.92 33.12,90.13 v1(33.12,89.68) ; v1(33.19,46.89) 33.22,46.86 34.84,46.86 36.67,48.68 39.11,48.68 39.46,48.33 40.58,48.33 42,46.92 47.16,46.92 48.3,48.06 50.57,48.06 51.1,48.59 51.48,48.59 51.71,48.36 54.3,48.36 55.6,47.06 57.64,47.06 57.89,46.81 57.89,46.78 v1(58.24,46.43)
CMP_VOUT0: length 8.9
  TOP w0.089: U2401.85 31.08,41.71 30.87,41.92 27.66,41.92 v2(27.57,41.83) 27.2,41.46 26.18,41.46 25.98,41.25 25.98,40.95 R2615.2 25.44,39.96 25.57,39.83 R2607.2 R2602.2
CNV_BRI_DT: length 111.9
  TOP w0.102: v1(157.83,51.29) 157.83,51.62 158.19,51.97 159.58,51.97 159.63,52.02 159.68,52.02 160.32,52.66 161.97,52.66 163.24,53.93 163.24,54.92 163.52,55.2 164.08,55.2 v2(164.43,55.55) 164.76,55.88 164.76,57.43 165.09,57.76 165.09,58.55 v1(164.76,58.88) ; v1(205.42,49.2) 205.42,49.24 205.43,49.25 R2007.2
  L3 w0.102: v1(141.62,64.04) 141.67,64.04 142.23,63.48 143.86,63.48 144.29,63.05 146.32,63.05 v1(146.37,62.99)
  L6 w0.102: v1(146.37,62.99) 146.18,62.99 145.84,62.66 145.84,58.02 149.75,54.1 149.78,54.1 151.61,52.28 156.89,52.28 157.14,52.02 157.14,51.97 v1(157.83,51.29) ; v1(141.62,64.04) 140.21,65.46 136.92,65.46 135.6,66.77 135.6,66.88 134.24,68.24 130.31,68.24 127.26,71.29 126.83,71.29 126.8,71.32 126.72,71.32 v1(126.36,71.68) ; v1(205.42,49.2) 204.97,49.65 204.97,53.42 199.87,58.52 199.87,59.72 199.6,59.98 199.6,61.92 199.05,62.46 194.58,62.46 193.42,63.63 189.76,63.63 188.67,64.72 180.74,64.72 179.6,63.58 177.31,63.58 172.13,58.4 166.31,58.4 165.83,58.88 v1(164.76,58.88)
  BOTTOM w0.102: v1(126.36,71.68) 126.67,71.99 CPU1.CJ20
CNV_BRI_DT_R: length 7.3
  TOP w0.102: R2007.1 205.43,51.51 v1(205.4,51.54) 205.38,51.56 v2(203.73,51.56) 203.73,51.87 203.93,52.07 204.85,52.07 205.1,52.33 R6115.2
  BOTTOM w0.102: WLAN1.36 204.96,52.19 204.98,52.17 204.98,51.86 205.3,51.54 v1(205.4,51.54)
CNV_BRI_RSP: length 115.6
  TOP w0.102: R6118.1 208.05,50.83 206.45,49.23 206.45,48.16 206.71,47.9 v2(206.71,47.9) v1(207.1,47.5) ; v1(127.01,71.69) 127.95,71.69 R2030.2
  L6 w0.102: v1(196,34.88) 196,36.95 193.32,39.63 183.56,39.63 183.03,40.16 180.26,40.16 175.56,44.86 163.8,44.86 162.07,46.59 159.77,46.59 158.93,45.75 154.04,45.75 142.21,57.58 142.21,58.89 141.67,59.43 141.67,63.27 142.06,63.65 142.06,64.22 140.61,65.66 137,65.66 135.8,66.87 135.8,66.96 134.32,68.43 130.39,68.43 127.12,71.69 v1(127.01,71.69)
  BOTTOM w0.102: v1(207.1,47.5) 207.1,47.47 207.03,47.4 207.03,47.38 203.6,43.94 202.43,43.94 198.24,39.76 198.24,38.51 196,36.27 v1(196,34.88) ; v1(127.01,71.69) 127.03,71.69 127.32,71.99 CPU1.CK20
CNV_BRI_RSP_R: length 3.3
  TOP w0.102: R6118.2 207.69,52.89 v2(207.08,52.89) 207.05,52.91 v1(207.05,53.6)
  BOTTOM w0.102: WLAN1.22 207.31,53.85 v1(207.05,53.6)
CNV_RGI_DT: length 28.6
  TOP w0.254: v1(143.63,62.21) 143.63,61.34 R2006.2
  L6 w0.254: v1(143.63,62.21) 143.71,62.28 143.71,63.91 141.5,66.12 141.5,66.81 138.83,69.47 136.77,69.47 135.43,70.82 133.12,70.82 131.59,72.34 128.85,72.34 127.94,73.25 125.54,73.25 125.07,72.78 v1(125.07,72.72)
  BOTTOM w0.254: v1(125.07,72.72) 125.07,72.84 125.37,73.14 CPU1.CG19 ; v2(144.44,61.95) 144.19,62.21 v1(143.63,62.21)
CNV_RGI_DT_R: length 98.1
  TOP w0.254: v1(208.45,50.37) 208.66,50.57 208.66,55.4 v2(207.96,56.1) 207.18,56.87 206.83,56.87 206.22,57.48 205.68,57.48 205.02,56.82 v1(205.02,55.32) ; 144.82,62.28 144.82,61.24 145.49,60.58 R2006.1 145.49,60 145.28,59.79 v1(143.68,59.79)
  L6 w0.254: v1(143.68,59.79) 143.68,57.59 152.52,48.75 158.45,48.75 158.49,48.8 160.06,48.8 161.23,47.63 162.48,47.63 163.74,46.36 175.59,46.36 180.88,41.07 183.41,41.07 183.97,40.52 195.73,40.52 v1(196.82,39.42)
  BOTTOM w0.254: v1(205.02,55.32) 205.46,55.32 205.96,54.82 WLAN1.32 ; v1(196.82,39.42) 196.82,40.31 201.42,44.91 204.01,44.91 206.45,47.35 206.45,47.36 206.57,47.49 206.57,47.91 206.57,47.92 206.57,48.49 v1(208.45,50.37)
CNV_RGI_RSP: length 109.7
  TOP w0.254: v1(125.71,72.71) 125.71,72.78 126.51,73.58 R2029.2 ; R6109.1 206.07,49.74 v2(206.07,48.95) v1(206.07,47.7)
  L6 w0.254: v1(125.71,72.71) 125.71,72.67 126.16,72.21 127.45,72.21 128.87,70.79 131.12,70.79 132.84,69.07 134.28,69.07 136.21,67.13 140.51,67.13 141.07,66.58 141.07,66.02 143.33,63.76 143.33,62.62 143.12,62.42 143.12,57.61 152.65,48.08 158.69,48.08 159.53,47.25 162.3,47.25 163.56,45.98 175.43,45.98 180.74,40.67 183.26,40.67 183.79,40.13 194.41,40.13 v1(196.56,37.98)
  BOTTOM w0.254: v1(125.71,72.71) 125.71,72.83 126.02,73.14 CPU1.CH19 ; v1(206.07,47.7) 206.06,47.7 206.06,47.53 203.83,45.29 201.24,45.29 196.06,40.11 196.06,38.48 v1(196.56,37.98)
CNV_RGI_RSP_R: length 4.1
  TOP w0.254: R6109.2 v1(206.19,51.46) 206.06,51.59 v2(206.06,52.07)
  BOTTOM w0.254: WLAN1.34 205.46,52.86 206.04,52.28 206.04,51.64 206.19,51.49 v1(206.19,51.46)
CNV_WR_CLKN: length 123.2
  L3 w0.102: v1(208.88,64.14) 208.71,63.96 208.71,62.33 207.46,61.08 207.46,58.46 207.88,58.03 207.88,57.72 207.9,57.7 v1(207.9,57.38)
  L4 w0.102: v1(207.9,57.38) 207.64,57.12 207.64,56.67 206.6,55.63 206.6,54.35 205.79,53.55 204.89,53.55 204.77,53.43 204.77,51.73 204.53,51.49 204.19,51.49 203.95,51.73 203.95,53.43 203.84,53.55 203.12,53.55 203,53.43 203,53 202.78,52.78 202.41,52.78 202.19,53 202.19,53.43 202.07,53.55 200.56,53.55 199.97,52.95 199.97,49.71 199.31,49.05 199.31,44.3 197.91,42.9 196.72,42.9 195.47,41.66 181.45,41.66 173.13,49.98 173.13,53.16 169.01,57.28 166.2,57.28 165.3,58.19 165.3,58.98 164.66,59.62 163.44,59.62 160.52,62.53 160.52,63.96 153.59,70.89 153.58,70.89 153.55,70.92 149.17,70.92 148.51,71.58 147.42,71.58 146.7,70.87 145.92,70.87 144.72,69.67 143.25,69.67 141.29,67.72 138.35,67.72 137.64,67.01 134.54,67.01 133.88,66.35 133.57,66.35 133.32,66.09 132.42,66.09 132.32,65.99 v1(132.32,65.2)
  BOTTOM w0.076: CPU1.CN31 129.68,65.59 129.7,65.59 129.72,65.6 129.83,65.61 131.04,65.61 131.25,65.81 131.82,65.81 132.1,65.53 132.1,65.42 v1(132.32,65.2)
  BOTTOM w0.102: v1(208.88,64.14) R6123.2
CNV_WR_CLKN_R: length 1.5
  BOTTOM w0.102: WLAN1.21 208.71,62.44 R6123.1
CNV_WR_CLKP: length 123.2
  L3 w0.102: v1(207.06,57.38) 207.28,57.38 207.68,57.78 207.68,57.95 207.26,58.37 207.26,61.17 208.5,62.41 208.5,63.76 v1(208.12,64.14)
  L4 w0.102: v1(207.06,57.38) 207.33,57.38 207.44,57.28 207.44,56.75 206.39,55.71 206.39,54.43 205.71,53.75 204.8,53.75 204.56,53.51 204.56,51.81 204.44,51.69 204.28,51.69 204.16,51.81 204.16,53.51 203.92,53.75 203.03,53.75 202.8,53.51 202.8,53.09 202.69,52.99 202.49,52.99 202.39,53.09 202.39,53.51 202.15,53.75 200.48,53.75 199.77,53.04 199.77,49.79 199.1,49.13 199.1,44.38 197.83,43.11 196.63,43.11 195.39,41.86 181.53,41.86 173.33,50.07 173.33,53.24 169.09,57.48 166.29,57.48 165.5,58.27 165.5,59.07 164.75,59.82 163.52,59.82 160.73,62.61 160.73,64.04 153.67,71.1 153.66,71.1 153.64,71.12 149.25,71.12 148.59,71.78 147.33,71.78 146.62,71.07 145.83,71.07 144.64,69.88 143.17,69.88 141.21,67.92 138.26,67.92 137.55,67.21 134.45,67.21 133.79,66.55 133.49,66.55 133.23,66.3 132.33,66.3 132.11,66.08 132.11,65.7 v1(131.62,65.2)
  BOTTOM w0.076: v1(131.62,65.2) 131.85,65.2 131.93,65.28 131.93,65.46 131.75,65.64 131.32,65.64 131.12,65.43 129.89,65.43 CPU1.CP31
  BOTTOM w0.102: v1(208.12,64.14) R6124.2
CNV_WR_CLKP_R: length 1.5
  BOTTOM w0.102: WLAN1.23 208.21,62.53 R6124.1
CNV_WR_DN0: length 123
  L3 w0.102: v1(210.43,64.14) 210.15,63.86 210.15,61.9 209.11,60.86 209.11,59.04 v1(209.48,58.67)
  L4 w0.102: v1(209.48,58.67) 209.27,58.67 209.06,58.88 209.06,59.26 208.84,59.48 206.72,59.48 203.7,56.47 199.43,56.47 198.22,55.25 198.22,54.99 197.03,53.81 197.03,53.47 197.65,52.85 197.65,52.68 197.53,52.56 197.36,52.56 196.74,53.18 196.41,53.18 196.17,52.95 196.17,52.61 196.97,51.81 196.97,51.64 196.85,51.52 196.68,51.52 195.88,52.32 195.54,52.32 195.31,52.08 195.31,51.75 196.38,50.67 196.38,50.51 196.26,50.39 196.09,50.39 195.02,51.46 194.68,51.46 192.88,49.66 186.48,49.66 183.86,47.04 183.86,44.38 183.08,43.59 181.57,43.59 174.55,50.62 174.55,54.31 167.85,61.01 166.6,61.01 162,65.61 160.91,65.61 158.79,67.73 158.79,68.99 155.01,72.77 151.68,72.77 151.56,72.65 151.15,72.65 150.77,73.03 145.84,73.03 144.52,71.71 141.75,71.71 139.82,69.78 136.87,69.78 136.1,69.01 132.85,69.01 132.24,68.4 131.79,68.4 131.49,68.1 131.49,67.39 131.8,67.08 131.8,66.94 131.69,66.83 v1(131.58,66.83)
  BOTTOM w0.076: CPU1.CR30 130.01,65.96 130.76,65.96 131.11,66.31 131.69,66.31 131.79,66.41 131.79,66.61 v1(131.58,66.83)
  BOTTOM w0.102: v1(210.43,64.14) R6121.2
CNV_WR_DN0_R: length 1.6
  BOTTOM w0.102: R6121.1 210.21,62.39 WLAN1.15
CNV_WR_DN1: length 123.2
  L3 w0.102: v1(212.01,58.85) 211.86,59.01 211.86,59.46 211.69,59.63 211.69,63.85 v1(211.98,64.14)
  L4 w0.102: v1(133.42,67.59) 133.42,67.77 133.8,68.15 136.39,68.15 137.2,68.96 141.65,68.96 142.97,70.28 144.27,70.28 146.2,72.21 149.24,72.21 149.67,71.78 154.82,71.78 157.98,68.63 157.98,67.36 161.11,64.24 161.84,64.24 165.42,60.66 165.42,59.74 165.91,59.26 165.91,58.92 166.74,58.09 169.23,58.09 173.73,53.59 173.73,50.27 181.71,42.29 195.22,42.29 196.44,43.51 197.56,43.51 198.7,44.66 198.7,48.54 198.24,49 198.24,52.12 200.27,54.16 205.21,54.16 205.73,54.68 205.73,57.08 206.47,57.81 211.71,57.81 211.93,58.03 211.93,58.77 v1(212.01,58.85)
  BOTTOM w0.076: 131.4,67.86 131.4,67.83 130.94,67.37 130.91,67.11 130.89,67.03 130.69,66.83 130.62,66.8 130.53,66.77 129.73,66.44 129.72,66.44 129.62,66.4 129.58,66.39 129.44,66.39 129.34,66.4 129.19,66.4 129.01,66.38 128.83,66.35 128.49,66.28 CPU1.CM30
  BOTTOM w0.102: v1(211.98,64.14) R6119.2 ; v1(133.42,67.59) 133.25,67.76 133.25,68.03 132.99,68.29 131.84,68.29 131.4,67.86
CNV_WR_DN1_R: length 1.6
  BOTTOM w0.102: WLAN1.9 211.71,62.34 R6119.1
CNV_WR_DP0: length 123.1
  L3 w0.102: v1(209.67,64.14) 209.95,63.86 209.95,61.99 208.91,60.95 208.91,58.95 208.91,58.95 v1(208.63,58.67)
  L4 w0.102: v1(132.21,66.83) 132,67.04 132,67.17 131.69,67.48 131.69,68.02 131.88,68.2 132.33,68.2 132.94,68.81 136.19,68.81 136.95,69.57 139.91,69.57 141.84,71.5 144.6,71.5 145.93,72.82 150.68,72.82 151.07,72.44 151.64,72.44 151.77,72.57 154.93,72.57 158.59,68.9 158.59,67.64 160.83,65.41 161.92,65.41 166.52,60.81 167.76,60.81 174.34,54.23 174.34,50.53 181.49,43.39 183.16,43.39 184.07,44.29 184.07,46.96 186.57,49.46 192.97,49.46 194.77,51.26 194.93,51.26 196.01,50.18 196.34,50.18 196.58,50.42 196.58,50.76 195.51,51.83 195.51,52 195.63,52.12 195.8,52.12 196.6,51.32 196.93,51.32 197.17,51.56 197.17,51.89 196.37,52.69 196.37,52.86 196.49,52.98 196.66,52.98 197.28,52.36 197.62,52.36 197.85,52.6 197.85,52.94 197.23,53.56 197.23,53.73 198.42,54.91 198.42,55.16 199.52,56.26 203.79,56.26 206.8,59.28 208.76,59.28 208.86,59.18 208.86,58.9 v1(208.63,58.67)
  BOTTOM w0.076: v1(132.21,66.83) 131.97,66.59 131.97,66.34 131.88,66.24 ; v2(132,66.12) 131.88,66.24 ; 131.88,66.24 131.77,66.13 131.18,66.13 130.84,65.78 129.84,65.78 CPU1.CP30
  BOTTOM w0.102: v1(209.67,64.14) R6122.2
CNV_WR_DP0_R: length 1.5
  BOTTOM w0.102: WLAN1.17 209.71,62.57 R6122.1
CNV_WR_DP1: length 123.2
  L3 w0.102: v1(211.2,64.14) 211.49,63.85 211.49,59.54 211.65,59.38 211.65,59.11 211.4,58.85 v1(211.17,58.85)
  L4 w0.102: v1(211.17,58.85) 211.4,58.85 211.73,58.52 211.73,58.12 211.63,58.02 206.39,58.02 205.53,57.16 205.53,54.77 205.12,54.36 200.19,54.36 198.04,52.21 198.04,48.92 198.5,48.46 198.5,44.74 197.47,43.72 196.35,43.72 195.13,42.5 181.8,42.5 173.94,50.36 173.94,53.68 169.32,58.3 166.82,58.3 166.11,59.01 166.11,59.35 165.63,59.83 165.63,60.74 161.93,64.44 161.19,64.44 158.19,67.45 158.19,68.71 154.91,71.99 149.75,71.99 149.32,72.42 146.11,72.42 144.18,70.49 142.89,70.49 141.57,69.17 137.12,69.17 136.31,68.35 133.72,68.35 133.41,68.05 132.94,68.05 132.77,67.88 v1(132.77,67.63)
  BOTTOM w0.076: CPU1.CN30 128.9,66.13 129.19,66.22 129.34,66.22 129.42,66.21 129.65,66.21 129.79,66.28 129.8,66.28 130.59,66.6 130.61,66.6 130.62,66.61 130.69,66.64 130.79,66.68 131.05,66.94 131.08,67.07 131.11,67.28 131.46,67.64 131.52,67.64
  BOTTOM w0.102: v1(211.2,64.14) R6120.2 ; v1(132.77,67.63) 132.92,67.63 133.02,67.73 133.02,67.93 132.89,68.06 131.93,68.06 131.52,67.64
CNV_WR_DP1_R: length 1.5
  BOTTOM w0.102: WLAN1.11 211.21,62.6 R6120.1
CNV_WT_CLKN: length 122.2
  L3 w0.102: v1(196.39,64.11) 196.03,63.76 196.03,63.17 199.16,60.05 199.16,56.52 198.75,56.11 198.75,53.37 200.78,51.34 202.9,51.34 203.72,50.51 203.72,47.85 203.5,47.63 203.09,47.63 203.07,47.6 203.05,47.6 202.95,47.5 v1(202.95,47.2)
  L4 w0.102: v1(202.95,47.2) 202.95,47.46 203.12,47.63 203.56,47.63 203.73,47.46 203.73,46.52 202.86,45.65 201.31,45.65 200.37,44.71 200.37,43.88 198.39,41.89 197.19,41.89 195.95,40.64 180.71,40.64 172.1,49.25 172.1,52.71 168.85,55.96 164.62,55.96 161.67,58.91 161.67,59.92 159.51,62.08 159.51,63.43 153.09,69.85 148.38,69.85 147.8,69.27 145.84,69.27 142.44,65.86 134.87,65.86 133.95,64.95 132.8,64.95 132.52,64.67 131.79,64.67 131.15,64.03 131.15,63.61 130.96,63.42 130.9,63.42 v1(130.65,63.17)
  BOTTOM w0.076: CPU1.CP34 129.49,63.6 129.59,63.6 129.69,63.6 129.82,63.67 129.86,63.68 130.08,63.68 130.18,63.59 130.91,63.59 130.98,63.51 130.98,63.32 130.83,63.17 v1(130.65,63.17)
  BOTTOM w0.102: v1(196.39,64.11) R6129.2
CNV_WT_CLKN_R: length 1.5
  BOTTOM w0.102: WLAN1.71 196.21,62.41 R6129.1
CNV_WT_CLKP: length 122.2
  L3 w0.102: v1(202.95,48.04) 203.16,47.83 203.42,47.83 203.52,47.93 203.52,50.43 202.81,51.13 200.7,51.13 198.55,53.28 198.55,56.2 198.95,56.6 198.95,59.96 195.83,63.09 195.83,63.91 v1(195.62,64.11)
  L4 w0.102: v1(131.35,63.17) 131.35,63.95 131.87,64.47 132.61,64.47 132.89,64.75 134.04,64.75 134.95,65.66 142.52,65.66 145.93,69.07 147.88,69.07 148.47,69.65 153,69.65 159.3,63.35 159.3,62 161.46,59.84 161.46,58.83 164.54,55.76 168.77,55.76 171.9,52.63 171.9,49.17 180.62,40.44 196.03,40.44 197.28,41.68 198.47,41.68 200.58,43.79 200.58,44.63 201.39,45.44 202.94,45.44 203.93,46.43 203.93,47.54 203.64,47.83 203.16,47.83 v1(202.95,48.04)
  BOTTOM w0.076: CPU1.CN34 129.03,63.79 129.08,63.83 129.31,63.83 129.31,63.83 129.32,63.83 129.44,63.82 129.46,63.8 129.68,63.8 129.71,63.82 129.72,63.83 129.79,63.85 129.83,63.86 130.15,63.86 130.25,63.76 130.98,63.76 131.16,63.58 131.16,63.36 v1(131.35,63.17)
  BOTTOM w0.102: v1(195.62,64.11) R6130.2
CNV_WT_CLKP_R: length 1.5
  BOTTOM w0.102: R6130.1 195.71,62.5 WLAN1.73
CNV_WT_DN0: length 122.4
  L3 w0.102: v1(197.91,64.11) 197.91,63.83 197.81,63.73 197.48,63.73 197.35,63.6 197.35,63.25 200.22,60.38 200.22,58.88 202.64,56.47 202.64,55.11 200.76,53.23 200.76,52.65 200.95,52.46 200.97,52.46 v1(201.19,52.24)
  L4 w0.102: v1(138.3,66.45) 138.3,66.8 138.61,67.11 141.56,67.11 143.51,69.07 144.98,69.07 146.17,70.26 153.35,70.26 159.91,63.7 159.91,62.26 162.1,60.07 162.1,59.35 164.96,56.49 168.92,56.49 172.5,52.91 172.5,49.42 180.88,41.05 195.75,41.05 197,42.29 198.19,42.29 199.97,44.07 199.97,44.88 201.92,46.84 201.92,47.78 202.69,48.55 202.69,48.92 202.79,49.03 203.83,49.03 204.05,49.25 204.05,49.84 203.83,50.06 202.68,50.06 202.39,50.35 202.39,50.52 203.14,51.26 203.14,51.6 202.9,51.84 202.56,51.84 201.81,51.09 201.64,51.09 200.93,51.8 200.93,51.99 v1(201.19,52.24)
  BOTTOM w0.076: CPU1.CN32 128.9,64.82 129.12,64.89 129.2,64.92 129.22,64.92 129.57,64.92 129.58,64.91 130.22,64.91 130.39,65.09 130.87,65.09 131.25,64.65 131.35,64.54 132,64.54 132.02,64.52 132.04,64.52
  BOTTOM w0.102: 137.98,65.75 137.71,65.48 135.63,65.48 134.88,64.73 132.89,64.73 132.68,64.52 132.04,64.52 ; 137.98,65.75 v2(138.09,65.64) ; 137.98,65.75 138.04,65.82 138.04,66.2 v1(138.3,66.45) ; v1(197.91,64.11) R6127.2
CNV_WT_DN0_R: length 1.5
  BOTTOM w0.102: WLAN1.65 197.71,62.39 R6127.1
CNV_WT_DN1: length 121.5
  L3 w0.102: v1(205.17,47.43) 204.9,47.7 204.9,49.9 205.02,50.02 206.66,50.02 206.89,50.26 206.89,50.6 206.66,50.83 205.02,50.83 204.9,50.95 204.9,53.22 203.32,54.8 203.32,58.17 198.93,62.56 198.93,63.6 v1(199.43,64.11)
  L4 w0.102: v1(205.17,47.43) 204.67,46.93 204.67,46.28 203.22,44.83 201.65,44.83 201.19,44.37 201.19,43.44 198.83,41.07 197.54,41.07 196.29,39.83 180.17,39.83 171.24,48.77 171.24,52.4 169.48,54.16 165.25,54.16 158.41,60.99 158.41,63.38 152.75,69.04 148.72,69.04 148.14,68.46 147.37,68.46 145.42,66.5 144.55,66.5 143.1,65.05 135.33,65.05 133.94,63.66 133.23,63.66 133.16,63.73 v1(132.35,63.73)
  BOTTOM w0.102: v1(132.35,63.73) 132.35,63.91 132.25,64.01 130.42,64.01 130.34,64.09 129.59,64.09 CPU1.CP33 ; v1(199.43,64.11) R6125.2
CNV_WT_DN1_R: length 1.5
  BOTTOM w0.102: R6125.1 199.21,62.36 WLAN1.59
CNV_WT_DP0: length 122.4
  L3 w0.102: v1(200.56,52.23) 200.56,53.31 202.43,55.19 202.43,56.38 200.02,58.8 200.02,60.29 197.15,63.16 v1(197.15,64.11)
  L4 w0.102: v1(137.51,66.45) 137.58,66.53 137.61,66.53 137.69,66.6 137.81,66.6 138.53,67.31 141.47,67.31 143.43,69.27 144.89,69.27 146.09,70.46 153.44,70.46 160.12,63.78 160.12,62.34 162.3,60.16 162.3,59.44 165.04,56.7 169.01,56.7 172.71,52.99 172.71,49.51 180.96,41.25 195.67,41.25 196.91,42.5 198.11,42.5 199.77,44.16 199.77,44.97 201.72,46.92 201.72,47.87 202.48,48.63 202.48,49.01 202.7,49.23 203.74,49.23 203.85,49.33 203.85,49.75 203.74,49.86 202.59,49.86 202.19,50.26 202.19,50.6 202.94,51.35 202.94,51.52 202.82,51.64 202.65,51.64 201.9,50.89 201.56,50.89 200.73,51.72 200.73,52.05 v1(200.56,52.23)
  BOTTOM w0.076: 132.04,64.75 132.02,64.75 132,64.72 131.43,64.72 131.38,64.77 130.95,65.27 130.32,65.27 130.14,65.09 129.65,65.09 129.65,65.1 129.57,65.1 129.21,65.1 129.17,65.09 129.16,65.09 128.59,65.01 CPU1.CM32
  BOTTOM w0.102: v1(137.51,66.45) 137.81,66.14 137.81,65.92 137.61,65.71 135.54,65.71 134.78,64.96 134.13,64.96 ; 134.13,64.96 v2(134.13,65.15) ; 134.13,64.96 132.79,64.96 132.58,64.75 132.04,64.75 ; v1(197.15,64.11) R6128.2
CNV_WT_DP0_R: length 1.5
  BOTTOM w0.102: WLAN1.67 197.21,62.53 R6128.1
CNV_WT_DP1: length 121.5
  L3 w0.102: v1(198.67,64.11) 198.72,64.06 198.72,62.48 203.12,58.08 203.12,54.72 204.7,53.13 204.7,50.87 204.94,50.63 206.57,50.63 206.69,50.51 206.69,50.34 206.57,50.22 204.94,50.22 204.7,49.99 204.7,47.72 204.41,47.44 v1(204.41,47.44)
  L4 w0.102: v1(204.41,47.44) 204.46,47.38 204.46,46.37 203.14,45.04 201.57,45.04 200.98,44.45 200.98,43.52 198.74,41.28 197.45,41.28 196.21,40.03 180.26,40.03 171.44,48.85 171.44,52.48 169.56,54.36 165.33,54.36 158.62,61.07 158.62,63.46 152.83,69.24 148.63,69.24 148.05,68.66 147.29,68.66 145.33,66.7 144.46,66.7 143.01,65.26 135.25,65.26 133.85,63.86 133.32,63.86 133.04,64.14 v1(132.94,64.14)
  BOTTOM w0.102: v1(198.67,64.11) R6126.2 ; CPU1.CN33 129.43,64.37 129.7,64.37 129.75,64.32 130.43,64.32 130.51,64.24 132.84,64.24 v1(132.94,64.14)
CNV_WT_DP1_R: length 1.5
  BOTTOM w0.102: R6126.1 198.71,62.55 WLAN1.61
CNV_WT_RCOMP: length 4
  TOP w0.254: R2101.1 129.74,65.43 129.31,65 v2(129.31,64.62) 130.61,64.62 v1(130.68,64.69)
  BOTTOM w0.254: CPU1.CP32 129.9,64.65 CPU1.CR32 130.62,64.63 v1(130.68,64.69)
CPU_D4_TP: length 2.7
  TOP w0.102: v1(125.04,69.6) 125.57,69.07 126.49,69.07 126.61,68.94 TP1804.1
  BOTTOM w0.089: v1(125.04,69.6) 125.37,69.94 CPU1.CG23
CPU_D6_TP: length 1.3
  TOP w0.102: v1(125.06,71.68) 124.38,71.68 TP1806.1
  BOTTOM w0.089: v1(125.06,71.68) 125.06,71.82 CPU1.CG20
CPU_DP2_CTRL_CLK: length 8.7
  BOTTOM w0.089: CPU1.CH4 126.22,82.94 126.22,84.55 126.71,85.04 126.87,85.04 127.5,85.68 127.7,85.68 128.34,86.33 128.34,88.11 128.09,88.36 RN403.3 128.46,89.31 v2(129.03,89.31)
CPU_DP2_CTRL_DATA: length 7.2
  BOTTOM w0.089: RN403.4 v2(127.42,87.94) 127.42,87.63 128.17,86.88 128.17,86.4 127.62,85.85 127.43,85.85 126.79,85.22 126.53,85.22 125.92,84.61 CPU1.CH3
CPU_DP_HPD_P: length 4.5
  TOP w0.102: Q401.2 98.9,95.2 98.37,94.67 v2(98.37,94.26) 98.72,94.26 99.01,94.55 Q401.3 99.83,94.55 100.02,94.36 100.02,93.93 99.84,93.75 R406.2
CPU_I2C_SCL_ISH0: length 38
  TOP w0.089: RN2007.2 152.97,75.95 152.57,75.55 v1(152.57,75.17) ; v1(125.71,71.68) 126.03,71.99 v2(126.03,72.19)
  L4 w0.114: v1(152.57,75.17) 152.57,77.52 151.23,78.86 146.27,78.86 143.5,76.09 137.01,76.09 136.78,76.32 134.38,76.32 133.72,75.67 132.96,75.67 132.77,75.86 130.46,75.86 127.45,72.85 127.45,71.55 127.17,71.26 126.13,71.26 v1(125.71,71.68)
  BOTTOM w0.089: R2020.1 153.23,75.83 v1(152.57,75.17) ; CPU1.CH20 126.02,71.99 v1(125.71,71.68)
CPU_I2C_SCL_ISH1: length 34
  TOP w0.089: v1(151.23,75.19) 151.25,75.21 151.25,75.22 151.45,75.42 RN2008.2
  L4 w0.114: v1(151.23,75.19) 151.23,76.45 149.55,78.13 146.6,78.13 143.76,75.29 136.65,75.29 136.49,75.13 132.89,75.13 132.57,75.45 130.66,75.45 128.59,73.38 128.59,71.7 127.17,70.28 126.75,70.28 v1(126.36,70.67)
  BOTTOM w0.089: CPU1.CJ22 126.67,70.98 v1(126.36,70.67) ; v2(151.86,74.75) 151.43,75.19 v1(151.23,75.19)
CPU_I2C_SCL_P0: length 108.9
  TOP w0.089: v1(175.51,11.28) 175.13,11.28 174.9,11.05 R6518.1 EC6504.1 ; v1(178.84,14.1) 178.84,15.62 179.17,15.95 179.17,16.85 180.08,17.76 180.08,18.42 v1(179.75,18.75) 179.75,19.84 179.88,19.97 179.88,20.43 180.49,21.04 180.49,24.56 179.34,25.71 179.34,29.01 177.96,30.39 177.96,31.26 177.59,31.63 177.23,31.63 171.7,37.15 171.7,43.06 167.95,46.81 167.95,47.38 167.3,48.03 166.14,48.03 165.56,48.61 164.24,48.61 v2(163.49,49.35) 163.54,49.41 163.54,49.84 v1(163.82,50.12)
  L6 w0.089: v1(131.41,77.79) 131.84,78.21 132.99,78.21 134.74,76.46 134.74,75.72 135.63,74.83 137.1,74.83 137.46,75.19 139.77,75.19 140.39,75.8 144.27,75.8 145.53,74.54 145.62,74.45 145.62,73.17 146.84,71.95 149.23,71.95 149.75,71.43 151.51,71.43 155.04,67.9 155.04,57.25 157.35,54.94 158.57,54.94 163.39,50.12 v1(163.82,50.12)
  BOTTOM w0.076: v1(131.41,77.79) 131.41,78.1 131.18,78.28 130.21,78.28 130.06,78.23 129.84,78.23 129.66,78.25 129.5,78.25 CPU1.CN11
  BOTTOM w0.089: Q6503.1 180.1,18.75 v1(179.75,18.75) ; v1(175.51,11.28) 176.96,11.28 178.84,13.16 v1(178.84,14.1)
CPU_I2C_SCL_P1: length 92.1
  TOP w0.089: v1(56.51,90.61) 56.51,90.05 v2(56.51,90.05)
  L4 w0.114: v1(126.16,76.8) 126.65,76.3 127.16,76.3 127.42,76.05 127.42,75.71 127.13,75.42 124.91,75.42 124.33,74.83 121.96,74.83 121.64,74.51 120.28,74.51 120.07,74.72 113.69,74.72 112.01,76.41 108.93,76.41 108.1,77.24 107.08,77.24 104.82,79.5 104.82,82.12 103.33,83.62 103.33,85.91 103.78,86.37 103.78,87.14 102.46,88.47 94.86,88.47 93.87,89.46 78.81,89.46 78.07,90.2 71.77,90.2 71.34,89.77 63.6,89.77 62.25,91.11 57.02,91.11 v1(56.51,90.61)
  BOTTOM w0.089: v1(126.16,76.8) 126.67,77.31 CPU1.CJ12 ; R5555.2 56.43,87.36 EC5505.6 EC5505.5 56.61,88.7 56.61,90.51 v1(56.51,90.61) 56.51,90.64 56.56,90.68 LCD1.38
CPU_I2C_SDA_ISH0: length 35.7
  TOP w0.089: v1(152.06,75.57) 152.06,75.69 152.32,75.95 RN2007.1
  L4 w0.114: v1(126.99,70.69) 128.21,71.91 128.21,73.31 130.56,75.66 132.67,75.66 132.86,75.47 134,75.47 134.49,75.96 136.61,75.96 136.84,75.73 143.66,75.73 146.43,78.5 151.08,78.5 152.06,77.51 v1(152.06,75.57)
  BOTTOM w0.089: R2021.1 152.44,76.28 v2(151.3,76.28) 151.3,75.77 151.51,75.57 v1(152.06,75.57) ; CPU1.CK22 127.32,71.02 v1(126.99,70.69)
