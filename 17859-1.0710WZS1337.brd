# Allegro board 17859-1.0710WZS1337.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V0.85A_VID0: length 5
  BOTTOM w0.076: CPU1.CB36 122.76,61.91 122.76,61.76 122.74,61.69 122.74,60.32 122.5,60.07 122.5,58.95 123.53,57.92 TP2201.1
V0.85A_VID1: length 7.3
  BOTTOM w0.076: CPU1.CB35 122.71,62.59 122.49,62.36 122.49,62.17 122.46,62.08 122.46,61.84 122.49,61.75 122.49,61.68 122.5,61.67 122.5,61.66 122.57,61.59 122.57,60.4 122.31,60.14 122.31,58.87 122.77,58.4 122.77,57.79 123.84,56.73 123.85,56.73 124.06,56.53 124.06,56.51 124.09,56.47 TP2202.1
V3D3_STB: length 6.8
  TOP w0.203: v1(23.68,19.34) 23.68,19.32 23.77,19.23 U2701.16
  BOTTOM w0.254: v1(23.68,19.34) 22.74,19.34 v2(22.66,19.42) 22.45,19.64 21.71,19.64 21.05,20.3 21.05,21.52 21.79,22.25 R2708.2
VBUS_P_CTRL: length 70.7
  TOP w0.102: U7204.D7 76.51,98 76.27,97.77 v1(76.22,97.77) ; Q7404.2 27.6,79.76 28.67,78.7 v1(28.67,78.62)
  L3 w0.102: v1(76.22,97.77) 75.69,97.23 75.43,97.23 72.99,99.67 70.38,99.67 68.02,97.31 64.66,97.31 63.72,96.36 50.61,96.36 50.18,95.94 47.87,95.94 47.09,96.73 47.06,96.73 47.02,96.77 38.82,96.77 33.57,91.52 33.57,89.44 33.32,89.18 29.25,89.18 27.57,87.51 27.57,86.83 29.66,84.74 29.66,82.32 28.67,81.33 v1(28.67,78.62)
  BOTTOM w0.102: v2(27.78,77.85) 27.91,77.85 v1(28.67,78.62)
VBUS_P_CTRL_R: length 11.9
  TOP w0.127: Q7404.6 26.95,82.49 27.3,82.83 v1(27.54,82.83) 27.6,82.77 Q7404.5
  L4 w0.127: v1(27.54,82.83) 27.21,82.5 25.11,82.5 v1(23.72,81.1)
  BOTTOM w0.254: R7423.2 20.8,81.68 21.07,81.68 R7409.1 21.65,81.1 v1(23.72,81.1) ; v2(26.82,83.64) 27.54,82.92 v1(27.54,82.83)
VCC_SENSE: length 100.9
  TOP w0.254: v1(104.38,81.14) 104.46,81.14 104.97,80.62 v2(104.97,79.94) 104.01,79.94 R719.2
  L3 w0.254: v1(103.94,85.09) 102.9,84.05 97.48,84.05 93.24,88.29 69.88,88.29 69.07,87.48 51.04,87.48 49.78,86.22 49.78,82.9 48.76,81.88 48.76,77.09 47.54,75.87 47.54,74.17 43.16,69.79 v1(42.98,69.79)
  L6 w0.254: v1(103.94,85.09) 104.2,85.09 104.81,84.48 104.81,82.06 104.86,82.01 104.86,81.59 104.41,81.14 v1(104.38,81.14) ; v1(42.98,69.79) 42.95,69.75 42.08,69.75 42.03,69.7 40,69.7 37.84,67.54 35.08,67.54 34.26,68.35 32.93,68.35 32.04,67.47 30.9,67.47 v1(30.44,67.01)
  BOTTOM w0.254: v1(104.38,81.14) 104.62,81.14 CPU1.AN6 ; PR4665.1 30.44,65.72 v1(30.44,67.01)
VCCDSW_ON: length 208.2
  TOP w0.102: v1(210.99,25.22) 211.16,25.06 D2503.2 212.57,25.5 C2525.1 213.81,25.05 R2520.2 214.29,25.02 214.88,24.44 v2(215.06,24.44) ; U2401.88 29.93,40.51 v1(29.92,40.53)
  L6 w0.102: v1(173.53,31.96) 173.96,32.39 174.39,32.39 176.07,30.71 178,30.71 178.28,30.99 178.3,30.99 178.37,31.07 182.59,31.07 184.32,29.34 188,29.34 188.23,29.11 190.14,29.11 190.62,28.63 190.87,28.37 190.88,28.37 192.55,26.7 199.61,26.7 201.89,24.42 206.31,24.42 207.11,25.22 v1(210.99,25.22) ; v1(28.26,32.46) 28.3,32.5 28.38,32.5 29.23,33.35 29.23,34.04 28.98,34.29 28.77,34.29 28.49,34.57 28.49,37.98 29.92,39.4 v1(29.92,40.53)
  BOTTOM w0.102: v1(173.53,31.96) 172.76,31.19 155.23,31.19 154.47,30.43 54.87,30.43 53.5,31.8 52.14,31.8 49.42,34.52 47.7,34.52 47.09,35.13 43.56,35.13 41.64,33.22 40,33.22 39.4,32.62 37.96,32.62 35.93,30.58 35.22,30.58 34.64,31.17 29.61,31.17 28.32,32.46 v1(28.26,32.46)
VCCGT_SENSE: length 63
  TOP w0.254: v1(87.55,83.75) 87.5,83.7 87.02,83.7 87.01,83.7 86.94,83.7 85.87,82.63 85.87,81.22 R807.2 87.01,80.95 v2(87.07,81)
  L6 w0.254: v1(87.55,83.75) 87.65,83.75 87.9,83.49 87.9,83.11 87.54,82.76 85.87,82.76 85.39,82.27 80,82.27 78.4,80.67 74.52,80.67 70.23,84.97 67.13,84.97 65.73,86.36 57.07,86.36 56.36,85.65 52.9,85.65 51.78,84.54 51.78,81.48 50.01,79.71 46.12,79.71 43.2,76.79 42.52,76.79 41.84,76.11 v1(41.84,75.77)
  BOTTOM w0.254: v1(87.55,83.75) 87.55,83.72 87.52,83.69 CPU1.E3 ; PR4667.1 41.88,75.73 v1(41.84,75.77)
VCCIO_EN_R: length 14.4
  BOTTOM w0.102: R4039.1 165.7,69.09 165.93,69.32 R4003.2 165.68,70.69 R4037.2 164.36,69.8 163.87,70.28 163.72,70.28 162.94,69.5 R4017.2 160.95,69.11 v2(161.46,68.6) 161.51,68.55 C4033.1 161.97,67.16 161.97,65.99 160.94,64.96 U4002.4
VCCPD_VBUS_ACK: length 160.6
  TOP w0.254: v1(22.83,36.63) 23.29,36.17 23.29,33.99 24.05,33.23 v2(24.05,32.59) 24.05,29.97 v1(23.21,29.14) ; v1(92.3,4.96) 93.29,5.95 94.15,5.95 95.3,4.8 PQ4417.G
  L3 w0.254: v1(22.27,88.39) 22.63,88.04 22.63,85.25 21.79,84.41 21.79,80.24 23.1,78.93 23.1,73.75 21.48,72.14 21.48,69.45 20.9,68.86 20.9,67.87 20.06,67.03 20.06,63.99 20.62,63.43 20.62,62.31 21.13,61.8 21.13,53.83 19.22,51.92 18.87,51.56 18.87,50.88 20.09,49.66 20.09,45.44 21.89,43.64 21.89,42.42 22.24,42.07 22.24,39.09 22.83,38.51 v1(22.83,36.63) ; v1(39.01,18.39) 39.01,18.42 38.65,18.77 38.65,19.81 37.43,21.03 37.43,22.94 37.64,23.14 37.64,26.39 36.93,27.1 30.45,27.1 29.59,27.97 26.21,27.97 26.16,27.92 25.06,27.92 23.84,29.14 v1(23.21,29.14)
  L4 w0.254: v1(39.01,18.39) 39.01,18.4 39.64,19.03 46.46,19.03 51.66,13.83 51.66,12.91 57.8,6.76 57.8,5.97 58.54,5.24 58.85,5.24 59.91,4.17 91.51,4.17 v1(92.3,4.96)
  BOTTOM w0.254: U7419.A2 22.24,84.86 22.52,85.14 22.52,85.93 22.78,86.18 R7424.2
  BOTTOM w0.508: R7424.2 23.34,87.33 v1(22.27,88.39)
VCCRTCEXT: length 5
  TOP w0.254: C2201.1 115.49,73.03 115.36,72.9 v2(115.36,72.85) 115.36,71.76 v1(117.06,70.06)
  BOTTOM w0.203: v1(117.06,70.06) 117.06,69.98 CPU1.BP24
VCCSA_SENSE: length 94.3
  TOP w0.254: v1(112.69,80.49) 112.92,80.25 R810.2
  L3 w0.254: v1(50.34,65.89) 48.79,67.44 48.79,68.99 50.21,70.41 50.21,75.75 51,76.54 51,79.99 52.37,81.36 52.37,84.61 52.88,85.12 56.64,85.12 57.35,85.83 65.83,85.83 67.02,84.64 71.89,84.64 74.61,81.92 77.75,81.92 82.45,86.62 89.45,86.62 90.32,85.75 92.68,85.75 95.6,82.83 103.8,82.83 104.24,83.26 106.35,83.26 107.77,81.85 107.77,79.76 108.63,78.9 112.19,78.9 112.69,79.4 v1(112.69,80.49)
  BOTTOM w0.203: v1(112.69,80.49) 112.95,80.49 113.15,80.28 CPU1.BG7
  BOTTOM w0.254: v1(50.34,65.89) v2(50.34,66.47) 50.13,66.68 PR4601.2
VCCST_PWRGD: length 311.1
  TOP w0.127: v1(203.42,52.3) 202.99,51.87 D4002.A D4003.A ; R1716.1 114.14,93.98 114.39,94.24 ED1704.1 113.64,94.86 v1(113.53,94.74) ; R4002.1 41.93,63.25 43.28,61.9 v2(43.28,61.04) 42.84,60.61 42.84,59.64 42.72,59.51 v1(42.72,59.41) 42.74,59.39 43.53,59.39 R4005.2 R4011.2 44.15,56.71 42.79,55.35 R2421.1
  L3 w0.127: v1(87.37,100.46) 88.2,99.63 88.89,99.63 92.73,95.8 104.08,95.8 107.09,98.81 108.83,98.81 109.26,98.38 109.26,97.52 109.56,97.23 109.56,95.91 110.84,94.63 113.42,94.63 v1(113.53,94.74) ; v1(69.41,102.95) 67.46,102.95 62.68,98.17 39.24,98.17 32.46,91.39 27.29,91.39 24.29,88.39 24.29,83.3 24.82,82.78 24.82,80.69 25.44,80.06 25.44,78.69 24.12,77.37 24.12,77.35 24,77.22 24,73.13 24.25,72.88 24.25,72.39 24.02,72.16 24.02,66.45 25.92,64.55 25.92,60.02 23.95,58.05 23.95,55.17 v1(23.73,54.95)
  L4 w0.127: v1(42.72,59.41) 42.72,60.32 41.02,62.02 37.88,62.02 37.76,61.9 37.34,61.9 36.47,61.03 36.47,60.56 36.42,60.51 36.42,60.45 36.39,60.43 36.39,59.49 34.64,57.74 34.63,57.74 34.22,57.33 33.67,57.33 33.4,57.05 33.4,57.02 32.91,56.53 30.11,56.53 29.47,57.17 26.3,57.17 24.09,54.95 v1(23.73,54.95) ; v1(76.12,105.44) 76.35,105.67 82.47,105.67 83.33,104.8 83.84,104.8 84.09,105.06 85.64,105.06 87.37,103.33 v1(87.37,100.46)
  L6 w0.127: v1(113.53,94.74) 115.16,93.11 122.06,93.11 126.32,88.85 139.33,88.85 142.56,85.62 142.56,83.83 143.05,83.34 145.41,83.34 146.3,82.45 147.67,82.45 149.9,80.22 151.49,80.22 162.02,69.69 162.02,68.79 165.28,65.53 165.28,60.03 164.32,59.07 164.32,58.7 164.59,58.42 165.92,58.42 166.19,58.16 172.24,58.16 177.41,63.32 179.7,63.32 180.77,64.39 188.64,64.39 189.66,63.38 193.31,63.38 194.48,62.21 198.01,62.21 198.19,62.03 198.19,60.76 199.61,59.34 199.61,58.42 203.42,54.61 v1(203.42,52.3)
  BOTTOM w0.127: v1(69.41,102.95) 69.41,105.59 70.94,107.11 74.44,107.11 v1(76.12,105.44)
VCCST_PWRGD_R: length 26.4
  TOP w0.127: R1718.1 111.3,92.89 111.8,92.38 v2(112.01,92.38) 112.11,92.48 112.11,92.87 111.98,92.99 C1711.1 112.69,93.17 R1719.1 R1716.2 114.23,93.12 ED1704.2 114.39,92.89 v1(115.23,92.05)
  L4 w0.127: v1(115.23,92.05) 114.8,92.48 111.12,92.48 110.51,91.87 110.51,90.55 108.93,88.97 108.93,85.09 109.9,84.12 111.06,84.12 112.04,85.09 112.45,85.09 112.76,85.4 113.48,85.4 114.11,84.76 114.11,84.29 v1(113.72,83.9)
  BOTTOM w0.127: CPU1.BJ2 113.99,83.9 v1(113.72,83.9)
VCCSTG_EN_L: length 2.1
  BOTTOM w0.102: R4037.1 164.79,71.2 164.94,71.35 v2(164.94,71.68) 164.71,71.92 U4007.4
VCCSTU_EN_R: length 6.1
  BOTTOM w0.127: R4024.2 109.06,100.99 C4034.1 110.56,101.55 111.2,101.55 112.01,102.36 112.8,102.36 112.92,102.49 v2(112.92,102.75) 112.92,102.9 112.78,103.04 U4006.4
VDD: length 32.6
  TOP w0.254: v1(161.64,8) 161.16,7.52 PC4422.1 161.16,5.72 PR4405.2 161.63,5.25 161.63,4.3 160.91,3.58 159.33,3.58 v1(159.1,3.81) 159.71,4.42 v1(159.89,4.42) ; v1(170.89,5.24) 170.86,5.24 170.68,5.41 169.49,5.41 ; v1(154.4,5.31) 154.07,5.31 v2(153.79,5.59) 153.79,5.97 PR4448.1
  L4 w0.254: v1(170.89,5.24) 169.34,5.24 168.27,4.17 164.61,4.17 163.77,3.33 161.64,3.33 161.44,3.53 159.38,3.53 v1(159.1,3.81)
  BOTTOM w0.203: v1(161.64,8) 161.64,8.15 161.29,8.49 PU4401.18
  BOTTOM w0.254: v1(159.89,4.42) 159.91,4.45 159.91,6.07 PR4429.1 ; v1(159.1,3.81) 158.52,3.81 157.08,5.26 154.48,5.26 154.43,5.31 v1(154.4,5.31)
VSS_SENSE: length 98.6
  TOP w0.254: v1(31.31,66.86) 31.31,66.4 v2(31.62,66.09) ; v1(104.03,82.1) 104.03,81.58 103.53,81.09 103.31,81.09 103.03,80.8 R720.1
  L3 w0.254: v1(42.31,69.24) 43.17,69.24 47.92,73.99 47.92,75.69 49.14,76.91 49.14,81.72 50.16,82.74 50.16,86.06 51.2,87.1 69.23,87.1 70.04,87.91 93.08,87.91 97.32,83.67 103.23,83.67 v1(103.97,84.41)
  L6 w0.254: v1(42.31,69.24) 42.23,69.32 40.16,69.32 38,67.16 34.92,67.16 34.11,67.97 33.09,67.97 31.99,66.87 31.32,66.87 v1(31.31,66.86) ; v1(103.97,84.41) 104.17,84.41 104.42,84.15 104.42,82.49 v1(104.03,82.1)
  BOTTOM w0.254: PR4666.1 30.98,67.18 v1(31.31,66.86) ; CPU1.AN5 104.62,81.79 104.34,81.79 v1(104.03,82.1)
VSSGT_SENSE: length 65.6
  TOP w0.254: v2(84.4,81.38) 84.65,81.38 85.08,80.95 R808.1 85.49,81.12 85.49,82.79 86.78,84.08 86.84,84.08 87.11,84.34 v1(87.11,84.91)
  L6 w0.254: v1(42.82,75.83) 42.82,76.15 43.07,76.41 43.36,76.41 46.28,79.33 50.17,79.33 52.17,81.32 52.17,84.38 53.05,85.27 56.51,85.27 57.23,85.98 65.57,85.98 66.97,84.58 70.07,84.58 74.36,80.29 78.56,80.29 80.16,81.89 85.55,81.89 86.03,82.37 87.7,82.37 88.28,82.96 88.28,83.74 v1(87.11,84.91)
  BOTTOM w0.089: v1(87.11,84.91) 87.18,84.84 87.18,84.1 87.03,83.95 CPU1.D2
  BOTTOM w0.254: v1(42.82,75.83) 42.7,75.71 PR4668.1
VSSSA_SENSE: length 98.4
  TOP w0.254: R809.1 112.25,79.19 112.25,80.04 111.8,80.49 v1(111.77,80.49)
  L3 w0.254: v1(111.77,80.49) 111.8,80.49 112.25,80.04 112.25,79.64 111.97,79.35 108.8,79.35 108.2,79.95 108.2,82.07 106.5,83.77 103.82,83.77 103.37,83.33 95.84,83.33 92.91,86.26 90.7,86.26 89.85,87.11 82.22,87.11 77.54,82.43 74.82,82.43 72.1,85.14 67.25,85.14 66.06,86.34 57.08,86.34 56.42,85.68 52.72,85.68 51.86,84.82 51.86,81.64 50.49,80.27 50.49,76.76 49.09,75.36 49.09,70.03 48.28,69.22 48.28,67.21 50.13,65.36 50.54,65.36 50.57,65.38 50.65,65.38 v1(50.93,65.66)
  BOTTOM w0.203: CPU1.BE7 112.23,80.28 112.03,80.49 v1(111.77,80.49)
  BOTTOM w0.254: PR4602.2 49.61,65.92 49.83,65.7 49.83,65.68 50.13,65.38 50.64,65.38 50.92,65.66 v1(50.93,65.66) 50.95,65.64 v2(51.63,65.64)
0D6V_S0: length 5.8
  BOTTOM w0.279: DM2.258 175.14,21.78 v1(175.81,22.46) ; v1(99.69,21.19) 98.44,21.19 98.13,20.88 DM1.258
  vias: v1(58.21,15.6) v1(58.34,14.96) v1(74.42,17.73) v1(75.2,17.73) v1(99.69,21.92) v2(176.37,22.33)
1D0V_PWR:
  vias: v2(150.17,59.44) v3(149.96,57.03) v3(150.95,57) v3(151.96,57) v3(152.9,60.18) v3(152.93,59.08) v3(152.95,57.99)
1D0V_S5: length 132.1
  TOP w0.508: v3(115.72,94.85) 115.82,94.85 115.88,94.79 116.94,94.79 R2205.1 ; v1(28.92,34.75) 28.92,34.67 29.23,34.37 R2402.1
  L3 w0.508: v1(121.94,94.97) 121.94,94.82 121.28,94.16 116.59,94.16 115.9,94.85 v3(115.72,94.85)
  L6 w0.305: v1(119.68,74.27) 119.68,74.6 119.22,75.06 118.19,75.06 116.59,76.66 104.82,76.66 103.55,75.39 103.55,69.45 103.17,69.07 101.79,69.07 100.93,69.93 100.93,70.05 100.58,70.41 91.87,70.41 90,72.27 75.78,72.27 61.55,58.04 58.62,58.04 57.68,57.1 56.74,57.1 56.26,57.58 53.6,57.58 50.84,54.83 50.84,53.44 49.79,52.38 48.15,52.38 47.85,52.07 46.33,52.07 45.53,51.27 45.53,50.37 45.61,50.29 45.61,49.56 45.15,49.09 44.48,49.09 44.31,48.92 43.01,48.92 42.78,49.15 42.12,49.15 41.76,48.79 37.12,48.79 33.73,45.39 33.17,45.39 31.41,43.64 31.41,39.92 30.75,39.26 30.75,37.19 29.86,36.3 29.86,35.61 29.56,35.31 29.23,35.31 28.92,35 v1(28.92,34.75)
  vias: v1(117.75,71.75) v1(118.38,73.41) v1(119.02,73.41) v1(119.02,72.6) v1(119.65,72.57) v1(119.68,73.41) v1(119.68,71.76) v1(120.31,73.41) v1(120.31,72.57) v1(120.32,71.76) v1(120.97,71.76) v1(121.63,72.6) v1(121.63,71.76) v1(122.29,75.93) v1(151.25,54.54) v1(151.99,54.56) v1(152.62,54.56) v1(153.26,54.56) v1(153.76,55.04) v1(153.92,54.41) v1(161.6,63.69) v1(161.6,63.05) v1(161.6,62.42) v2(112.31,106.35) v2(113.91,107.67) v3(110.99,102.24) v3(148,89.03) v3(169.13,63.96)
1D0V_S5_PWRGD: length 79.9
  TOP w0.127: R4029.1 204.01,44.12 204.01,43.51 203.5,43 202.75,43 v2(202.2,42.45) 200.11,40.37 v1(197.66,40.37)
  L6 w0.127: v1(197.66,40.37) 196.72,41.31 184.26,41.31 183.61,41.96 181.27,41.96 174.49,48.74 169.92,48.74 169.91,48.73 169.53,48.73 169.18,49.08 162.33,49.08 154.4,57.01 154.4,67.69 151.29,70.79 148.31,70.79 v1(147.97,71.13)
  BOTTOM w0.127: v1(147.97,71.13) 147.92,71.13 147.01,72.04 147.01,72.52 PR5206.1
1D0V_VCCA_XTAL: length 43.1
  TOP w0.406: v1(131.15,81.2) 131.15,81 130.74,80.6 130.05,80.6 C2219.1
  TOP w0.508: v1(141.22,89.23) 141.22,88.27 142.31,87.18 142.31,83.67 141.14,82.5 141.14,82.37 v1(140.94,82.17) ; R2202.2 124.68,92.71 v1(124.76,92.79) 125.14,93.17 v2(125.14,93.42)
  L3 w0.508: v1(131.15,81.2) 131.24,81.1 133.75,81.1 135.33,79.53 137.54,79.53 138.45,80.44 139.6,80.44 140.94,81.78 v1(140.94,82.17)
  BOTTOM w0.305: CPU1.CP5 130.46,81.89 v1(131.15,81.2)
  BOTTOM w0.508: v1(141.22,89.23) 139.47,90.99 127.65,90.99 126.51,92.13 126.36,92.13 125.69,92.79 v1(124.76,92.79)
1D0V_VCCAMPHYPLL: length 22.1
  TOP w0.508: v1(116.73,92) 116.94,92 R2205.2 C2208.1 120.04,92.74 C2209.1 120.14,92.84 v2(121.23,92.84)
  L4 w0.457: v1(116.73,92) 116.73,91.8 116.35,91.42 113.28,91.42 112.74,90.88 112.74,89.82 113.1,89.46 117.98,89.46 119.8,87.64 v1(119.8,85.96)
  BOTTOM w0.152: v1(119.8,85.96) 119.81,85.95 CPU1.BV2
1D0V_VCCDSW: length 2.3
  TOP w0.254: C2213.1 118.12,68.88 118.41,69.17 v2(118.41,69.29) 118.94,69.29 v1(119.02,69.22)
  BOTTOM w0.203: v1(119.02,69.22) 118.99,69.24 118.99,69.35 CPU1.BT24
1D0V_VCCPRIM_MPHY:
  vias: v1(119.65,76.79) v1(120.31,77.6) v2(120.36,78.16)
1D2V_S3: length 200.7
  TOP w0.254: v1(175.43,31.96) 174.9,32.49 173.97,32.49 171.31,35.15 171.31,35.28 170.56,36.02 169.84,36.02 167.28,38.59 148.58,38.59 148.03,39.14 148.03,41.25 147.95,41.33 147.95,41.53 147.29,42.19 R505.1
  L6 w0.508: v1(114.05,61.09) 112.67,62.47 v1(112.67,64.98)
  BOTTOM w0.114: v1(103.82,60.98) 103.83,60.99 103.83,62.05 ; v1(101.3,61.01) 101.32,61.03 101.32,62.05 101.32,62.05 ; 108.87,62.05 v1(108.87,61.05) ; v1(96.29,60.96) 96.29,60.98 96.29,60.99 96.29,61.74 96.28,61.76 96.28,62.05 ; 98.8,62.05 v1(98.8,61.04)
  BOTTOM w0.127: CPU1.R32 93.03,64.15 v1(92.99,64.11) ; v1(101.3,61.01) 101.17,60.88 101.17,60.21 101,60.04 101,59.51 100.64,59.15 v1(100.62,59.15)
  BOTTOM w0.203: v1(112.67,64.98) 112.67,64.98 112.61,64.98 112.26,64.63 CPU1.BE32
  BOTTOM w0.254: 113.9,62.05 113.97,61.97 113.97,61.17 v1(114.05,61.09) ; v1(135.37,24.32) 134.92,24.77 134.92,25.15 136.39,26.61 DM2.111 ; v1(101.65,65.65) 101.62,65.62 101.62,65.02 CPU1.AH32 ; v1(108.97,64.98) 108.63,64.63 CPU1.AW32 ; v1(105.28,64.97) 105.28,64.97 105.27,64.94 CPU1.AN32
  BOTTOM w0.279: DM2.130 v1(141.14,21.76) ; DM1.136 65.64,19.75 65.64,20.91 65.36,21.19 v1(65.3,21.19) ; DM2.12 111.64,20.87 111.2,21.31 v1(111.2,22.2) ; DM1.129 63.89,25.51 62.1,23.73 v1(62,23.73) ; v1(39.36,24.34) 39.91,24.89 39.91,26.18 39.88,26.21 DM1.33 ; v1(132.38,21.54) 132.63,21.29 DM2.96 ; DM2.112 136.63,20.91 v1(135.87,21.67) ; v1(60.73,21.34) 61.14,20.93 DM1.118 ; DM2.160 v1(150.63,21.36) ; v1(74.54,22.02) 74.42,22.02 73.63,21.24 DM1.160 ; DM1.135 65.38,25.19 v1(65.27,25.07) ; v1(59.17,21.29) 59.64,20.82 59.64,19.75 DM1.112 ; v1(62.07,25.73) 62.07,26.49 62.38,26.81 DM1.123 ; v1(70.52,21.29) 70.52,21.26 70.64,21.15 70.64,19.75 DM1.148 ; v1(72.43,22.74) 72.41,22.74 71.96,23.19 71.96,23.31 70.38,24.88 DM1.147 ; DM2.147 147.39,27.13 147.79,26.72 147.79,25.75 v1(147.3,25.26) ; DM1.117 60.89,26.93 60.64,26.69 60.64,25.37 v1(60.12,24.84) ; v1(142.12,22.8) 142.82,22.1 142.82,21.25 142.63,21.07 DM2.136 ; v1(136.57,25.05) 136.57,25.22 137.89,26.54 DM2.117 ; DM2.129 140.89,24.79 140,23.9 v1(139.74,23.9) ; DM2.153 148.89,26.73 149.07,26.55 v1(149.07,26.52) ; DM1.111 59.38,26.21 58.24,25.07 v1(57.98,25.07) ; v1(137.47,22.16) 138.14,21.49 DM2.118 ; DM1.124 62.63,21.41 62.2,21.85 v1(62.1,21.85) ; v1(35.67,24.08) 34.59,23 34.59,20.75 34.63,20.7 DM1.12 ; v1(50.31,25.12) 50.38,25.2 DM1.75 ; DM2.154 149.14,21.43 v1(149.11,21.46) ; DM2.220 165.64,21.55 v1(165.73,21.64) ; DM2.123 139.39,26.77 139.29,26.67 139.29,25.85 139.76,25.38 v1(139.77,25.38) ; v1(142.08,25.46) 142.2,25.46 142.64,25.9 142.64,26.75 142.39,27 DM2.135 ; v1(94.15,25.22) 94.07,25.31 94.07,26.48 93.89,26.66 DM1.241 ; v1(159.92,25.65) 159.99,25.65 160.42,26.09 160.42,26.72 160.38,26.76 DM2.199 ; v1(77.85,22.1) 77.85,21.06 78.13,20.77 DM1.178 ; 116.88,27.95 116.88,25.15 v1(117.74,24.3) ; v1(45.85,21.44) 45.14,20.73 DM1.54 ; DM1.163 74.38,25.8 74.54,25.65 74.54,25.58 v1(74.57,25.56) ; DM1.159 73.38,25.21 74.42,24.18 v1(74.57,24.18) ; v1(71.85,25.38) 71.88,25.41 71.88,25.47 72.15,25.75 72.15,26.68 72.04,26.79 72.04,26.8 71.89,26.95 DM1.153 ; DM2.178 155.14,21.2 155.11,21.22 155.11,21.63 155.58,22.1 v1(155.65,22.1) ; DM1.130 64.14,20.77 64.28,20.91 64.28,21.42 64.22,21.47 64.22,21.51 63.91,21.82 63.88,21.82 63.77,21.92 v1(63.72,21.92) ; v1(67.2,26.29) 66.89,26.61 DM1.141 ; DM2.141 143.89,26.67 v1(144.06,26.5) ; DM2.75 127.39,26.61 127.41,26.58 127.41,26.15 126.99,25.73 v1(126.92,25.73) ; v1(143.96,21.41) 144.14,21.24 DM2.142 ; v1(139.09,22.11) 139.18,22.11 139.65,21.64 139.65,21.21 139.63,21.19 DM2.124 ; DM2.159 150.39,25.85 150.69,25.54 150.69,25.48 151.11,25.06 v1(151.2,25.06) 151.32,25.06 151.74,25.48 151.74,26.54 151.39,26.89 DM2.163 ; DM1.220 88.64,20.94 88.41,21.16 v1(88.41,21.9) ; v1(67.13,21.29) DM1.142 ; DM1.199 83.38,26.85 83.08,26.54 v1(83.08,25.76) ; DM2.241 170.89,26.49 v1(170.71,26.32) ; v1(147.67,21.62) 147.63,21.58 DM2.148 ; DM1.154 v1(72.13,21.29) ; DM2.54 v1(122.14,21.49) ; v1(55.63,21.44) DM1.96
  vias: v1(57.98,23.8) v1(59.17,22.56) v1(67.17,22.9) v1(67.84,24.48) v1(72.36,24.31) v1(92.11,56.95) v1(94.14,55.41) v1(135.81,22.94) v1(137.19,23.33) v1(139.95,22.89) v1(141.04,23.07) v1(142.08,24.13) v1(143.94,23.44) v1(144,24.41) v1(147.72,23.68) v1(149.09,24.11) v1(149.12,22.74) v1(150.62,23.17) v1(158.44,53.62) v1(158.88,53.16) v1(163.27,61.06) v1(163.34,44.33) v1(163.72,60.61) v1(164.23,44.17) v1(170.76,40.26) v1(177.34,26.29) v1(177.34,25.66) v2(34.69,19.59) v2(37.13,15.83) v2(65.78,50.57) v2(67.3,28.2) v2(91.74,19.15) v2(96.18,65.51) v2(101.01,48.59) v2(116.02,28.45) v2(136.85,27.43) v2(160.7,21.31) v2(162.73,59.69) v2(165.45,44.88) v2(174.54,27.33) v3(34.56,17.96) v3(35.17,17.33) v3(35.4,18.24) v3(35.83,16.67) v3(36.09,17.5) v3(36.72,16.69) v3(63.39,51.11) v3(63.62,51.95) v3(64.05,50.52) v3(64.46,51.77) v3(64.76,50.98) v3(65.17,52.25)
1D2V_VCCSFR_OC: length 63.5
  TOP w0.305: v2(157.35,71.5) 157.75,71.5 v1(157.93,71.68)
  TOP w0.508: C803.2 113.94,68.28 114.67,67.54 v1(115.41,67.54)
  L3 w0.508: v1(157.93,71.68) 157.78,71.68 153.04,76.42 149.74,76.42 149.65,76.33 148.1,76.33 146.88,75.11 137.33,75.11 135.68,76.77 134.58,76.77 133.85,77.5 133.67,77.5 133.04,78.13 132.53,78.13 132.17,78.49 129.03,78.49 128.19,77.65 ; v1(115.41,67.54) 115.41,68.07 116.43,69.09 116.43,69.78 116.42,69.79 116.42,69.8 115.97,70.24 115.97,75.82 116.72,76.57 118.78,76.57 119.18,76.17 121.45,76.17 122.25,76.97 122.94,76.97
  L4 w0.508: v1(157.93,71.68) 161.01,68.6 v1(163.69,68.6)
  BOTTOM w0.305: v1(115.41,67.54) 115.46,67.54 115.8,67.88 CPU1.BL27 115.81,67.89 CPU1.BM26
  BOTTOM w0.508: R4043.2 163.66,68.63 v1(163.69,68.6)
1D2V_VTT_PWRGD: length 56.3
  TOP w0.102: R4011.1 43.29,57.33 v1(43.68,56.94) 43.68,56.8 v2(43.35,56.47)
  L3 w0.102: v1(60.07,13.79) 60.07,15.62 58.44,17.25 57.84,17.25 57.09,18 57.09,18.06 54.35,20.81 52.73,20.81 52.24,21.3 52.24,26.55 49.08,29.71 49.08,34.64 48.53,35.18 48.53,35.21 47.97,35.77 47.95,35.77 46.91,36.81 46.91,39.4 45.08,41.23 45.08,41.89 46.45,43.26 46.45,43.56 46.93,44.05 46.93,51.67 46.68,51.92 45.66,51.92 45.05,52.53 45.05,55.57 v1(43.68,56.94)
  BOTTOM w0.102: v1(60.07,13.79) 60.01,13.74 PR5109.1
1D8V_AON_S0_DISCHG: length 2.6
  BOTTOM w0.102: Q8608.3 164.01,98.9 v2(164.08,98.83) 164.23,98.83 165.14,99.75 R8644.2
1D8V_CPVDD: length 5.6
  TOP w0.203: v1(20.83,14.52) 20.92,14.6 U2701.29
  BOTTOM w0.406: v2(20.72,13.7) 20.72,13.76 20.83,13.87 v1(20.83,14.52) 20.83,15.27 20.48,15.62 R2709.2 19.68,15.62 19.22,15.17 C2704.1
  BOTTOM w0.508: v1(20.83,14.52) 21.34,14.52 C2705.1
1D8V_EN#: length 3.1
  TOP w0.102: R2738.1 R2736.2 58.57,50.27 v2(58.08,49.79) 57.73,50.14 57.57,50.14 Q2705.D
1D8V_EN_R#: length 11.5
  TOP w0.102: C2738.2 61.16,52.63 61.16,51.69 v1(61.03,51.56) 61.23,51.56 61.41,51.39 61.64,51.39 62.27,50.75 62.27,50.45 61.34,49.51 v2(61.06,49.51) R2738.2
  BOTTOM w0.102: v1(61.03,51.56) 60.5,52.1 60.5,52.83 58.34,54.99 Q2704.G
1D8V_PWR:
  vias: v2(85.77,14.81) v3(84.53,15.6) v3(85.41,15.57)
1D8V_S0: length 225.9
  TOP w0.254: v1(67.48,44.07) 68.19,43.36 73.55,43.36 78.59,38.32 100.23,38.32 101.28,39.37 113.43,39.37 v2(113.92,38.88) 114.22,38.59 121.12,38.59 122.27,39.74 122.27,45.24 121.86,45.65 121.25,45.65 121.03,45.88 120.34,45.88 120.06,46.15 R2052.1
  L3 w0.305: v1(19.53,81.74) 20.52,82.73 20.52,84.66 21.61,85.75 21.61,87.18 21.2,87.58 21.2,90.55 v1(21.18,90.58)
  L4 w0.508: v1(16.43,42.34) 17.65,42.34 20.5,45.19 22.68,45.19 23.57,46.08 25.07,46.08 26.13,47.15 v1(26.87,47.15) ; v1(12.47,72.09) 12.8,72.42 12.8,78.03 16.51,81.74 v1(19.53,81.74)
  L6 w0.305: v1(20.14,95.51) 20.14,95.48 19.65,95 19.65,92 21.08,90.58 v1(21.18,90.58)
  L6 w0.508: v1(57.12,57.97) 56.97,58.12 53.34,58.12 51.12,55.89 49.79,55.89 48.46,54.57 45.32,54.57 44.3,53.55 41.58,53.55 41.02,52.99 39.9,52.99 39.75,52.83 39.15,52.83 36.35,50.04 36.35,49.16 33.46,46.26 32.35,46.26 30.75,44.66 29.7,44.66 29.29,44.24 ; v1(12.47,72.09) 12.19,71.81 12.19,57.25 11.22,56.29 11.22,54 11.73,53.5 12.49,53.5 13.38,52.61 13.38,43.26 14.14,42.5 v1(14.14,41.84) ; v1(18.71,14.33) 18.98,14.33 19.82,15.17 21.1,15.17 21.69,14.58 26.06,14.58 28.67,17.19 28.67,19.99 27.02,21.64 27.02,21.8 26.16,22.66 26.16,23.12 24.05,25.22 24.05,31.12 24.81,31.88 24.81,33.94 25.39,34.52 25.39,38.2 25.34,38.26 25.34,39.5 25.39,39.55 25.39,39.73 28.32,42.65 28.32,43.27 29.29,44.24 ; 29.29,44.24 28.32,45.22 28.32,45.77 26.94,47.15 v1(26.87,47.15)
  BOTTOM w0.305: R6401.1 v1(20.14,95.51)
  BOTTOM w0.508: v1(14.14,41.84) 15.92,41.84 v1(16.43,42.34)
  vias: v1(57.75,57.97) v1(66.85,43.97) v3(171.08,96.13) v3(176.68,69.95)
1D8V_S5: length 199
  TOP w0.305: R6115.1 204.11,52.83 203.19,52.83 202.74,52.38 v1(202.74,52.35)
  TOP w0.381: 128.57,71.2 128.57,72.01 128.19,72.39 128.19,73.1 127.97,73.32 R2029.1
  TOP w0.406: R2497.2 41.12,55.4 C6402.1 39.54,55.37 R2462.1 39.13,55.27 38.56,54.7 v1(38.56,54.54)
  TOP w0.508: v1(33.15,58.64) 33.15,58.5 32.54,57.89 31.2,57.89 U6402.5 ; R1515.1 146.24,62.28 146.27,62.25 v1(146.37,62.25) ; 128.99,70.98 130.16,70.98 130.21,71.03 132.69,71.03 132.98,70.74 133.7,70.74 135,72.04 139.71,72.04 139.99,71.76 143.58,71.76 143.63,71.71 143.64,71.71 144.2,71.15 145.64,71.15 146.15,70.64 R1104.1 146.15,69.62 145.76,69.24 145.76,68.28 v1(145.73,68.24)
  L4 w0.127: 120.75,71.33 121.91,71.33
  L4 w0.356: v1(162.86,55.7) 161.69,54.54 155.42,54.54 154.32,53.44 151.4,53.44 145.97,58.88 145.97,61.65 146.37,62.05 v1(146.37,62.25)
  L4 w0.508: 116.73,70.89 113,70.89 112.03,69.93 112.03,69.24 111.45,68.66 101.49,68.66 101.09,69.07 95.27,69.07 v1(94.58,69.75)
  L6 w0.356: v1(164.66,57.97) 164.92,57.97 165.26,57.62 172.27,57.62 176.88,62.23 179.17,62.23 180.96,64.02 188.42,64.02 189.55,62.89 192.74,62.89 195.48,60.15 198.27,60.15 199.23,59.18 199.23,57.13 200.17,56.19 200.17,54.92 v1(202.74,52.35)
  L6 w0.457: v1(94.58,69.75) 98.9,69.75 99.54,69.11 101.09,69.11 101.6,68.6 116.69,68.6 116.88,68.79 117.36,68.79 117.51,68.63 123.13,68.63 123.5,69 123.5,69.67 v1(124.43,70.61)
  L6 w0.508: v1(38.56,54.54) 38,55.1 34.22,55.1 32.35,56.97 32.35,57.5 33.15,58.31 v1(33.15,58.64)
  BOTTOM w0.356: v1(164.66,57.97) 164.61,57.97 164.13,57.48 164.13,56.97 v1(162.86,55.7)
  BOTTOM w0.508: v1(146.37,62.25) 146.27,62.36 145.13,62.36 144.19,63.3 144.19,66.7 v1(145.73,68.24) ; v1(55.11,54.31) 54.91,54.51 52.9,54.51 52.37,53.98 49.45,53.98 48.86,54.57 46.86,54.57 46.07,53.77 41.99,53.77 41.56,53.34 39.75,53.34 v1(38.56,54.54)
  vias: v1(55.75,54.31) v1(61.11,50.93) v1(61.49,50.42) v1(67.35,50.47) v2(59.71,52) v2(126.66,70.18) v3(82.52,17) v3(83.48,17)
1D8V_S5_KBC: length 4.5
  TOP w0.203: C2423.1 39.14,53.32 v2(38.55,52.73) 38.09,52.28 37.56,52.28 37.18,51.9 U2401.54
  TOP w0.508: C2423.1 39.14,54.1 R2462.2
1D8V_VCCPRIM: length 128.9
  TOP w0.305: v1(123.72,41.4) 123.77,41.46 123.77,46.03 v1(123.72,46.08) ; R1738.1 121.87,52.33 121.87,51.24 v1(121.76,51.13) ; R1512.1 112.62,48.03 113.1,48.52 113.1,49.27 v1(113.38,49.55)
  TOP w0.356: R1821.1 134.28,40.34 133.85,40.78 133.85,41.4 v1(133.82,41.43)
  TOP w0.508: v1(130.3,74.22) 130.27,74.22 130.09,74.4 C2210.1 ; C2211.1 130.72,70.23 v1(130.73,70.24) 130.75,70.26 132.48,70.26 132.84,69.9 133.87,69.9 134.84,70.87 136.65,70.87 137.01,70.51 137.72,70.51 138.32,71.11 ; 138.32,71.11 v1(138.32,71.25) ; 138.32,71.11 138.32,70.79 138.86,70.26 141.27,70.26 v1(141.32,70.31) 141.83,69.8 142.34,69.8 142.77,70.23 144.82,70.23 144.88,70.18 C1122.1 ; v1(136.9,41.38) 137.48,41.38 139.31,43.21 139.31,44.53 138.02,45.82 138.02,48.42 138.25,48.64 v2(138.25,49.91) v1(138.25,51.74) ; v1(138.25,51.74) 138.07,51.92 R2053.1 ; v1(138.25,51.74) 138.75,52.25 138.75,53.88 139.26,54.38 140.25,54.38 v1(141.04,53.6)
  L3 w0.305: v1(130.3,74.22) 130.27,74.22 130.22,74.27 124.33,74.27 123.59,73.53 v1(123.59,73.41)
  L6 w0.508: v1(141.04,53.6) 140.76,53.88 140.76,54.43 138.12,57.08 136.05,57.08 133.34,59.78 133.34,63.25 134.79,64.7 v1(134.79,66.58)
  BOTTOM w0.203: CPU1.CP23 130.54,70.43 v1(130.73,70.24)
  BOTTOM w0.305: v1(130.3,74.22) 129.52,74.22 CPU1.CP17 ; v1(123.72,46.08) 123.72,47.37 122.26,48.83 122.26,50.63 v1(121.76,51.13)
  BOTTOM w0.508: R2111.1 141.24,69.55 141.24,70.23 ; 141.24,70.23 141.19,70.18 R2115.1 ; 141.24,70.23 v1(141.32,70.31) ; R2117.1 138.76,70.53 138.32,70.97 v1(138.32,71.25) ; v1(113.38,49.55) 113.38,48.59 114.07,47.91 115.51,47.91 116.07,47.35 116.07,46.26 118.31,44.02 120.19,44.02 122.76,41.46 123.67,41.46 v1(123.72,41.4) 124.86,40.26 132.65,40.26 v1(133.82,41.43) 134.5,40.74 136.27,40.74 v1(136.9,41.38) ; v1(138.25,51.74) 138.25,51.97 137.46,52.76 135.62,52.76 135.11,53.27 132.79,53.27 131.87,54.18 R2113.1 ; v1(130.73,70.24) 130.74,70.25 131.75,70.25 132.28,69.73 132.91,69.73 133.88,68.76 134.28,68.76 135.08,67.96 135.08,66.87 v1(134.79,66.58)
  vias: v1(123.57,72.6)
1D8V_VGA_EN: length 2.2
  BOTTOM w0.102: R8603.1 170.15,98.55 v2(170.15,98.28) 169.31,98.28 R8629.2
1D8V_VGA_EN_OR: length 6.1
  BOTTOM w0.102: Q8602.D 167.3,101.32 168.9,99.72 168.9,98.88 R8629.1 R8637.2 168.14,97.36 v2(167.13,97.36)
1D8V_VGA_EN_OR#: length 19
  TOP w0.102: v1(166.41,100.8) 165.88,101.34 v2(165.88,101.72) 165.88,104.17 165.4,104.65 v1(165.37,104.65)
  BOTTOM w0.102: Q8603.G 165.37,104.38 v1(165.37,104.65) ; v1(166.41,100.8) 167.11,100.8 168.25,99.66 Q8602.G 167.68,98.75 167.68,97.99 167.41,97.72 166.98,97.72 166.77,97.51 166.77,97.21 167.03,96.95 170.07,96.95 170.34,96.69 Q8606.6 170.34,95.95 169.72,95.33 169.39,95.33 169.04,94.98 Q8606.3 169.04,93.36 R8634.2
1D8V_VGA_EN_R: length 3.5
  BOTTOM w0.102: R8603.2 170.23,99.34 C8602.1 170.35,100.03 170.96,99.42 v2(171.24,99.42) 171.44,99.42 171.65,99.63 U8601.3
1D8V_VGA_PLL: length 0.5
  BOTTOM w0.356: 181.13,78.04 v1(181.52,78.42)
  vias: v2(180.97,83.14)
1D8V_VGA_S0_DISCHG: length 3.7
  BOTTOM w0.102: v2(162.6,102.06) 163.04,102.49 R8647.2 164.28,101.8 Q8603.D
1D24V_VCCDPHY_EC: length 3.4
  TOP w0.305: v2(129.56,68.02) 129.48,68.1 C2218.1
  TOP w0.508: C2218.1 130.38,69.19 v1(130.55,69.02)
  BOTTOM w0.203: v1(130.55,69.02) 130.44,69.13 129.59,69.13 129.53,69.14 CPU1.CP25
1D35V_PGOOD: length 96.9
  TOP w0.102: v1(178.45,54) 178.35,54.1 178.35,57.28 178.23,57.41 PR8635.1
  L4 w0.102: v1(170.4,62.36) 171.37,62.36 172.54,61.19 172.54,60.51 178.1,54.94 178.1,54.36 v1(178.45,54)
  L6 w0.102: v1(112.52,100.6) 112.55,100.64 113.47,100.64 114.85,99.26 114.85,98.55 117.04,96.37 122.44,96.37 124.37,94.44 125.6,94.44 128.95,91.09 144.09,91.09 146.32,88.85 146.32,86.3 146.59,86.03 146.6,86.03 147.59,85.04 150.97,85.04 151.45,84.56 151.45,83.98 164.43,71 164.43,70.39 168.98,65.84 168.98,65.13 168.78,64.93 168.78,64.39 168.52,64.14 168.52,63.73 169.06,63.2 169.06,62.87 169.57,62.36 v1(170.4,62.36)
  BOTTOM w0.102: R8530.1 112.02,101.09 v1(112.52,100.6) ; v2(178.1,53.44) 178.1,53.65 v1(178.45,54)
1D35V_PGOOD_L: length 4.2
  BOTTOM w0.102: U8502.2 110.76,99.39 ; 110.76,99.39 111.27,98.88 111.27,98.38 v2(111.75,97.89) ; 110.76,99.39 111.14,99.77 111.14,101.02 R8530.2
1D35V_PWR:
  vias: v2(187.52,54) v2(189.63,57.64) v3(188.23,55.97) v3(188.26,55.08) v3(188.36,52.05) v3(189.25,52.06) v3(189.35,55.98) v3(189.38,55.09)
1D35V_VGA_EN: length 12.1
  TOP w0.102: v1(175.91,64.06) 176.26,63.72 v2(176.97,63.72) 177.32,63.72 178.68,62.36 178.68,60.38 179.93,59.13 R8604.1 180,58.3 PR8631.1
  BOTTOM w0.102: D8601.3 176.5,63.48 v1(175.91,64.06) 175.84,63.99 174.9,63.99 174.68,63.77 Q8609.2
1D35V_VGA_EN#: length 3.3
  BOTTOM w0.102: 174.68,65.55 R8645.1 173.98,66.25 v2(173.98,66.55) ; 174.68,65.55 Q8609.5 ; 174.68,65.55 174.73,65.55 175.33,64.95 Q8609.6
1D35V_VGA_S0: length 52.2
  TOP w0.076: 213.71,76.81 214.32,76.81 ; 204.03,71.5 204.03,71.86 ; 213.66,69.07 213.66,69.42 ; 206.29,76.81 205.84,76.81 ; 213.07,92.2 213.66,92.2 ; 213.66,92.2 213.66,91.52 ; 213.66,92.2 214.44,92.2 v1(214.84,91.8) ; 215.26,71.4 215.26,71.88 ; 206.47,69.04 206.47,69.47 ; 214.4,69.6 215.36,69.6 ; 210.46,76.99 210.46,77.52 ; 207.26,76.23 207.26,76.69 ; 215.26,76.25 215.26,76.71 ; 213.66,70.64 213.66,71.86 ; 214.45,76.71 214.45,76.18
  TOP w0.127: 203.37,72.04 203.17,71.83 203.17,70.69 203.45,70.41
  TOP w0.305: R7805.2 198.55,76.59 198.16,76.2 197.22,76.2 194.84,78.59 194.84,82.48 194.05,83.27 v1(194.05,84.53)
  TOP w0.508: R7803.2 R7801.2 198.92,69.12 198.92,68.51 199.46,67.97 199.46,67.03 199.64,66.86 199.64,65.66
  L6 w0.508: v1(177.62,61.55) 177.67,61.5 180.54,61.5 182.14,59.89 188.68,59.89 189.76,60.96 191.84,60.96 v3(192.17,61.29)
  BOTTOM w0.203: GPU1.H24 193.57,86.97 193.57,87.56 194,87.99 GPU1.H26
  BOTTOM w0.305: v1(196.97,86.22) 196.96,86.23 GPU1.E26 ; GPU1.L26 192.99,89.75 193.8,90.56 193.86,90.56 v1(193.88,90.58)
  BOTTOM w0.356: v1(195.05,88.38) 194.67,87.99 GPU1.H26 ; GPU1.C25 GPU1.B26 v1(198.83,84.5) ; v1(194.05,84.53) 194.06,84.52 194.61,84.52 GPU1.E23
  BOTTOM w0.508: R8646.1 176.27,61.55 v1(177.62,61.55)
  vias: v1(182.7,100.36) v1(182.98,100.99) v1(183.38,100.41) v1(185.34,92.13) v1(190.27,86.82) v1(191.12,88.63) v1(192.3,83.95) v1(201.72,85.52) v1(202.2,100.51) v1(204.21,68.19) v1(204.34,100.73) v1(204.38,79.75) v1(204.47,91.82) v1(204.46,70.84) v1(204.99,89.23) v1(205.1,93.5) v1(205.13,72.55) v1(205.26,98.18) v1(205.27,77.19) v1(205.41,96.49) v1(205.66,75.42) v1(205.98,100.68) v1(205.97,79.78) v1(206.06,71.62) v1(206.07,97.41) v1(206.07,91.82) v1(206.07,70.82) v1(206.32,89.26) v1(206.54,68.25) v1(206.72,72.56) v1(206.86,98.2) v1(206.9,96.55) v1(206.86,77.22) v1(207.01,75.52) v1(207.54,79.76) v1(207.64,100.73) v1(207.69,93.52) v1(208.1,89.21) v1(208.46,91.79) v1(208.46,70.82) v1(209.22,99.8) v1(209.25,97.38) v1(209.24,78.82) v1(209.24,78) v1(209.26,76.42) v1(209.26,71.62) v1(209.26,91.79) v1(209.39,89.23) v1(210.08,105.62) v1(210.85,91) v1(210.92,67.49) v1(211.66,99) v1(211.66,92.64) v1(211.65,91.8) v1(211.64,77.99) v1(211.65,71.62) v1(211.68,69.22) v1(211.88,89.21) v1(211.88,79.75) v1(212.19,67.47) v1(212.43,99.8) v1(212.43,98.19) v1(212.46,76.42) v1(212.83,89.18) v1(212.84,67.43) v1(212.9,80.33) v1(213.24,93.49) v1(213.23,70.01) v1(213.26,99) v1(213.28,97.39) v1(213.26,91) v1(213.26,78.02) v1(213.41,72.69) v1(214.06,97.39) v1(214.06,98.99) v1(214.29,101.93) v1(214.47,89.07) v1(214.54,68) v1(214.85,70.82) v1(215.01,74.88) v1(215.03,72.65) v1(215.48,67.49) v1(215.64,96.57) v1(215.63,93.44) v1(215.67,99) v1(216.09,79.78) v1(216.25,100.92) v1(216.36,89.17) v1(216.46,91.82) v1(216.43,75.54) v1(216.46,77.19) v1(216.47,70.84) v1(217.04,104.86) v1(218.61,97.44) v1(218.61,96.8) v1(218.61,96.17) v1(218.61,95.51) v1(218.84,92.31) v1(218.84,91.67) v1(218.84,91.04) v1(218.84,90.38) v1(218.82,75.85) v1(218.82,75.21) v1(218.82,74.58) v1(218.82,73.92) v2(191.94,57.25) v2(196.21,62.84) v2(199.18,98.94) v2(200.58,102.64) v2(207.03,66.22) v2(210.1,84.74) v2(213.23,86.77) v3(191.94,54.59) v3(192.07,55.45) v3(192.07,53.67) v3(192.65,56.67) v3(192.68,62) v3(192.83,54.69) v3(192.96,53.8) v3(193.01,61.19) v3(194.71,65.33) v3(195.45,66.25) v3(198.88,65.51) v3(199.94,65.36) v3(200.12,64.47) v3(206.29,62.56) v3(206.6,61.7) v3(207,64.11) v3(206.98,63.27) v3(207.28,62.33)
1D35V_VGA_S0_DISCHG: length 3
  BOTTOM w0.305: R8646.2 174.85,61.8 174.03,62.62 Q8609.3
  BOTTOM w0.356: R8646.2 175.15,61.65 175.81,60.99 v2(175.81,60.91)
2D5V_S3:
  vias: v1(61.23,16.59) v1(99.87,28.35) v1(99.92,27.46) v1(176.27,27.95) v1(176.3,27.28) v2(175.76,27.59) v3(60.78,17.17)
3D3V_1D8V_AON_S0: length 281.1
  TOP w0.305: PR8505.1 120.24,95.3 120.63,94.91 121.06,94.91 v1(121.1,94.95)
  TOP w0.508: R7917.1 198.67,66.52 198.22,66.07 197.58,66.07 v1(197.53,66.02) ; v1(160.06,79.91) 160.97,79 162.54,79 162.86,79.33 163.27,79.33 v1(163.29,79.3) ; v1(116.33,106.12) 116.33,105.97 116.71,105.59 PR8515.1 ; PR8522.1 119.4,106.2 v1(119.13,106.47) ; v1(198.11,71.98) 198.11,72.62 198.39,72.9 R7949.2 ; v1(170.33,97.41) 171.61,97.41 173.22,95.8 173.22,94.48 175.13,92.57 v1(175.98,92.57)
  L3 w0.508: v1(177.87,67.43) 178.07,67.63 178.07,70.84 183.05,75.82 183.05,78.11 183.74,78.79 v1(185.41,78.79) ; v1(166.87,108.16) 166.67,107.95 166.67,104.17 167.28,103.56 v1(167.28,99.6) ; v1(116.33,106.12) 118.79,106.12 v1(119.13,106.47) ; 191.13,58.8 189.41,60.52 v1(187.39,60.52) 187.39,60.53 187.29,60.63 187.29,63.38 186.59,64.09 181.15,64.09 181.11,64.05 v1(179.37,64.05) ; 195.02,63.68 195.02,63.8 194.99,63.83 194.99,64.54 195.96,65.51 197.1,65.51 197.53,65.94 v1(197.53,66.02)
  L3 w0.635: 195.02,63.68 195.12,63.58 195.12,60.63 194.48,59.99 194.48,59.16 195.89,57.75 ; v1(176.12,103.1) 176.78,103.1 177.41,102.47 177.41,97.08 178.23,96.27 178.23,95.71 178.2,95.68 178.2,94.8 v1(175.98,92.57) ; 191.13,58.8 191.13,53.44 192.17,52.4 193.82,52.4 195.75,54.33 195.75,55.32 196.56,56.14
  L4 w0.356: v1(160.06,79.91) 159.66,79.91 154.88,84.69 154.88,86.01 150.44,90.45 146.7,90.45 v1(145.38,89.13)
  L4 w0.508: v1(116.33,106.12) 118.23,104.22 118.23,101.5 117.85,101.12 117.85,99.57 118.56,98.86 120.49,98.86 120.75,98.61 120.77,98.61 121.18,98.2 121.18,97.54 121.1,97.46 v1(121.1,94.95) ; v1(176.12,103.1) 176.93,103.1 177.57,102.47 178.61,102.47 179.22,103.08 179.37,103.08 180.79,104.5 182.57,104.5 184.19,102.87 184.19,95.96 184.07,95.84 184.07,92.74 184.09,92.71 184.09,91.62 184.4,91.32 184.4,90.6 184.73,90.27 184.73,89.26 185.69,88.29 185.69,87.53 187.6,85.63 187.6,80.98 v1(185.41,78.79) ; v1(177.87,67.43) 176.57,67.43 175.28,68.72 175.28,69.9 173.78,71.4 172.42,71.4 168.81,75.01 167,75.01 163.32,78.69 163.32,79.28 v1(163.29,79.3)
  L6 w0.508: v1(119.13,106.47) 119.13,106.52 119.77,107.15 122.34,107.15 122.6,106.89 126.82,106.89 128.59,108.66 154.1,108.66 154.2,108.56 166.47,108.56 v1(166.87,108.16) ; v1(170.33,97.41) 169.54,97.41 167.35,99.6 v1(167.28,99.6)
  BOTTOM w0.305: R7614.1 163.44,79.15 v1(163.29,79.3) 163.11,79.48 162.1,79.48 161.77,79.15 R7931.1 161,78.18 R7943.2 ; U7601.5 160.18,80.02 v1(160.06,79.91)
  BOTTOM w0.356: GPU1.G12 187.05,79.23 185.77,79.23 185.41,78.87 v1(185.41,78.79) 185.89,78.32 GPU1.G10
  BOTTOM w0.508: v1(197.53,66.02) 197.83,66.32 199.38,66.32 199.66,66.6 200.3,66.6 201.09,67.39 201.09,69.85 R7912.1 199.63,71.39 v2(199.63,72.39) 199.63,73.19 198.89,73.93 Q7906.G 198.04,73.38 198.04,72.1 198.11,72.03 v1(198.11,71.98) ; v1(177.87,67.43) 177.87,67.39 R7938.1 179.04,67.29 R7925.1 179.63,67.9 R7909.1 ; v1(187.39,60.52) 186.63,59.77 186.48,59.77 185.97,59.26 185.97,58.12 186.48,57.62 R7978.2 ; R8637.1 169.92,97.59 170.1,97.41 v1(170.33,97.41) ; R8644.1 165.6,98.5 166.67,98.5 167.28,99.11 v1(167.28,99.6) ; R7603.2 175.08,93.68 175.98,92.78 v1(175.98,92.57) ; Q8601.G 146.78,89.23 146.27,89.74 R7933.1 145.38,89.23 v1(145.38,89.13)
3D3V_1D8V_S0:
  vias: v2(172.03,102.29) v3(172.69,101.86) v3(172.66,98.24)
3D3V_1D8V_VGA_S0: length 143.1
  TOP w0.305: R8529.2 107.61,106.45 109.09,106.45 110.29,107.65 117.37,107.65 v1(117.9,108.18)
  L4 w0.254: v1(117.9,108.18) 118.32,108.18 119.48,107.01 127.1,107.01 128.87,108.79 159.3,108.79 v1(163.24,104.85)
  L4 w0.508: 184.68,93.93 184.68,93.02 184.73,92.97 184.73,91.87 185.08,91.52 185.08,90.81 186.38,89.51 186.38,87.73 188.21,85.91 188.21,80.72 185.39,77.9 184.73,77.9 184.17,77.35 v1(184.17,77.32) 184.5,76.99 186.58,76.99 187.23,76.35 188.22,76.35 191.43,73.13 v1(192.6,73.13) ; 185.59,96.6 185.59,97.74 184.8,98.53 184.8,103.18 182.65,105.34 180.64,105.34 179.58,104.28 ; v1(163.24,104.85) 163.61,104.85 164.06,105.3 166.48,105.3 167.13,104.65 167.35,104.65 167.43,104.57 167.94,104.57 168.02,104.65 173.18,104.65 173.86,103.97 177.97,103.97 ; v1(180.45,60.56) 180.45,61.43 178.43,63.45 178.43,66.27 178.84,66.69 178.84,68.22 177.57,69.5 177.57,72.49 v1(178.51,73.43)
  BOTTOM w0.356: GPU1.G9 185.28,77.44 184.73,76.89 GPU1.G8 184.26,77.32 v1(184.17,77.32)
  BOTTOM w0.508: v1(192.6,73.13) 192.6,73.11 194.79,70.92 R7913.1 ; R7957.1 180.46,60.18 180.46,60.54 v1(180.45,60.56) ; C8003.1 178.51,72.58 v1(178.51,73.43) ; v1(163.24,104.85) 163.24,103.71 R8647.1
  vias: v1(174.95,97.69) v1(174.97,98.38) v1(178.38,103.15) v1(178.68,103.71) v2(176.65,73.74)
3D3V_AUX_S5: length 384.4
  TOP w0.508: v1(113.95,43.44) 113.89,43.44 R1727.1 R1726.2 ; R1737.1 121.23,41.94 v2(121.08,41.79) 120.75,41.46 120.16,41.46 120.07,41.36 v1(120.04,41.36) ; R2453.1 v1(42.97,29.9) 42.97,29.52 43.48,29.01 49.07,29.01 R2473.1 ; PR4505.1 201.08,49.86 v1(201.31,49.53) ; R4004.1 214.67,45.47 v1(214.67,45.16) ; v1(193.19,51.36) 193.19,51.93 193.64,52.38 PR4503.1 194.1,52 194.02,51.92 PG4532.2 ; R2502.2 212.67,21.24 v1(212.59,21.16)
  L3 w0.508: v1(56.41,50.29) 55.62,49.51 53.84,49.51 v1(53.64,49.3) ; v1(44.04,47.88) 44.04,45.29 43.97,45.23 43.97,45.18 43.48,44.68 43.48,39.55 43.96,39.07 43.96,38.71 44.93,37.75 44.93,36.71 44.57,36.35 44.52,36.35 42.21,34.04 42.21,30.53 42.84,29.9 42.86,29.9 42.87,29.9 v1(42.97,29.9) ; v1(159.53,100.69) 161.67,98.55 166.82,98.55 v1(167.23,98.15) ; v1(218.99,18.8) 219.26,18.8 219.66,19.2 219.66,24.18 217.39,26.44 217.39,28.3 218.38,29.29 219.65,29.29 220.01,29.64 220.01,34.32 216.78,37.54 216.61,37.54 214.52,39.63 214.52,40.17 214.67,40.32 v1(214.67,45.16) 214.67,45.88 214.22,46.33 214.22,47.66 213.54,48.34 209.71,48.34 207.6,46.23 205.94,46.23 205.64,45.93 202.62,45.93 201.54,47.01 201.54,48.53 201.31,48.76 v1(201.31,49.53) 200.04,50.8 200.04,50.9 199,51.95 196.56,51.95 195.98,51.36 v1(193.19,51.36) 191.43,51.36 190.11,52.68 190.11,56.37 189.49,56.99 184.87,56.99 183.13,58.73 v1(183.13,59.06)
  L4 w0.508: v1(61.79,54.13) 61.72,54.21 59.2,54.21 56.41,51.41 v1(56.41,50.29) ; v1(53.64,49.3) 53.13,48.8 51,48.8 50.16,47.96 47.29,47.96 46.25,46.92 45.03,46.92 44.7,47.25 44.67,47.25 v1(44.04,47.88) ; v1(176.05,65.22) 176.55,64.71 176.55,60.97 177.61,59.92 182.26,59.92 v1(183.13,59.06) ; v1(163.77,43.69) 164.08,43.39 165.63,43.39 166.06,42.95 166.06,42.86 166.62,42.29 166.92,42.29 168.27,40.95 171.01,40.95 178,33.96 178.78,33.96 180.21,32.54 184.96,32.54 187.42,30.08 190.68,30.08 191.74,29.02 191.74,28.14 193.05,26.83 195.14,26.83 195.5,27.18 198.77,27.18 201.55,29.96 205.38,29.96 209.19,26.15 209.19,25.58 212.44,22.33 212.44,21.31 v1(212.59,21.16) 213.94,19.81 216.15,19.81 216.4,19.56 217.95,19.56 218.71,18.8 v1(218.99,18.8)
  L6 w0.508: v1(167.23,98.15) 167.84,98.15 169.46,96.52 169.46,93.53 166.03,90.1 166.03,85.78 167.56,84.25 169.92,84.25 171.09,83.09 171.09,79.63 175.89,74.83 175.89,66.17 176.05,66.01 v1(176.05,65.22)
  BOTTOM w0.508: R7952.2 v1(183.13,59.06) ; v1(159.53,100.69) R8643.2 160.4,100.59 160.4,99.39 159.89,98.88 R8640.1 ; v1(176.05,65.22) 175.55,65.71 R8645.2 ; v1(163.77,43.69) 162.76,42.67 162.1,42.67 161.23,41.81 153.84,41.81 153,40.97 145.61,40.97 143.76,39.12 122.29,39.12 v1(120.04,41.36) 119.34,40.66 116.92,40.66 116.2,41.38 116.2,42.42 115.19,43.44 v1(113.95,43.44) 113.93,43.46 109.6,43.46 108.73,44.33 79.46,44.33 69.66,54.13 v1(61.79,54.13)
3D3V_CAMERA_S0: length 1.1
  BOTTOM w0.305: LCD1.26 50.56,91.23 v1(50.46,91.13)
  vias: v2(52.8,93.53)
3D3V_ECVBAT: length 12.2
  TOP w0.203: 43.17,34.7 43.18,34.7 U2401.122
  TOP w0.254: R2452.1 50.13,31.88 v1(50.21,31.8) 50.39,31.98 R2451.1
  TOP w0.305: R2472.2 49.37,30.13 R2473.2 49.35,31.75 R2452.1
  BOTTOM w0.254: 45.46,32.82 48.74,32.82 49.76,31.8 v1(50.21,31.8)
  BOTTOM w0.305: v1(44.2,33.84) 45.22,32.82 45.46,32.82
  vias: v2(42.56,34.47)
3D3V_FLASH: length 39.9
  TOP w0.203: U7204.G1 79.97,99.77 80.16,99.96 81.74,99.96 82.77,100.99 83.08,100.99 C7244.1
  TOP w0.356: C7244.1 83.18,100.89 83.18,100.08 C7228.1
  TOP w0.508: v1(70.83,105.51) 70.19,106.15 R7244.1 ; C7228.1 83.08,98.68 v1(82.77,98.38)
  L4 w0.508: v1(70.83,105.51) 70.83,105.49 70.94,105.39 70.94,102.77 71.09,102.62 71.09,100.1 71.95,99.24 v1(72.62,99.24) 72.62,99.55 73.32,100.26 74.14,100.26 75.43,101.55 78.53,101.55 80.89,99.19 80.89,98.81 81.7,98.01 82.28,98.01 82.65,98.38 v1(82.77,98.38)
  BOTTOM w0.508: v1(72.62,99.24) 72.54,99.16 72.54,97.18 72.96,96.75 R7233.1 73.17,96.19 72.08,95.1 71.93,94.95 U7205.8 ; v1(82.77,98.38) 82.8,98.38 82.93,98.25 83.61,98.25 84.75,97.11 84.75,95.94 83.59,94.77 82.85,94.77
  vias: v2(80.82,94.82)
3D3V_GSEN2: length 15.1
  TOP w0.254: R7005.1 R7006.2 166.59,49.46 166.16,49.89 165.81,49.89 165.55,50.14 165.55,50.65 165.7,50.8 165.7,50.9 v1(165.86,51.06) ; C7004.1 166.31,54.43 v1(165.83,54.92) ; C7004.1 167.13,54.08 U7001.9 ; C7004.1 166.57,54.24 U7001.10 ; C7004.1 166.77,54.97 166.97,55.17 C7003.1 166.49,55.58 166.24,55.83 v2(166.24,56.09) 166.24,56.57 R7004.2
  L3 w0.254: v1(165.83,54.92) 165.55,54.64 165.55,51.36 v1(165.86,51.06)
3D3V_LCDVDD_R:
  vias: v2(39.03,83.47)
3D3V_LCDVDD_S0:
  vias: v2(38.98,88.06)
3D3V_LDO_SET: length 5.6
  TOP w0.102: v1(62.3,89.08) 62.3,88.95 v2(61.89,88.55) R5548.2 R5547.1
  BOTTOM w0.102: v1(62.3,89.08) 62.66,88.72 63.9,88.72 64.57,89.4 U5502.4
3D3V_MUX: length 41.2
  TOP w0.203: U7301.20 28.92,68.33 29.18,68.07 v1(29.18,68) ; U7301.6 v1(22.98,70.05) ; U7301.1 v1(23.79,72.57) ; 29.66,72.47 U7301.28
  TOP w0.381: R7327.1 R7325.1 19.63,70.21 v1(19.55,70.28) 18.97,70.87 C7317.1 ; R7301.1 32.25,73.38 v1(31.54,74.09) ; v1(29.21,73.92) 29.26,73.92 29.66,73.52 29.66,72.47
  L4 w0.381: v1(29.21,73.92) 29.56,74.28 31.36,74.28 v1(31.54,74.09)
  BOTTOM w0.381: C7315.1 29.25,68.2 29.2,68.14 29.2,68.02 v1(29.18,68) 28.41,67.24 27.6,67.24 27.3,67.54 R7344.1 26.99,67.41 25.95,67.41 R7341.1 25.8,67.02 25.42,66.64 24.64,66.64 24.12,67.15 R7323.1 24.12,70.23 C7319.1 ; C7319.1 23.74,72.53 v1(23.79,72.57) 23.79,73.4 24.4,74.02 24.4,74.32 25.06,74.98 R7320.1 R7318.1 28.12,74.98 29.17,73.92 v1(29.21,73.92) 29.26,73.92 29.64,73.54 29.64,72.68 v2(29.56,72.6) 30.19,71.96 C7318.1 C7316.1 29.36,71.71 R7306.1 R7307.1 ; C7319.1 23.55,70.61 v1(22.98,70.05) 22.92,69.98 19.83,69.98 19.55,70.26 v1(19.55,70.28) 19.53,70.31 R7303.2
3D3V_PD: length 22.8
  TOP w0.203: U7204.H1 79.66,100.27 79.85,100.46 80.61,100.46 80.62,100.47 80.79,100.47 81.99,101.67 v1(81.99,102.01)
  TOP w0.305: U7204.B1 79.6,97.27 80.03,96.84 80.03,95.61 80.44,95.2 80.44,95.05 80.82,94.67 80.82,94.36
  TOP w0.508: v1(86.13,97.06) 86.13,96.4 85.85,96.12 v2(85.85,95.58) 85.85,95.48 85.47,95.1 85.47,94.77 84.96,94.26 84.17,94.26 84.07,94.16 84.07,94.11 83.76,93.8 83.71,93.8 83.69,93.78 81.93,93.78 81.17,93.02 R7250.2 80.82,93.3 80.82,94.36
  L3 w0.356: v1(81.99,102.01) 81.99,101.25 83.76,99.47 83.76,99.42 v1(86.13,97.06)
3D3V_RTC: length 205
  TOP w0.508: C2503.1 210.09,18.49 D2501.3 211.8,20.21 v1(211.8,21.11) 211.86,21.16 R2512.1 ; v1(22.92,24.35) 23.46,24.89 27.27,24.89 27.88,25.5 28.62,25.5 30.35,27.23 31.08,27.23 32.23,28.37 49.47,28.37 50.16,29.06 R2472.1 52.98,29.26 53.94,30.23 132.15,30.23 v2(133.36,31.44) 134.23,32.31 171.34,32.31 172.51,31.14 v1(177.39,31.14)
  L4 w0.508: v1(211.8,21.11) 211.8,21.34 211.3,21.85 210.38,21.85 209.01,23.22 209.01,23.93 207.79,25.15 203.24,25.15 202.18,26.22 195.45,26.22 195.42,26.19 192.21,26.19 v1(191.18,27.22) 187.69,27.22 183.26,31.65 177.9,31.65 v1(177.39,31.14)
  BOTTOM w0.508: R2708.1 22.3,23.73 v1(22.92,24.35) ; v1(191.18,27.22) Q2507.S
3D3V_RTC_SYS: length 5.6
  TOP w0.254: R2503.1 R2502.1 213.4,21.69 213.4,18.72 213.71,18.42 v2(213.71,18.19) 213.57,18.05 D2501.1
3D3V_S0: length 756.5
  TOP w0.254: Q2601.5 Q2601.2 58.67,42.98
  TOP w0.305: v1(132.2,49.17) 132.37,49.17 133.47,50.27 134.61,50.27 R2107.1 R1818.2 R1820.1 ; R7004.1 169.56,55.88 169.56,52.12 169.95,51.74 v1(170.11,51.74)
  TOP w0.406: R1718.2 110.31,92.66 110.94,92.03 111.6,92.03 112.21,91.42 118.03,91.42 118.51,91.9 121.1,91.9 121.61,91.39 125.95,91.39 v1(126.05,91.49) ; RN2603.4 222.45,64.17 222.68,63.94 v1(222.68,63.71) 222.47,63.5 RN2603.3
  TOP w0.457: v1(44.14,55.02) 44.24,55.12 EC8952.1
  TOP w0.508: R4005.1 42.73,58.77 v1(42.59,58.63) ; R2490.1 52.78,46.27 v1(52.45,46.6) ; R1302.1 178.78,18.82 178.33,18.37 v1(178.12,18.37) 177.92,18.16 176.85,18.16 176.55,17.86 173.22,17.86 172.46,18.62 v2(164.18,18.62) 163.62,18.62 163.24,19 C1328.1 154.98,19 154.48,18.49 R1310.1 152.67,18.49 C1329.1 ; R2604.1 167.13,103.25 168.57,101.81 v1(168.96,101.81) 170,100.77 170,99.57 169.59,99.16 169.59,95.53 168.44,94.38 v1(168.35,94.38) ; R7948.2 200.04,68.56 200.83,67.77 v2(200.83,67.64) v1(200.83,66.22) ; 98.34,20.32 97.66,20.32 R1204.2 v3(97.5,18.13) ; v1(132.66,77.52) 132.66,78.01 131.97,78.69 R402.2 R2048.1 R2049.1 R2010.1 ; R2737.1 58.72,53.52 v1(59.33,52.91) 59.33,52.66 58.55,51.88 57.79,51.88 57.22,52.45 57.22,52.81 57.02,53.02 57.02,53.16 56.99,53.16 56.76,53.39 55.77,53.39 55.54,53.16 55.54,53.04 55.29,52.78 v1(55.29,52.73) ; v1(153.28,92.31) v2(155.19,92.31) 157.52,92.31 v1(157.68,92.15) ; v1(98.04,26.32) 97.4,26.32 96.81,26.91 96.02,26.91 95.7,26.6 C1228.1 94.81,26.83 C1223.1 ; v1(167.35,81.69) 164.04,78.37 160.16,78.37 159.23,79.3 157.52,79.3 156.18,77.96 156.18,77.93 155.82,77.57 153.64,77.57 ; v1(112.29,99.3) v2(112.29,98.4) 112.29,98.17 112.31,98.15 112.31,98.12 112.8,97.64 112.8,97.11 112.64,96.95 112.64,95.94 112.82,95.76 112.82,95.2 112.47,94.85 111.69,94.85 111.28,94.44 109.91,94.44 109.33,93.86 109.33,93.25 v1(109.34,93.25) 109.34,93.22 109.67,92.89 R1718.2 ; v1(51.86,95.13) 53.98,97.24 63.5,97.24 64.3,96.45 v1(65.58,96.45) ; 179.11,56.97 179.11,56.37 v1(178.99,56.24) ; v1(14.09,67.16) 15.07,67.16 15.71,66.53 v2(16.91,66.53) 18.29,66.53 v1(18.35,66.47) ; R9150.1 202.84,41.43 203.23,41.43 203.23,41.43 204.97,41.43 205.15,41.61 206.93,41.61 208.03,40.5 208.66,40.5 208.85,40.31 ; v1(13.48,55.81) 13.05,56.23 13.05,59.16 13.46,59.57 13.48,59.57 13.84,59.92 13.84,59.95 15.21,61.32 15.21,62.9 16.22,63.91 18.46,63.91 19.22,63.15 v1(19.22,63.07) ; PR8634.2 184.63,58.35 185.29,59.01 v1(185.29,59.05) ; R7018.1 214.67,60.15 v1(215.79,60.15)
  L3 w0.508: v1(135.02,74.3) 135.02,75.44 134.13,76.33 134.13,76.36 133.78,76.71 133.6,76.71 133.24,77.07 133.12,77.07 v1(132.66,77.52) ; v1(178.12,18.37) 177.92,18.16 176.22,18.16 174.75,19.64 ; v1(178.99,56.24) 178.99,58.91 179.78,59.7 v1(179.78,60.56) 179.78,61.75 179.11,62.41 179.11,62.49 177.74,63.86 177.69,63.86 176.96,64.59 176.96,65.56 174.62,67.9 174.62,68.89 174.54,68.96 174.54,71.26 173.56,72.25 v1(172.92,72.25) ; v1(167.35,81.69) 167.35,83.27 162,88.63 162,90.07 ; v1(101.85,105.16) 102,105.31 104.13,105.31 104.15,105.29 104.18,105.29 105.94,103.53 107.33,103.53 107.69,103.18 107.69,102.52 108.55,101.65 110.08,101.65 112.29,99.44 v1(112.29,99.3) ; v1(131.11,71.73) 133.93,68.91 136.04,68.91 137.1,67.85 v1(137.46,67.85) ; v1(168.35,94.38) 168.14,94.18 168.14,92.36 165.86,90.07 162,90.07 ; v1(157.68,92.15) 159.33,92.15 161.41,90.07 162,90.07 ; v1(40.3,81.79) 39.26,82.83 39.26,85.85 41.65,88.24 41.65,89.79 v1(43.1,91.24) 43.1,91.3 44.64,92.84 44.77,92.84 v1(45.46,93.53) ; v1(18.35,66.47) 18.35,68.77 18.98,69.41 v1(19.55,69.41) 19.61,69.41 20.21,70.01 20.21,71.12 16.58,74.75 16.58,77.83 17.67,78.92 17.67,83.24 17.16,83.75 17.16,86.13 17.29,86.26 17.29,86.29 17.47,86.46 v1(17.47,88.42)
  L3 w1.016: v3(215.69,50.12) 215.79,50.02 215.79,42.17 215.94,42.01 215.94,40.97 216.12,40.79 216.12,39.28 216.85,38.56 v3(216.96,38.56) 217.02,38.56 221.08,34.51 v3(221.08,31.47)
  L4 w0.305: v1(20.67,89.84) 20.67,89.06 22.37,87.35 22.37,85.27 21.76,84.66 21.76,81.92 20.16,80.32 17.72,80.32 14.4,76.99 14.4,70.08 13.96,69.65 13.96,67.29 v1(14.09,67.16)
  L4 w0.406: v1(83.48,97.36) 84.25,97.36 84.75,96.85 84.75,96.09 85.16,95.68 103.12,95.68 104.46,94.34 105.33,94.34 105.94,93.73 105.94,93.7 106.29,93.35 106.32,93.35 106.42,93.25 v1(109.34,93.25)
  L4 w0.508: v1(42.59,58.63) 42.64,58.58 42.64,55.93 43.56,55.02 v1(44.14,55.02) ; v1(42.59,58.63) 42.54,58.68 41.8,58.68 41.45,59.03 41.45,59.36 41.07,59.74 41.07,60.58 40.08,61.57 38.07,61.57 37.94,61.45 37.51,61.45 36.95,60.89 v1(36.95,60.4) 36.87,60.33 36.87,58.93 34.82,56.87 v1(33.85,56.87) 33.85,56.85 32.97,55.96 v1(27.71,55.96) ; v1(42.59,58.63) 43.49,58.63 46.82,55.3 47.97,55.3 48.58,55.91 55.05,55.91 56.38,54.57 56.38,53.83 v1(55.29,52.73) ; v1(17.47,88.42) 17.14,88.75 17.14,94.59 18.84,96.29 21.05,96.29 21.99,95.35 26.82,95.35 27.71,96.24 33.98,96.24 35.2,97.46 v1(35.2,98) ; v1(170.11,51.74) 170.11,51.01 170.45,50.66 170.45,48.42 170.2,48.16 170.2,47.59 v1(170.75,47.04) ; v1(185.29,59.05) 186.13,59.89 187.7,59.89 188.13,60.32 193.89,60.32 194.53,60.96 198.47,60.96 200.83,63.32 200.83,64.11 200.86,64.14 200.86,64.8 200.83,64.82 v1(200.83,66.22) ; v1(59.33,52.91) 59.9,52.34 v1(59.9,43.77) ; v1(65.58,96.45) 68.7,96.45 70.15,97.89 70.86,97.89 71.32,97.44 74.31,97.44 74.87,96.88 81.07,96.88 81.12,96.83 82.26,96.83 82.32,96.78 82.87,96.78 83.46,97.36 v1(83.48,97.36) ; v1(215.79,60.15) 216.88,59.05 216.88,51.31 v3(215.69,50.12)
  L6 w0.508: v1(45.46,93.53) 46.86,94.92 51,94.92 v1(51.2,95.13) ; v1(40.3,81.79) 41.22,81.79 42.51,80.5 43.66,80.5 45.1,81.94 47.95,81.94 49.7,83.7 49.7,86.44 50.57,87.3 55.54,87.3 56.38,88.14 v1(57.5,88.14) ; v1(155.57,40.92) 157.35,39.14 167.62,39.14 168.33,39.86 169.67,39.86 v1(170.12,40.31) ; v1(222.68,63.71) 222.5,63.53 218.9,63.53 215.79,60.42 v1(215.79,60.15) ; v1(154.3,50.26) 152.98,50.26 145.16,58.09 145.16,64.47 143.15,66.47 143.15,67.39 142.87,67.67 v1(142.87,67.72) 142.87,68.53 144.06,69.73 144.06,71.4 143.07,72.39 v1(143.07,74.02)
  BOTTOM w0.254: R6402.1 19.45,89.39 18.16,89.39 v1(17.79,89.02) 17.47,88.7 v1(17.47,88.42)
  BOTTOM w0.279: DM1.255 97.38,26.97 v1(98.04,26.32)
  BOTTOM w0.305: v1(57.5,88.14) 57.17,87.81 57.17,87.02 57.4,86.79 R5551.1 57.4,86.46 56.66,85.73 R5555.1 R5554.1 ; v1(147.57,47.02) 139.52,47.02 136.32,50.21 135.22,50.21 134.61,49.6 134.61,49 134.29,48.67 132.7,48.67 v1(132.2,49.17) 130.14,51.23 128.86,51.23 128.83,51.26 128.8,51.26 128.39,51.67 v1(128.39,51.77) ; v1(153.28,92.31) 153,92.31 152.43,91.74 U8604.5 ; R7953.1 180.31,61.19 179.78,60.66 v1(179.78,60.56) ; DM2.255 174.38,26.16
  BOTTOM w0.356: v1(167.43,106.76) 167.85,107.18 THM261.1 ; v1(19.22,63.07) 18.59,63.07 18.21,63.46 Q5702.2 ; v1(112.29,99.3) 112.21,99.22 U8502.5 ; v1(148.23,75.21) 148.23,75.24 148.08,75.39 Q1801.2 ; v1(18.35,66.47) 18.35,66.46 18.21,66.32 Q5702.5 ; Q1801.5 144.34,75.39 143.17,74.22 143.17,74.22 143.07,74.12 v1(143.07,74.02) ; U8605.5 153.63,90.82 R8635.2 152.76,90.76 U8604.5 ; v1(59.9,43.77) 58.9,44.77 55.38,44.77 53.77,46.38 52.83,46.38 52.61,46.6 v1(52.45,46.6)
  BOTTOM w0.508: R2044.1 142.7,73.38 143.07,73.76 v1(143.07,74.02) ; v1(178.12,18.37) 178.25,18.49 178.25,21.44 v3(178.96,22.15) 178.96,23.47 178.61,23.83 178.61,24.06 177.64,25.02 177.06,25.02 176.65,25.43 175.12,25.43 174.38,26.16 ; v1(185.29,59.05) 183.46,57.23 179.97,57.23 v1(178.99,56.24) 178.33,55.58 178.33,54.79 177.82,54.28 177.82,54 177.67,53.85 177.67,53.83 177.54,53.7 177.54,53.6 170.99,47.04 v1(170.75,47.04) 170.75,41.16 170.12,40.54 v1(170.12,40.31) ; v1(36.95,60.4) 36.86,60.49 PR4609.1 ; v1(168.96,101.81) 169.24,101.81 169.62,102.19 169.69,102.19 170.1,102.59 R8601.1 ; v1(126.05,91.49) 126.23,91.49 127.02,90.71 ; v1(137.46,67.85) 137.26,67.64 R2046.1 R2011.1 ; v1(168.35,94.38) 168.45,94.28 R8634.1 ; 144.9,77.78 145.41,78.29 150.05,78.29 v1(150.36,77.98) ; v1(172.92,72.25) 172.89,72.21 172.26,72.21 171.75,72.72 170.78,72.72 ; v1(137.87,74.07) 137.2,74.07 R2045.1 ; R2109.1 v1(135.02,74.3) 135.15,74.42 R2119.1 ; SBD1.10 79.37,98.47 79.53,98.31 79.53,97.86 79.54,97.85 79.54,97.78 79.91,97.41 79.97,97.35 81.76,97.35 82.5,96.61 v2(82.71,96.61) 83.46,97.36 v1(83.48,97.36) ; 141.78,81.86 141.62,82.01 141.62,83.01 142.28,83.66 142.28,87.03 138.98,90.33 130.93,90.33 ; v1(101.85,105.16) 103.12,105.16 v2(103.47,105.51) 103.68,105.31 R8541.1 ; R5529.2 43.38,90.6 43.1,90.88 v1(43.1,91.24) ; PR8625.1 145.74,81.68 145.34,81.28 ; R2038.1 142.75,68.3 142.87,68.18 v1(142.87,67.72) ; 170.78,72.72 v2(169.71,73.8) 168.5,75.01 167.61,75.01 167.33,74.73 R7934.1 ; 170.78,72.72 168.46,72.72 167.27,71.53 R4008.1 165.96,71.53 R4003.1 ; v1(19.55,69.41) 20.42,69.41 Q5703.C ; v1(33.85,56.87) 33.59,56.61 DBG1.10 ; v1(98.04,26.32) 99,25.35 100.04,25.35 101.34,24.06 101.34,20.37 99.09,18.13 v3(97.5,18.13) ; v1(65.58,96.45) 65.02,95.89 R5559.1
  vias: v1(26.03,36.83) v1(27.74,22.06) v1(28.19,21.57) v1(34.48,98) v1(34.75,11.04) v1(35.4,11.03) v1(36.87,93.2) v1(37.51,93.27) v1(64.08,11.59) v1(64.71,11.36) v1(69.34,5.86) v1(70.02,5.86) v1(179.52,21.64) v1(223.21,21.29) v1(223.23,20.45) v1(223.23,19.64) v2(28.44,22.1) v2(37.03,94.11) v2(130.09,89.94) v2(142.89,80.72) v2(149.65,77.9) v2(154.17,41.71) v2(166.47,106.81) v2(173.81,5.87) v2(209.26,39.63) v2(222.09,21.92) v3(76.42,17.5) v3(96.64,18.11) v3(174.9,5.53) v3(209.65,38.71) v3(209.57,37.67) v3(210.59,38.69)
