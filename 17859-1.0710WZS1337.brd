# Allegro board 17859-1.0710WZS1337.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
3D3V_S5: length 645.8
  TOP w0.254: R2001.1 131.26,50.14 R1910.1 131.45,49.95 131.45,48.69 131.66,48.49 131.66,46.93 v2(130.78,46.06) 130.37,45.65 129.89,45.65 129.64,45.9 R2050.2
  TOP w0.305: Q2412.2 Q2412.5 55.37,34.15 54.74,33.53 FC8902.1 54.96,33.2 55.59,33.2 v1(55.7,33.1) ; RN7206.1 83.82,96.12 83.84,96.14 83.89,96.14 83.99,96.24 83.99,96.29 84.12,96.42 v1(84.12,96.6) 83.95,96.77 RN7206.2 ; v1(128.87,43.49) 128.8,43.56 128.8,45.1 129.41,45.74 R2050.2 ; v1(80.74,95.84) 80.94,95.63 80.94,95.18 81.63,94.49 R7241.1
  TOP w0.356: R7246.1 85.26,102.87 v2(85.52,102.62) 85.59,102.54 85.59,101.65 85.87,101.37 85.87,99.72 85.95,99.64 87.75,97.84 v1(87.75,96.88)
  TOP w0.406: PR4450.2 170.96,13.41 171.12,13.26 171.12,12.53 ; 171.5,12.53 172.41,12.53 172.74,12.86 R6521.1 ; D4302.2 49.74,52.12 R4304.1 ; D4302.2 51.6,52.45 v1(53.26,52.45) ; D4302.2 51.65,54.03 52.39,54.03 C6401.1
  TOP w0.508: v1(222.09,58.88) 221.81,58.88 C6104.1 ; v1(203.33,40.79) 203,40.46 R9149.1 ; v1(55.7,33.1) 55.75,33.05 56.49,33.05 56.86,33.42 56.86,36.32 v1(56.61,36.58) ; v1(61.45,10.86) 61.66,10.65 74.54,10.65 v1(75.13,11.23) ; v1(97.81,6.89) 97.78,6.91 PR4430.1 98.28,8.32 98.28,8.66 97.74,9.2 PR4464.2 ; v1(182.59,17.88) 182.9,17.58 v2(182.9,15.83) 182.9,12.47 182.2,11.78 v1(182.2,11.07) ; v1(24.63,36.17) 24.35,36.17 24,35.82 R2475.1 ; v1(183.74,37.57) 184.04,37.87 R2517.1 ; v1(171.44,9.55) 171.44,10.16 171.47,10.18 v2(171.47,11.51) 171.47,12.18 171.12,12.53 171.5,12.53 ; R4031.1 202.81,43.85 202.61,43.64 v1(202.61,43.51) ; v1(212.97,30.74) 214.29,29.42 v2(214.29,28.17) 214.29,27.61 213.61,26.93 R2440.1 213.61,26.47 214.17,25.91 R2520.1 ; v1(93.01,15.78) 93.34,15.78 93.82,15.29 PR5304.1 ; R2514.1 209.52,27.69 209.98,28.15 FC8905.1 209.85,28.68 R2511.1 209.85,30.66 211.07,31.88 R1724.1 211.07,32.44 v1(211.4,32.77) 211.8,33.18 211.8,34.06 R9143.1 211.5,34.8 v2(212.22,35.52) 213.28,36.58 v1(213.28,36.91) ; R2607.1 26.16,38.64 v1(26.21,38.69) ; v1(141.22,42.71) 141.22,39.98 142.37,38.83 R507.2 ; v1(146.7,73.46) 150.18,73.46 150.43,73.71 153.18,73.71 154.05,74.58 v1(158.49,74.58) 158.99,74.58 159.36,74.94 v2(165.22,74.94) 165.95,74.94 167.28,73.61 v1(168.7,73.61) ; v1(70.5,97.26) 70.56,97.31 R7247.1 ; v1(71.22,15.67) 72.26,14.63 v2(72.92,14.63) 73.63,13.92 v1(73.63,13.74) ; v1(55.84,42.48) 55.57,42.22 v2(54.32,42.22) 53.31,42.22 53.08,41.99 R2434.1 ; v1(21.1,42.79) 20.74,42.79 20.04,43.49 20.04,44.2 20.52,44.68 20.52,47.45 21.19,48.12 v2(21.19,48.66) 21.19,50.97 24.89,54.66 24.89,56.47 25.7,57.28 R6137.1 25.57,59.24 C6103.1 v1(23.39,59.24) ; R7250.1 83.76,92.94 83.99,93.17 84.04,93.17 84.3,93.42 R7239.1 85.26,93.42 85.44,93.6 86.81,93.6 87.04,93.83 87.04,93.86 87.05,93.87 C7229.1 87.93,94.85 87.93,96.7 v1(87.75,96.88)
  L3 w0.508: v1(80.74,95.84) 79.93,95.84 78.51,94.41 73.83,94.41 73.07,95.18 73.07,95.68 71.5,97.26 v1(70.5,97.26) 68.68,95.43 66.54,95.43 66.16,95.05 64.94,95.05 64,94.11 47.29,94.11 46.37,95.02 44.57,95.02 39.72,90.17 39.72,88.9 36.24,85.42 36.24,83.38 35.53,82.67 35.53,82.48 35.5,82.45 35.5,81.24 v1(34.67,80.41) 34.67,77.45 35.48,76.63 35.48,75.39 35.3,75.21 35.3,74.82 34.7,74.22 33.18,74.22 32.81,73.85 32.81,73.66 32.8,73.63 32.28,73.11 32.28,68.25 32.07,68.05 32.07,66.42 33.93,64.57 33.93,62.19 33.06,61.32 33.06,60 v1(34.16,58.91) ; v1(75.13,11.23) 75.13,12.25 v1(73.63,13.74) ; v1(46.1,17.6) 44.9,17.6 43.33,19.18 42.34,19.18 40.09,21.44 40.09,26.15 37.61,28.63 37.61,29.88 v1(37.18,30.31) ; v1(87.75,96.88) 87.75,96.27 87.22,95.74 84.98,95.74 v1(84.12,96.6) ; v1(222.09,58.88) 222.29,58.68 222.29,54.31 v1(219.3,51.31)
  L4 w0.356: v1(53.26,52.45) 53.26,51.64 53.23,51.62 53.23,51.11 53.54,50.8 54.07,50.8 55.09,49.79 55.09,47.45 v1(53.44,45.8)
  L4 w0.508: v1(168.7,73.61) 169.31,73.61 170.78,72.14 170.78,71.42 v1(170.5,71.15) ; 216.4,48.72 218.99,51.31 v1(219.3,51.31) ; v1(25.32,84.2) 25.22,84.2 22.96,81.94 22.96,79.73 23.31,79.38 23.31,74.47 20.52,71.68 19.02,71.68 17.6,70.26 v1(17.29,70.26) 18.05,69.5 18.05,67.54 17.71,67.2 17.71,57.19 19.12,55.78 20.31,55.78 20.87,56.34 20.87,61.95 21.24,62.32 v1(21.24,62.76) ; v1(93.01,15.78) 92.93,15.85 88.77,15.85 86.68,13.77 73.65,13.77 v1(73.63,13.74) ; v1(34.67,80.41) 34.67,83.95 v1(34.21,84.41) ; v1(169.49,61.72) 169.49,61.24 176.09,54.64 176.09,53.06 178.66,50.49 178.66,49.67 179.58,48.75 181.47,48.75 v3(182.21,48.01) ; v1(213.28,36.91) 213.32,36.95 213.32,39.93 212.27,40.98 212.27,42.49 ; v1(169.97,34.88) 169.96,34.88 169.59,35.25 169.59,35.38 169.06,35.92 169.06,36.15 168.47,36.73 168.47,37.12 168.12,37.47 168.09,37.47 167.56,38 166.85,38 162,42.85 161.67,42.85 161.16,43.36 v1(161.16,43.56) ; v1(53.44,45.8) 53.56,45.67 54.27,45.67 55.32,44.63 55.32,42.99 55.82,42.48 v1(55.84,42.48) 55.84,41.29 56.66,40.46 56.66,36.63 v1(56.61,36.58) ; v1(21.1,42.79) 21.62,42.79 22.24,42.17 23.17,42.17 24.85,40.48 24.85,39.71 25.88,38.69 v1(26.21,38.69) 26.21,40.37 27.87,42.03 31.32,42.03 31.54,41.81 33.19,41.81 34.06,42.68 34.06,42.79 34.44,43.16 34.44,43.35 35.38,44.3 37.48,44.3 v1(38.42,45.24) ; v1(182.59,17.88) 182.59,20.5 180.54,22.56 180.54,25.28 180,25.81 v1(180,29.92)
  L6 w0.305: v1(217.01,39.65) 214.27,36.91 v1(213.28,36.91)
  L6 w0.508: v1(169.97,34.88) 169.84,34.75 169.84,33.73 173.96,29.62 178.22,29.62 178.67,30.08 179.72,30.08 179.88,29.92 v1(180,29.92) ; v1(23.39,59.24) 23.43,59.28 23.43,60.73 22.7,61.45 22.7,62.47 22.3,62.87 21.35,62.87 v1(21.24,62.76) ; v1(26.21,38.69) 28.06,36.83 28.06,34.27 27.22,33.43 27.22,30.43 27.91,29.75 v1(27.91,29.14) ; v1(46.1,17.6) 49.93,17.6 52.42,15.12 53.31,15.12 54.68,13.74 54.68,12.73 55.04,12.37 56.89,12.37 57.61,13.1 58.66,13.1 58.74,13.01 58.92,13.01 59.84,12.09 60.95,12.09 61.45,11.59 61.45,11.52 61.46,11.51 61.46,10.98 61.45,10.97 61.45,10.87 v1(61.45,10.86)
  BOTTOM w0.305: v1(17.29,70.26) 17.34,70.31 R7303.1 ; v1(217.01,39.65) 217.01,39.63 217.39,39.25 IOBD1.28 ; U4302.2 33.98,80.98 34.53,80.43 34.64,80.43 v1(34.67,80.41) 34.68,80.4 35.64,80.4 35.67,80.37 R4378.1 ; v1(55.7,33.1) 55.09,33.71 v1(53.72,33.71)
  BOTTOM w0.356: U4007.5 162.72,72.37 163.35,73 163.44,73
  BOTTOM w0.406: R7424.1 23.34,84.81 23.95,84.2 R7427.1 25.17,84.05 v1(25.32,84.2)
  BOTTOM w0.508: 170.43,64.26 170.43,66.78 168.65,68.56 168.65,70.21 169.11,70.67 169.56,70.67 169.92,71.02 170.28,71.02 170.4,71.15 v1(170.5,71.15) ; v1(34.16,58.91) 33.76,59.3 32.77,59.3 32.53,59.54 29.08,59.54 28.72,59.9 24.05,59.9 v1(23.39,59.24) ; v1(168.7,73.61) 167.68,73.61 167.33,73.26 R4034.1 164.61,73.26 164.36,73 163.44,73 ; v1(222.09,58.88) 222,58.97 Q6101.S ; v1(53.44,45.8) 52.54,45.8 52.38,45.96 50.48,45.96 50.18,46.26 48.91,46.26 47.87,45.21 45.51,45.21 45.46,45.16 42.06,45.16 41.17,46.05 39.24,46.05 v1(38.42,45.24) ; PR5208.1 146.98,73.74 v1(146.7,73.46) ; PR5114.1 73.48,13.9 v1(73.63,13.74) 74.19,14.3 PC5125.1 ; v1(61.45,10.86) 61.2,10.61 60.49,10.61 60.01,11.08 PR5104.1 ; v1(118.89,48.01) 118.83,47.96 118.48,47.96 118.03,47.51 118.03,46.98 118.54,46.48 120.26,46.48 122.87,43.87 128.49,43.87 v1(128.87,43.49) 129.62,42.74 137.43,42.74 137.67,42.5 139.79,42.5 140,42.71 v1(141.22,42.71) 150.29,42.71 151.44,43.87 156.74,43.87 157.49,43.12 160.72,43.12 161.16,43.56 v1(161.16,43.56) ; FC8903.1 184.02,37.85 v1(183.74,37.57) 181.45,37.57 180,36.12 v1(180,29.92) ; v1(84.12,96.6) 84.12,96.52 83.39,95.8 v2(81.6,95.8) 80.78,95.8 v1(80.74,95.84) ; v1(212.97,30.74) 212.95,30.71 212.08,30.71 211.2,31.6 211.2,32.57 v1(211.4,32.77) ; v1(158.49,74.58) 158.49,73.38 157.88,72.77 156.59,72.77 155.32,74.04 155.32,75.31 153.89,76.74 R8626.1 ; v1(171.44,9.55) 171.14,9.86 PR4472.1 169.44,9.86 PR4435.1 ; v1(26.21,38.69) 26.21,37.95 24.63,36.37 v1(24.63,36.17)
  vias: v1(43.2,78.77) v1(43.86,78.79) v1(208.1,42.4) v1(214.85,48.03) v2(119.65,48.14) v2(181.91,44.78) v2(209.06,42.6) v2(215.36,48.67) v3(15.95,27.89) v3(16.86,27.92) v3(29.03,95.46) v3(29.97,95.48) v3(32.38,16.69) v3(33.01,16.11) v3(33.6,15.5) v3(112.49,2.95) v3(113.05,3.63) v3(113.66,3) v3(181.6,45.67) v3(182.06,46.81) v3(182.19,5.29) v3(182.49,45.19) v3(182.62,46.05) v3(182.74,47.36) v3(182.8,5.95) v3(183.43,6.53) v3(207.11,44.2) v3(207.2,43.16) v3(207.94,44.2) v3(208.04,43.16) v3(214.47,48.67)
3D3V_S5_KBC: length 391.4
  TOP w0.203: 47.9,44.58 47.83,44.51 U2401.19 46.32,44.51 45.69,45.14 45.54,45.14 46.11,45.71 U2401.22 47.71,45.71 48.13,46.13 48.13,46.59 48.74,47.2 C2410.1 ; 34.82,34.62 34.97,34.62 35.58,35.23 U2401.103 ; 42.46,52.68 41.58,51.8 U2401.43 41.58,50.05 41.35,49.81 41.35,49.08 ; U2401.115 40.38,35.21 40.66,34.93 40.66,34.17 40.46,33.96 v1(40.46,33.86) ; 30.63,42.95 30.67,42.91 U2401.82 ; 45.02,38.14 45.57,38.14 46.34,38.91 U2401.5 48.74,38.91 C2411.1
  TOP w0.305: DBG3.1 92.86,8.41 92.09,9.17 v1(92.09,9.76)
  TOP w0.457: v1(40.46,33.86) 40.47,33.85 40.47,33.57 40.89,33.15 C2422.1
  TOP w0.508: v1(92.09,9.76) 94.56,9.76 95.12,9.2 96.36,9.2 97.02,8.54 97.33,8.54 v1(97.4,8.46) ; 45.02,38.14 42.96,38.14 v1(41.73,39.37) ; R2424.2 54.78,47.48 54.27,46.98 53.71,46.98 v1(53.26,47.42) ; D4304.2 113.76,8.47 v1(113.76,8.44) 115.21,8.44 D4305.2 116.23,6.41 114.65,4.83 D4306.2 114.65,2.95 114.93,2.67 v1(114.93,2.49) ; R2414.2 28.09,41.2 27.7,40.81 27.67,40.81 27.66,40.81 v1(27.54,40.81) ; 30.63,42.95 v1(29.59,42.95) 29.51,42.88 C2429.1 28.95,43.05 28.19,43.81 R2478.1 ; R2415.1 52.29,50.04 v1(52.34,49.99) ; 34.82,34.62 34.31,34.11 C2420.1 34.16,34.04 33.36,33.24 33.36,32.33 33.86,31.83 v1(33.95,31.83) ; R4032.1 205.42,44.49 206.22,45.29 v1(206.42,45.29) ; 41.35,49.08 41.24,48.97 41.24,42.19 40.86,41.81 40.86,40.31 41.73,39.45 v1(41.73,39.37) ; v1(41.73,39.37) 43.63,41.28 43.63,43.23 45.54,45.14
  L3 w0.508: v1(48.09,53.93) 48.1,53.93 49.6,53.93 50.08,53.45 50.08,53.45 50.95,52.58 50.95,51.39 v1(52.34,49.99) 52.34,48.34 v1(53.26,47.42) 53.59,47.09 54.35,47.09 57.07,44.37 v1(57.07,43.74) 56.81,43.49 56.81,41.52 57.8,40.54 57.8,39.31 58.29,38.82 58.29,36.76 64.58,30.46 64.58,21.84 64.08,21.34 64.08,20.65 64.58,20.15 64.58,18.17 67.86,14.89 73.86,14.89 77.36,11.38 79.72,11.38 80.39,10.72 91.13,10.72 v1(92.09,9.76) ; v1(29.59,42.95) 29.28,42.65 29.28,39.95 29.31,39.92 29.31,36.93 ; 29.31,36.93 v1(27.07,34.7) ; 29.31,36.93 29.96,36.28 29.96,34.03 29.43,33.51 29.43,31.78 29.66,31.55 29.66,30.2 30.94,28.92 32.3,28.92 33.95,30.58 v1(33.95,31.83) ; v1(206.42,45.29) 206.73,45.6 207.87,45.6 208.93,46.66 211.89,46.66 213.59,44.96 213.59,42.43 212.8,41.63 212.8,38.92 213.91,37.8 213.91,35.13 213.86,35.08 213.86,29.44 215.82,27.49 215.82,22.89 214.34,21.41 v1(214.34,20.48) ; v1(40.46,33.86) 40.44,33.87 40.44,37.62 41.75,38.93 41.75,39.35 v1(41.73,39.37)
  L4 w0.508: v1(28.06,54.79) 30.85,54.79 31.1,55.04 33.21,55.04 36.18,52.08 38.38,52.08 39.64,53.34 40.85,53.34 41.41,53.9 42.12,53.9 42.15,53.93 v1(48.09,53.93)
  L6 w0.508: v1(212.22,7.86) 211.64,7.28 206.22,7.28 204.88,8.62 204.04,8.62 202.58,10.08 202.58,12.85 200.07,15.36 193.98,15.36 190.69,12.07 186.35,12.07 185.01,10.72 184.48,10.72 183.79,10.03 183.79,9.03 179.33,4.57 163.52,4.57 162.68,5.41 158.97,5.41 157.58,4.02 152.55,4.02 152.5,3.97 149.27,3.97 149.23,4 127.44,4 126.11,2.67 116.86,2.67 116.68,2.49 v1(114.93,2.49) ; v1(113.76,8.44) 113.03,9.17 98.11,9.17 v1(97.4,8.46)
  BOTTOM w0.356: v1(27.2,51.23) 27.15,51.23 26.51,50.6 Q2417.2 Q2417.5
  BOTTOM w0.508: v1(214.34,20.48) 214.4,20.48 215.49,19.38 215.49,13.54 212.13,10.19 212.13,7.95 v1(212.22,7.86) ; v1(33.95,31.83) 34.13,31.83 34.63,32.33 34.63,32.89 35.24,33.51 35.77,33.51 36.02,33.25 38.6,33.25 38.98,33.63 38.98,33.66 39.19,33.86 v1(40.46,33.86) ; v1(27.54,40.81) 27.54,40.91 v1(29.59,42.95)
  vias: v2(25.17,33.73) v2(25.98,55.03) v2(26.3,46.58) v2(48.28,55.16) v2(51.15,38.64) v2(57.22,45.29)
3D3V_S5_PCH: length 288.8
  TOP w0.508: R2515.2 v2(192.88,38.69) 193.36,38.69 v1(194.84,37.21) ; R1510.2 R1508.2 132.04,51.39 132.4,51.03 133.73,51.03 134.23,51.54 v1(134.23,51.72) ; R1502.1 127.98,64.95 127.5,65.43 v1(127.34,65.43) ; R9148.1 v1(196.87,36.22) ; v1(136.06,43.56) 135.96,43.66 135.96,43.97 135.17,44.76 R1837.1 135.63,46.43 R303.1 135.96,47.81 R1506.1 ; R406.1 101.01,93.25 103.05,93.25 103.63,93.82 v1(103.63,93.88) 104.16,94.41 R405.1 ; v3(149.96,81.87) 150.13,82.04 150.13,84.48 150.64,84.99 151.56,84.99 152.14,85.58 152.14,87.38 151.4,88.12 149.5,88.12 149.35,88.27 R1103.1 ; R2516.2 213.07,27.89 212.24,27.06 v1(212.24,26.39) ; v1(161.28,44.2) 161.59,44.51 161.59,45.82 162.38,46.61 166.19,46.61 v1(167.15,47.58)
  L3 w0.508: v1(162.1,50.09) 161.87,50.32 161.87,52.33 158.03,56.16 155.92,56.16 154.88,57.2 154.88,68.71 151.83,71.76 147.12,71.76 145.79,70.44 142.99,70.44 142.28,71.15 v1(139.81,71.15) 139.81,71.3 137.73,73.38 v1(137.18,73.38) ; v1(143.22,83.8) 143.22,82.43 145.94,79.71 v1(146.82,79.71)
  L4 w0.508: v1(162.1,50.09) 162.81,50.8 164.05,50.8 164.43,50.42 166.36,50.42 167.08,49.71 167.08,47.68 167.15,47.6 v1(167.15,47.58) 168.14,48.57 168.91,48.57 169.36,48.11 169.36,47.53 170.48,46.41 171.57,46.41 179.39,38.59 193.47,38.59 v1(194.84,37.21) 194.81,37.19 194.81,36.46 195.18,36.09 196.74,36.09 v1(196.87,36.22) 197.68,37.04 204.47,37.04 208.6,32.9 208.6,30.61 209.32,29.9 209.34,29.9 209.7,29.54 209.7,29.52 212.24,26.97 v1(212.24,26.39) ; v1(148.86,76.96) 148.58,76.69 146.98,76.69 144.29,73.99 v1(143.73,73.99) 143.73,73.87 143.71,73.84 143.71,73.75 143.34,73.38 142.17,73.38 142.17,73.39 141.54,73.39 141.52,73.41 141.16,73.41 140.69,72.93 137.63,72.93 v1(137.18,73.38) 136.54,72.75 135.55,72.75 133.65,70.84 131.52,70.84 131.51,70.85 130.48,70.85 128.7,69.07 128.7,66.79 v1(127.34,65.43)
  L6 w0.508: v1(111.02,95.08) 111.25,94.85 112.67,94.85 113.21,95.38 113.8,95.38 115.57,93.6 122.32,93.6 126.61,89.31 139.52,89.31 139.54,89.28 139.62,89.28 143.22,85.68 v1(143.22,83.8) 145.84,83.8 146.73,82.91 148.69,82.91 149.73,81.87 v3(149.96,81.87) ; v1(136.06,43.56) 136.06,47.86 135.02,48.9 135.02,50.93 v1(134.23,51.72) ; v1(148.86,76.96) 146.82,79.01 v1(146.82,79.71)
  BOTTOM w0.254: v1(136.06,43.56) 136.37,43.25 137.64,43.25 137.88,43 139.57,43 139.79,43.22 150.08,43.22 151.23,44.38 156.95,44.38 157.7,43.63 160.51,43.63 161.08,44.2 v1(161.28,44.2)
  BOTTOM w0.406: v1(146.82,79.71) 146.73,79.62 R1504.1
  BOTTOM w0.508: R1513.1 138.42,67.8 138.27,67.95 138.27,68.74 138.77,69.24 138.99,69.24 139.81,70.07 v1(139.81,71.15) ; R1522.1 142.95,72.7 143.5,73.26 R1551.1 143.71,73.28 143.71,73.97 v1(143.73,73.99) ; v1(103.63,93.88) 103.67,93.84 103.69,93.84 104.18,93.35 107.59,93.35 109.16,94.92 110.87,94.92 v1(111.02,95.08)
3D3V_SPIVCC1: length 14.8
  BOTTOM w0.508: C2501.1 188.27,28.78 190.27,30.79 U2501.8 190.97,32.41 191.48,32.92 191.48,36.7 191.01,37.16 188.94,37.16 188.43,36.66 v1(188.43,35.64)
  vias: v2(185.8,38.97)
3D3V_SSD: length 5.4
  TOP w0.508: R6339.1 215.51,5.67
  vias: v1(216.99,3.58) v1(217.72,3.58) v1(218.48,3.58) v1(218.99,20.88) v1(218.99,20.2) v1(218.99,19.43) v2(217.01,5.54)
3D3V_TBT: length 4.7
  TOP w0.089: 80.99,100.21 80.03,100.21 79.84,100.02 79.25,100.02 U7204.H2
  TOP w0.102: 80.99,100.21 81.15,100.36 81.22,100.36
  TOP w0.254: C7225.1 82.72,101.78 v2(81.45,100.51) 81.43,100.49 81.35,100.49 81.22,100.36
3D3V_TP_S5_R: length 8.1
  TOP w0.356: v1(172.82,16.46) 172.36,16.46 v2(172.13,16.23)
  TOP w0.381: v1(172.82,16.46) 173.43,15.85 C6503.1 173.25,14.38 R6521.2
  BOTTOM w0.381: Q6504.S 171.31,17.23 172.08,16.46 v1(172.82,16.46)
3D3V_TP_VDD: length 18.8
  TOP w0.356: R6502.2 172.64,11.43 172.49,11.28 v1(172.31,11.28)
  TOP w0.381: v1(173.44,13.81) 173.44,12.79 173.3,12.65 R6502.2
  BOTTOM w0.381: TPAD1.8 173.21,14.04 173.3,13.95 ; v1(178.4,8.97) 175.51,8.97 174.58,8.04 173.22,8.04 172.89,8.38 172.89,10.28 173.15,10.55 173.15,11.09 172.97,11.28 v1(172.31,11.28) ; 173.3,13.95 v1(173.44,13.81) ; 173.3,13.95 172.31,13.95 170.84,15.42 Q6504.D
3D3V_TPAN_VDD: length 3.1
  BOTTOM w0.305: LCD1.40 57.56,91.79 57.78,91.57 v1(57.78,90.59) 57.78,89.72 C5503.1
  vias: v2(58.13,92.23)
3D3V_TPM: length 13.1
  TOP w0.254: R9150.2 R9149.2 R9144.1 200.78,39.7 v1(200.76,39.68) 200.45,39.37 198.47,39.37 R9153.1 ; v2(196.64,34.83) 197.37,34.83 v1(197.43,34.76) 197.52,34.67 R9140.1
  L3 w0.254: v1(197.43,34.76) 197.43,36.35 v1(200.76,39.68)
3D3V_TPM_VHIO: length 22.6
  TOP w0.254: U9101.22 200.06,34.38 198.77,33.1 C9113.1 ; v1(206.2,39.32) 206.17,39.29 206.17,38.94 206.42,38.69 C9112.1 207.72,38.69 C9109.1 206.9,37.32 v2(206.45,37.32) 206.01,36.88 U9101.8 ; v1(203.3,39.73) 203.27,39.7 R9144.2
  TOP w0.305: R9139.2 203.88,40.31 v1(203.3,39.73)
  TOP w0.508: C9113.1 199.43,32.79 199.54,32.69 v1(199.92,32.69)
  L4 w0.254: v1(206.2,39.32) 205.77,39.75 203.34,39.75 203.32,39.73 v1(203.3,39.73)
  BOTTOM w0.254: v1(203.3,39.73) 203.27,39.7 203.25,39.7 201.04,37.49 201.04,33.81 v1(199.92,32.69)
3D3V_TPM_VSB: length 6.5
  TOP w0.254: U9101.1 206.12,33.38 207.39,34.65 v2(208.22,34.65) 208.27,34.65 209.11,33.81 C9106.1 209.57,33.81 209.77,33.61 C9108.1 210.1,33.84 R9143.2
3D3V_VCCDSW: length 217.9
  TOP w0.254: v1(210.36,26.75) 210.46,26.85 210.46,27.61 R2516.1 211.4,30.25 R2511.2 ; v1(117.73,69.25) 117.7,69.21 117.7,67.61 C2224.1 118.28,67.03 118.28,66.93 118.92,66.3 R1707.1 ; RN1704.2 120.19,48.75 120.06,48.62 119.68,48.62 119.52,48.78 RN1704.1 119.28,49.19 119.04,49.43 R1722.1 118.49,49.23 v1(118.49,48.57) ; v1(167.18,65.46) 167.15,65.43 167.1,65.43 166.85,65.18 R1822.1 166.8,64.52 166.8,61.45 v2(166.1,60.75) 165.88,60.75 164.15,59.03 164.15,56.26 162.88,54.99 162.88,54.05 161.83,53 160.18,53 159.58,52.4 157.27,52.4 v1(156.71,51.84) ; R1525.1 144.27,45.32 R1520.1 144.37,44.43 143.43,43.49 143.43,42.6 143.49,42.54 143.49,41.06 143.19,40.76 142.5,40.76 142.08,41.18 v1(142.08,41.99)
  L3 w0.254: v1(117.73,69.25) 117.75,69.23 117.75,69.2 118.29,68.66 123.15,68.66 124.02,67.79 124.02,67.27 125.04,66.25 126.38,66.25 126.85,65.78 126.85,65.23 129.4,62.69 132.3,62.69 v1(132.73,63.12) 133.45,63.84 133.75,63.84 134.43,64.52 139.21,64.52 140.41,63.32 141.63,63.32 143.12,61.83 143.12,61.7 145.31,59.51 145.31,58.6 152.06,51.84 v1(156.71,51.84) 156.71,50.65 156.89,50.47 156.89,49.79 159.51,47.17 159.51,46.05 160.57,44.99 161.59,44.99 162.6,43.97 162.6,42.9 169.13,36.38 170.5,36.38 170.5,36.37 170.71,36.37 172.52,34.57 172.52,34.53 173.19,33.86 v1(173.91,33.86)
  L6 w0.254: v1(132.73,63.12) 132.73,59.64 135.96,56.42 138.06,56.42 140.05,54.43 140.05,53.65 141.32,52.38 141.32,50.52 142.08,49.76 v1(142.08,41.99) ; v1(210.36,26.75) 207.83,26.75 206.01,24.93 202.68,24.93 199.46,28.15 193.9,28.15 192.43,29.62 188.46,29.62 188.23,29.85 184.57,29.85 182.61,31.8 178.07,31.8 177.03,32.84 176.8,32.84 175.79,33.86 v1(173.91,33.86)
  BOTTOM w0.254: U2502.1 167.61,61.19 167.05,61.75 167.05,65.33 v1(167.18,65.46) ; v1(118.49,48.57) 118.37,48.57 117.52,47.72 117.52,46.77 118.6,45.7 120.31,45.7 122.7,43.31 128.31,43.31 129.39,42.24 137.22,42.24 137.46,41.99 v1(142.08,41.99) ; CPU1.BT23 118.31,70.1 118.31,69.91 CPU1.BR24 117.75,69.35 117.75,69.26 v1(117.73,69.25)
3D3V_VCCPRIM: length 41
  TOP w0.508: v1(146.33,65.81) 145.69,65.17 R1731.1
  L6 w0.508: v1(141.17,74.04) 141.17,74.31 141.54,74.68 143.95,74.68 144.47,74.15 144.47,72.82 144.7,72.6 144.7,67.97 146.33,66.34 v1(146.33,65.81)
  BOTTOM w0.203: CPU1.BP23 117.45,70.54 117.6,70.54 117.9,70.84 119.81,70.84 120.01,70.64 120.01,70.5 CPU1.BV23 ; CPU1.CP29 129.79,66.93 130.14,66.93 v1(130.47,67.26)
  BOTTOM w0.305: CPU1.BW23 120.65,70.39 v1(120.34,70.08) ; v1(119.68,70.08) 119.68,70.17 CPU1.BV23 ; CPU1.BT20 118.38,71.85 v1(118.38,71.73) ; CPU1.CB16 122.6,74.59 v1(122.27,74.27)
  BOTTOM w0.508: 140.74,74.83 141.17,74.4 v1(141.17,74.04) ; 140.74,74.83 140.79,74.83 141.22,75.26 142.51,75.26 144.21,76.96 147.87,76.96 148.56,77.65 149.79,77.65 150.12,77.32 151.26,77.32 151.63,77.69 151.63,78.54 149.22,80.95 148.25,80.95 v1(147.2,82.01) ; 140.74,74.83 R1701.1
  vias: v1(122.93,70.9) v1(123.58,70.9) v2(123.01,72.65) v2(146.17,82.5)
3D3V_VCCPRTC: length 48.9
  TOP w0.254: v2(117.95,72.37) 117.88,72.29 C2221.1 C2222.1 116.3,71.55 117.72,70.14 v1(117.72,70.06) ; v1(141.9,53.67) 141.9,53.65 142.69,52.86 144.24,52.86 144.62,52.48 R2204.2
  L4 w0.254: v1(140.76,63.83) 140.39,64.2 135.54,64.2 133.78,62.44 130.4,62.44 129.22,63.61 125.53,63.61 124.96,64.18 124.96,64.76 124.91,64.81 124.91,66.37 124.02,67.27 124.02,67.83 123.21,68.63 118.87,68.63 118.23,69.27 118.23,69.5 117.72,70.01 v1(117.72,70.06)
  L6 w0.254: v1(140.76,63.83) 140.86,63.73 140.86,59.52 141.7,58.68 141.7,53.88 v1(141.9,53.67)
  BOTTOM w0.203: v1(117.72,70.06) 117.75,70.1 117.75,70.11 118.05,70.4 CPU1.BR23
3D3V_WLAN: length 33.4
  TOP w0.508: v1(198.77,50.29) 198.32,50.75 198.32,51.59 198.37,51.64 R6142.1 ; v1(203.88,57.36) 203.8,57.28 R6102.1
  L3 w0.508: v3(214.09,53.16) 215.54,54.61 218.31,54.61 v1(220.64,56.95) ; v1(198.77,50.29) 197.83,49.35 194.1,49.35 193.67,48.92 v1(193.21,48.92)
  L6 w0.508: v3(214.09,53.16) 214.09,53.26 211.27,56.09 205.04,56.09 203.88,57.25 v1(203.88,57.36)
  BOTTOM w0.508: Q6101.D 220.44,57.71 FC6101.1 220.21,57.38 v1(220.64,56.95) ; C6106.1 192.09,50.04 v1(193.21,48.92)
27MHZ_IN: length 21
  BOTTOM w0.102: X7901.1 186.44,61.05 186.89,61.5 v2(186.89,61.93) 186.89,61.95 186.48,62.36 186.46,62.36 186.02,62.79 185.16,62.79 184.88,63.07 C7907.2 184.88,63.68 R7903.1 185.82,64.26 186.76,65.2 186.76,69.32 190.14,72.7 190.14,74.75 189.53,75.36 189.17,75.36 188.77,75.77 GPU1.C11
27MHZ_OUT: length 13.8
  BOTTOM w0.102: GPU1.B10 188.95,75.15 189.05,75.06 189.4,75.06 189.83,74.63 189.83,72.82 186.46,69.45 186.46,65.43 v2(186.35,65.33) 186.15,65.13 R7903.2 R7904.2
27MHZ_OUT_R: length 3.6
  BOTTOM w0.102: v2(182.88,62.04) X7901.3 184,62.77 184.32,63.09 C7908.2 184.32,63.66 184.7,64.04 R7904.1
65982_GPIO1: length 6.4
  TOP w0.089: U7204.C2 79.25,98.01 79.68,98.01 79.77,97.93 79.77,97.92 79.82,97.87 79.82,97.82 79.95,97.69
  TOP w0.102: 79.95,97.69 80.71,96.93 80.94,96.93 v2(81.2,96.68) 81.43,96.45 81.43,96.09 81.78,95.74 83.46,95.74 R7243.1
65982_GPIO2: length 5.9
  TOP w0.089: U7204.D10 74.98,98.27 74.73,98.52 74.01,98.52
  TOP w0.102: v2(71.22,97.06) 71.42,97.26 R7247.2 R7248.1 71.72,98.71 72.33,98.1 73.59,98.1 74.01,98.52
65982_GPIO3: length 4
  TOP w0.102: R7222.1 72.28,101.48 v2(72.4,101.36) 72.49,101.27 72.49,100.99 72.85,100.63 73.26,100.63 74.12,99.77 U7204.G11
65982_GPIO8: length 13.9
  TOP w0.102: v1(71.37,106.07) 70.43,107.01 R7244.2 70.05,107.06 v2(69.21,107.06) 69.21,106.28 R7245.1 ; U7204.H6 77.1,100.36 77.13,100.36 77.36,100.59 77.62,100.59 v1(77.79,100.76)
  BOTTOM w0.102: v1(71.37,106.07) 71.44,106.15 72.46,106.15 74.47,104.14 75.53,104.14 77.79,101.88 v1(77.79,100.76)
65982D_AUXN: length 6.8
  TOP w0.089: U7204.J2 79.02,100.77 79.26,101.01 79.68,101.01 79.75,100.94
  TOP w0.102: RN7203.7 81.68,105.09 81.76,105.01 81.76,104.83 81.81,104.78 81.81,104.04 81.25,103.48 81.25,103.3 ; 81.25,103.3 81.25,101.6 80.6,100.94 79.75,100.94 ; 81.25,103.3 v2(81.07,103.3)
65982D_AUXP: length 6.6
  TOP w0.102: 82.04,104.3 82.04,104.78 82.09,104.83 82.09,104.93 82.26,105.11 RN7203.8 ; 82.04,104.3 82.04,103.95 81.48,103.39 81.48,101.67 81.48,101.5 80.69,100.71 79.56,100.71 U7204.J1 ; 82.04,104.3 v2(82.21,104.3)
65982D_BUSPWR: length 8.3
  TOP w0.089: U7204.F10 74.76,99.51 74.34,99.51 74.33,99.5 73.82,99.5 73.71,99.61 v1(73.7,99.61)
  TOP w0.254: R7229.1 69.79,100.84 72.26,100.84 72.74,100.36 73.09,100.36 73.69,99.76 73.69,99.62 v1(73.7,99.61)
  BOTTOM w0.254: R7233.2 73.17,99.16 v2(73.25,99.24) 73.62,99.61 v1(73.7,99.61)
65982D_DBG_CTL1: length 5.4
  TOP w0.102: U7204.E4 78.18,98.94 78.43,98.94 v1(78.51,99.01)
  BOTTOM w0.102: v1(78.51,99.01) 78.5,99.01 77.65,98.16 77.65,97.64 78.23,97.05 78.76,97.05 v2(79.24,96.57) 79.17,96.5 79.17,95.59 RN7204.1
65982D_DBG_CTL2: length 5.2
  TOP w0.102: U7204.D5 77.63,98.27 v1(78.09,97.8)
  BOTTOM w0.102: RN7204.2 79.82,95.8 80.61,96.59 v2(80.61,96.71) 80.48,96.84 79.69,96.84 78.99,97.54 78.36,97.54 v1(78.09,97.8)
65982D_DEBUG1: length 29.2
  TOP w0.089: v1(78.96,104.22) 79.26,103.92 79.26,102.46 79.24,102.44 79.24,102.37 79.01,102.13 U7204.L2
  BOTTOM w0.089: v1(78.96,104.22) 78.76,104.42 74.59,104.42 72.49,106.53 71.16,106.53 70.23,105.59 v2(70.23,104.85) 70.38,104.85 71.29,103.94 74.09,103.94 76.37,101.65 76.37,100.54 75.89,100.05 75.25,100.05 75.2,100 75.08,100 73.93,98.86 73.93,97.18 74.19,96.93 74.49,96.93 74.7,97.13 R7218.2
65982D_DEBUG2: length 31.5
  TOP w0.089: v1(78.45,100.71) U7204.K2
  BOTTOM w0.089: v1(78.45,100.71) 78.5,100.75 78.5,101.87 79.41,102.79 79.41,104.48 79.19,104.7 74.7,104.7 72.59,106.81 71.06,106.81 69.79,105.54 69.79,104.6 70.73,103.66 v2(71.06,103.66) 73.93,103.66 74.56,103.04 74.61,103.04 76.09,101.55 76.09,100.59 75.79,100.28 74.97,100.28 73.65,98.96 73.65,97.08 74.26,96.47 R7219.2
65982D_DEBUG3: length 3.5
  TOP w0.102: R7220.1 78.23,104.93 78.23,103.66 78.71,103.18 v2(78.71,102.95) 78.71,102.54 78.51,102.34 U7204.L3
65982D_DEBUG4: length 5.3
  TOP w0.089: 78.85,102.27 78.76,102.18 78.76,101.52 U7204.K3
  TOP w0.102: v2(79.7,104.24) R7226.1 78.53,104.5 78.53,104.04 79.06,103.51 79.06,102.49 78.85,102.27
65982D_EE_CLK: length 24.6
  TOP w0.089: U7204.A3 78.44,96.7 78.44,92.08 79.45,91.07 80.29,91.07 81.15,91.93 81.15,91.99 81.4,92.24 81.95,92.24 v1(82.43,91.75)
  BOTTOM w0.089: U7205.6 71.77,91.82 71.58,91.63 71.14,91.63 71.04,91.53 71.04,90.75 71.6,90.19 81.43,90.19 v2(82.1,90.86) 82.37,91.13 82.37,91.48 82.37,91.48 82.37,91.69 v1(82.43,91.75)
65982D_EE_CS_N: length 14.3
  TOP w0.089: v1(80.49,91.87) 80.06,91.44 79.6,91.44 78.81,92.23 78.81,95.23 78.76,95.28 78.76,95.33 78.75,95.33 78.75,97.02 U7204.B3
  BOTTOM w0.089: U7205.1 77.4,94.95 78.56,93.79 v2(78.56,93.24) 78.56,93.03 79.29,92.3 79.29,91.76 79.6,91.44 80.06,91.44 v1(80.49,91.87) 80.49,92.36 80.31,92.53 R7255.2
65982D_EE_DI: length 13.6
  TOP w0.089: U7204.B4 78.25,97.02 78.25,95.28 77.97,94.99 77.97,94.14 v2(78,94.11) 78,91.8 v1(78.12,91.67)
  BOTTOM w0.089: U7205.5 71.77,90.73 71.95,90.56 77.7,90.56 78.12,90.98 v1(78.12,91.67)
65982D_EE_DO: length 18.1
  TOP w0.089: v1(81.58,91.81) 80.47,90.71 78.49,90.71 77.6,91.6 77.6,95.1 78.02,95.52 78.02,95.85 78.01,95.86 U7204.A4
  BOTTOM w0.089: U7205.2 77.39,93.68 78.92,92.15 78.92,91.34 79.22,91.04 v2(80.78,91.04) 81.24,91.04 81.58,91.39 v1(81.58,91.81) 81.58,92.15 81.07,92.66 R7254.2
65982D_GND: length 5.6
  TOP w0.254: U7204.H7 76.51,100.39 76.8,100.69 v1(76.8,100.76)
  BOTTOM w0.127: v1(76.8,100.76) 76.8,100.41 75.92,99.53 75.92,99.33 75.63,99.04 C7223.2
  BOTTOM w0.254: v2(74.31,97.36) 74.29,97.39 74.29,98.64 74.67,99.02 C7223.2
65982D_HRESET: length 2.9
  TOP w0.102: v1(77.21,97.76) 77.21,97.78 77.01,97.99 U7204.D6
  BOTTOM w0.102: R7221.1 78.28,96.16 v2(77.72,96.73) 77.51,96.93 77.51,97.25 77.21,97.55 v1(77.21,97.76)
65982D_I2C_ADDR: length 5.3
  TOP w0.102: U7204.F1 80.94,99.27 81.53,98.68 v1(81.93,98.68)
  BOTTOM w0.102: R7232.2 83.09,99.1 82.66,99.1 82.24,98.68 v1(81.93,98.68) 81.91,98.66 81.91,98.25 v2(82.26,97.89)
65982D_LDO_1V8A: length 7.9
  TOP w0.152: v1(80.59,101.55) 80.51,101.48 80.51,101.47 80.29,101.25 79.93,101.25 79.91,101.27 U7204.K1
  TOP w0.254: v1(80.59,101.55) 80.87,101.83 v2(80.87,102.09)
  L6 w0.254: v1(80.59,101.55) 80.64,101.5 83.23,101.5 83.31,101.58 84.86,101.58 85.31,101.13 v1(85.31,101.12)
  BOTTOM w0.254: C7224.2 85.72,101.52 v1(85.31,101.12)
65982D_LDO_1V8D: length 3
  TOP w0.229: 79.04,95.76 79.04,96.73 U7204.A2
  TOP w0.254: C7226.2 79.6,94.82 v2(79.29,95.13) 79.04,95.38 79.04,95.76
65982D_LDO_BMC: length 5.5
  TOP w0.203: U7204.E1 80.35,98.77 80.44,98.68 80.44,98.68 80.81,98.31 80.81,98.31 81.4,97.72 v2(81.88,97.72) 82.19,97.72 82.37,97.89 83.97,97.89 C7230.2
65982D_LSTX_P2R: length 3.1
  TOP w0.089: U7204.K4 78.25,101.51 78.25,102.02
  TOP w0.102: 78.25,102.02 78.25,102.44 78.33,102.52 78.33,103.23 TP7207.1
65982D_LSTX_R2P: length 5.4
  TOP w0.102: U7204.L4 78.01,102.55 78.12,102.67 78.12,103.03 77.85,103.3 77.72,103.3 77.59,103.43 77.59,103.48 77.51,103.56 77.49,103.56 77.34,103.71 77.31,103.71 77.21,103.81 TP7206.1 R7242.1
65982D_MRESET: length 3.6
  TOP w0.102: U7204.E11 73.97,98.77 73.71,98.5 v2(73.17,98.5) 72.43,98.5 71.47,99.47 R7223.1
65982D_PD_HPD: length 12.5
  TOP w0.102: U7204.C10 75.51,97.77 v1(75.56,97.82) ; R7236.2 71.93,93.8 72.46,94.34 v2(72.51,94.34) 72.56,94.34 v1(74.06,95.84)
  L3 w0.102: v1(74.06,95.84) 74.57,95.33 77.77,95.33 78.05,95.61 78.05,95.96 77.79,96.22 77.77,96.22 76.75,97.23 76.75,97.87 76.42,98.2 76.02,98.2 75.64,97.82 v1(75.56,97.82)
65982D_PRD_CC1: length 4.3
  TOP w0.089: U7204.K9 75.75,101.51 75.75,102.12 75.71,102.16
  TOP w0.102: R7225.1 74.24,104.55 v2(74.82,103.97) 75.19,103.6 75.19,102.68 75.71,102.16
65982D_PRD_CC2: length 5.5
  TOP w0.089: 74.44,103.13 74.75,102.82 74.75,102.47 75.25,101.96 75.25,101.51 U7204.K10
  TOP w0.102: 74.44,103.13 73.6,103.96 v2(73.2,103.96) 73.17,103.94 R7224.1
65982D_RESET_N: length 2.3
  TOP w0.102: TP7205.1 72.89,99.8 73.57,99.12 73.71,99.12 73.8,99.21 74.45,99.21 U7204.F11
65982D_ROSC: length 6
  TOP w0.089: 80.1,99.52 79.25,99.52 U7204.G2
  TOP w0.102: 80.1,99.52 81.38,99.52 v1(81.63,99.27)
  BOTTOM w0.102: R7237.1 82.95,99.7 82.39,99.14 81.76,99.14 v1(81.63,99.27) 81.1,98.73 v2(81.1,98.28)
65982D_SBU1: length 5.2
  TOP w0.089: 76.17,102.31 76.18,102.31 76.18,102.02 76.22,101.97 76.25,101.93 76.25,101.51 U7204.K8
  TOP w0.102: 76.17,102.31 76.17,102.32 75.64,102.86 75.64,104.04 75.03,104.65 75.03,105.72 TP7201.1
65982D_SBU2: length 6.3
  TOP w0.102: TP7202.1 73.86,106.56 73.86,105.74 74.31,105.29 74.54,105.29 74.64,105.18 74.64,104.96 74.77,104.83 74.77,104.6 75.44,103.93 75.44,102.76 75.97,102.24 75.97,101.81 U7204.L8
65982D_UART_RX: length 12.9
  TOP w0.089: U7204.E2 79.25,99.01 80.82,99.01 81.55,98.28 82.1,98.28 82.37,98.55 82.37,98.81 v2(82.47,98.91) 82.52,98.96 82.52,99.24 v1(82.19,99.57)
  TOP w0.102: v1(80.03,101.91) 80.06,101.94 80.06,102.83 80.59,103.36 80.59,103.74 81.18,104.32 RN7203.6 ; U7204.F2 U7204.E2
  L4 w0.102: v1(82.19,99.57) 80.97,100.79 80.54,100.79 80.03,101.3 v1(80.03,101.91)
+DC_IN: length 12.5
  BOTTOM w0.406: R4376.1 36.89,85.11 v2(36.09,85.91) 35.81,86.18 32.53,86.18 ; 32.53,86.18 v1(32.53,88.11) ; 32.53,86.18 Q4305.2
  vias: v2(33.39,88.86)
+DC_IN_C:
  vias: v3(29.25,92.59) v3(30.09,92.59) v3(30.98,92.59) v3(31.9,92.51)
+RTC_VCC: length 23.8
  TOP w0.508: R2506.1 R2504.1 206.8,11.99 AFTP2502.1 208.63,11.48 208.63,8.75 Q2501.G 209.05,8.59 210.14,9.68 213.66,9.68 215.22,11.24 215.22,13.05 212.64,15.62 212.64,16.51 211.96,17.2 211.96,18.95 212.71,19.7 D2501.2
+SDC_IN: length 68.1
  TOP w0.356: v1(168.8,6.48) 168.6,6.28 PR4434.2
  TOP w0.508: R7406.1 34.49,79.33 34.85,79.69 35.51,79.69 v1(35.55,79.73) v2(35.55,78.96) 35.55,78.83 Q8612.S 37.32,77.07 38.58,77.07 38.98,77.47 R4370.1 R4318.1 42.06,77.47 C4343.2
  L3 w0.508: v3(25.8,85.65) 25.8,85.5 28.2,83.1 28.2,82.6 27.1,81.5 27.1,78.12 v1(27.1,78.11) ; 19.98,28.3 19.98,29.72
  L4 w0.508: v1(168.8,6.48) 168.55,6.73 168.55,9.32 170,10.77 170,11.74 169.87,11.86 169.87,13.54 170.34,14.01 170.34,15.07 167.58,17.83 v1(166.72,17.83)
  L6 w0.508: 150.26,17.73 152.44,17.73 153.13,17.05 155.27,17.05 155.88,16.44 163.56,16.44 164.24,17.12 166.01,17.12 v1(166.72,17.83) ; v1(35.55,79.73) 35.55,79.5 33.26,77.21 29.5,77.21 28.98,77.72 27.5,77.72 27.11,78.11 v1(27.1,78.11)
  BOTTOM w0.254: PG4401.1 151.6,12.7 150.41,12.7 150.16,12.95 PR4401.1
  BOTTOM w0.508: v1(35.55,79.73) 35.1,79.73 35.06,79.69 Q4348.S
  vias: v1(13.89,87.12) v1(14.52,87.05) v1(14.93,87.56) v1(15.44,87.18) v1(18.26,93.2) v1(18.61,92.66) v3(25.65,87.3) v3(25.93,86.49) v3(26.53,87.34) v3(28.49,26.88) v3(37.76,17.07) v3(37.87,17.94) v3(38.6,17.22) v3(96.13,7.29) v3(96.13,6.45) v3(148.81,17) v3(149.65,16.97) v3(150.54,16.94) v3(151.43,16.97)
+SDC_IN_SW: length 52
  TOP w0.254: v1(25.95,84.28) 26.09,84.14 PU4302.4 ; R4368.1 R4333.2 41.37,79.76 R4318.2 41.45,78.26 C4343.1 42.69,77.75 42.69,77.12 42.41,76.84 41.24,76.84 41.22,76.81 v1(40.05,76.81)
  L3 w0.254: v1(35.68,68.51) 35.68,71.22 36.29,71.83 36.29,71.88 38.37,73.97 38.37,74.22 38.81,74.65 38.81,75.77 39.36,76.33 39.49,76.33 39.97,76.81 v1(40.05,76.81) ; v1(25.95,84.28) 25.95,84.23 26.46,83.72 26.46,79.25 26.08,78.87 26.08,76.08 25.6,75.59 25.01,75.59 24.45,75.03 24.45,73.13 24.58,73 24.58,72.27 24.45,72.14 24.45,67.57 24.35,67.47 24.35,66.75 v1(26.26,64.85)
  L6 w0.254: v1(30.32,68.63) 30.58,68.38 31.68,68.38 32.54,69.24 34.95,69.24 v1(35.68,68.51)
  BOTTOM w0.254: v1(26.26,64.85) 26.74,64.85 29.74,67.85 v2(29.74,67.89) 29.74,68.05 v1(30.32,68.63)
+SDC_IN_SW_R1: length 17.1
  TOP w0.254: R4333.1 40.18,79.89 39.87,79.58 39.87,79.35 39.37,78.85 v2(39.37,78.27) 39.21,78.11 38.72,78.11 38.34,77.73 v1(38.32,77.73)
  L6 w0.254: v1(38.32,77.73) 36.82,77.73 36.24,78.31 36.24,79.81 35.81,80.24 35.34,80.24 33.77,78.67 29.84,78.67 v1(29.59,78.41)
  BOTTOM w0.254: v1(29.59,78.41) 29.69,78.51 29.69,78.92 29.71,78.95 29.71,79.01 30.42,79.72 Q4349.3
+V_VREF_PATH1: length 2
  TOP w0.508: C1222.2 71.98,19.13 v2(72.16,18.95) 72.16,18.87 71.65,18.37 R1209.1
+V_VREF_PATH2: length 1.8
  TOP w0.305: v2(147.87,17.73) 148.41,18.27 R1309.1
  TOP w0.508: R1309.1 C1323.2
AC_DIS: length 53.4
  TOP w0.102: v1(33.47,48.49) 33.09,48.11 U2401.69
  L3 w0.102: v1(29.25,80.55) 29.25,80.04 30.12,79.17 30.12,78.56 30.22,78.46 30.22,78.16 v1(29.92,77.85) ; v1(34.33,76.79) 33.45,75.9 33.45,75.1 32.38,74.03 32.38,73.82 31.85,73.29 31.85,69.72 31.44,69.32 31.26,69.32 30.88,68.94 30.88,68.07 30.01,67.21 30.01,66.83 30.47,66.37 31.5,66.37 33.5,64.38 33.5,62.39 32.63,61.52 32.63,59.77 34.64,57.76 34.64,56.09 34.42,55.87 34.42,50.08 33.55,49.2 33.55,48.57 v1(33.47,48.49)
  BOTTOM w0.102: 27.22,79.33 27.63,79.73 27.63,80.37 Q4304.B 29.08,80.37 v1(29.25,80.55) ; v1(34.33,76.79) 34.08,76.53 33.62,76.53 33.6,76.56 30.65,76.56 30.09,76 29.48,76 29.18,75.69 28.59,75.69 28.32,75.97 28.32,77.22 28.59,77.5 v2(29.15,77.5) 29.48,77.83 29.89,77.83 v1(29.92,77.85) 30.12,78.06 30.12,78.72 30.47,79.07 Q4349.2
AC_IN#_G: length 3.8
  BOTTOM w0.254: R4376.2 36.26,82.81 R4377.1 35.27,82.98 34.93,83.33 U4302.5 34.93,84.32 v2(35.38,84.76)
AC_PRESENT: length 39.9
  TOP w0.102: RN1704.3 120.19,50.65 v1(120.01,50.83) 120.03,50.85 120.03,51.13 120.21,51.31 120.21,51.36 120.52,51.67 120.52,54.17 119.72,54.97 119.72,56.61 119.83,56.72 119.83,58.16 119.64,58.35 v1(119.6,58.35) ; Q1702.3 118.55,42.8 118.98,42.37 118.98,40.9 120.07,39.8 EC1707.1 ; v1(118.66,47.25) 118.41,46.99 v2(118.41,46.41) 119.05,45.76 119.19,45.76 119.61,45.34 120.75,45.34 120.95,45.14 121.43,45.14 121.76,44.81 121.76,40.29 EC1707.1 ; EC1707.1 121.28,39.47 120.9,39.1 117.29,39.1 116.63,39.75 116.63,40.13
  BOTTOM w0.076: CPU1.BU35 119.64,62.84 119.76,62.5 119.8,62.4 119.8,62.18 119.76,62.08 119.76,61.84 119.8,61.73 119.8,61.68 119.83,61.65 119.92,61.4 119.92,60.44 119.63,60.15 119.63,58.37 v1(119.6,58.35)
  BOTTOM w0.102: v1(118.66,47.25) 118.99,47.25 119.35,47.6 119.35,50.17 v1(120.01,50.83)
ACOK#: length 7.4
  TOP w0.102: PR4427.2 v1(169.49,3.89)
  BOTTOM w0.102: PQ4415.2 165.35,7.34 165.25,7.24 165.25,6.76 165.31,6.69 PQ4415.3 166.94,6.69 v2(167.05,6.58) 169.49,4.14 v1(169.49,3.89)
ACOK_IN: length 156.2
  TOP w0.102: R2469.2 48.61,33.89 v1(48.55,33.83)
  L4 w0.102: v1(160.5,4.17) 160.32,3.99 159.71,3.99 159.46,4.24 158.44,4.24 157.7,3.5 129.78,3.5 129.68,3.61 125.74,3.61 120.52,8.82 120.52,10.8 118.79,12.52 117.87,12.52 117.01,11.66 117.01,10.14 116.55,9.68 116.55,9.65 116.33,9.43 115.92,9.43 115.69,9.65 110.89,9.65 110.26,9.02 109.82,9.02 109.8,8.99 96.95,8.99 96.59,8.64 95.04,8.64 91,4.6 62.71,4.6 60.63,6.69 60.63,9.3 59.99,9.94 58.58,9.94 57.7,10.82 57.5,10.82 57.47,10.85 55.62,10.85 55.52,10.95 55.42,10.95 52.95,13.41 52.95,14.38 49.27,18.06 49.27,24.49 48.55,25.2 v1(48.55,33.83)
  BOTTOM w0.102: PQ4415.5 v2(163.14,7.34) 163.14,4.23 162.77,3.86 160.8,3.86 v1(160.5,4.17) 160.34,4.32 160.34,6.43 PG4408.2
ACOK_IN_M: length 330.3
  TOP w0.102: D1701.K 115.31,40.87 v1(114.45,41.73) ; v1(162.61,41.28) 162.67,41.33 v2(163.29,41.33)
  L4 w0.102: v1(27.48,43.51) 27.73,43.77 33.5,43.77 33.6,43.87 34,43.87 34.11,43.77 34.24,43.77 35.64,45.16 37.59,45.16 38.09,45.67 39.74,45.67 40.43,44.99 41.65,44.99 42.18,44.45 43.73,44.45 43.91,44.27 44.39,44.27 45.38,43.28 48.67,43.28 51.14,40.81 51.14,36.48 52.57,35.05 52.57,31.32 53.36,30.53 53.36,27.46 53.61,27.21 53.61,21.65 57.84,17.43 59.48,17.43 60.85,16.06 62.25,16.06 62.5,15.8 66.16,15.8 67.79,14.18 73.43,14.18 73.45,14.2 86.43,14.2 88.51,16.28 93.21,16.28 93.54,15.95 100.02,15.95 101.7,17.63 107.84,17.63 109.9,19.69 169.93,19.69 171.52,18.1 171.52,17.12 173.98,14.66 173.98,13.01 v1(174.95,12.04) 174.95,9.3 172.51,6.86 172.15,6.86 171.29,7.72 v1(170.63,7.72) ; v1(162.61,41.28) 162.66,41.28 162.97,40.97 162.97,40.56 167.12,36.4 168.19,36.4 168.62,35.97 168.62,35.6 169.78,34.45 170.17,34.45 170.28,34.55 170.91,34.55 171.15,34.79 171.84,34.79 173.15,33.48 173.65,33.48 173.7,33.43 174.11,33.43 174.16,33.48 174.24,33.48 174.26,33.51 174.67,33.51 174.9,33.28 174.9,33.27 v1(175.11,33.06)
  L6 w0.102: v1(29.15,74.75) 28.62,74.22 28.62,69.42 27.43,68.23 27.43,66.67 30.02,64.09 30.02,63.48 28.16,61.62 27.93,61.62 27.4,61.09 27.4,58.32 26.79,57.71 26.79,54.82 24.84,52.87 24.84,49.05 24.81,49.02 24.81,48.64 24.84,48.62 24.84,48.44 27.48,45.8 v1(27.48,43.51)
  BOTTOM w0.102: v1(170.63,7.72) 170.33,7.72 169.84,8.21 168.57,8.21 168.52,8.26 168.4,8.26 168.02,8.64 167.48,8.64 167.45,8.6 164.52,8.6 164.27,8.35 PQ4415.6 ; v1(114.45,41.73) 117.72,38.46 147.38,38.46 148.7,39.78 161.12,39.78 v1(162.61,41.28) ; v1(174.95,12.04) 174.95,12.36 176.02,13.43 176.02,14.01 175.52,14.51 175.1,14.51 174.88,14.73 174.88,15.87 174.98,15.97 175.29,15.97 175.88,16.56 177.28,16.56 178.89,18.16 178.89,20.3 180.18,21.59 180.18,27.31 179.37,28.12 179.37,29.57 179.01,29.92 178,29.92 176.85,31.07 176.85,32.21 176.01,33.06 v1(175.11,33.06) ; D4308.K 29.25,74.85 v1(29.15,74.75)
AD+: length 209.3
  TOP w0.254: PR4473.1 168.52,17.5 v1(169.01,17.99) ; v1(140.33,16.23) 140.74,16.64 140.74,17.6 PD4411.A 139.06,19.28 133.88,19.28 133.22,18.62 108.07,18.62 v2(106.68,17.23) 105.68,16.23 104.41,16.23 v1(104.26,16.39)
  L3 w0.254: v1(47.09,55.93) 48.33,54.69 49.92,54.69 51.71,52.9 51.71,51.7 52.98,50.43 52.98,48.72 53.31,48.39 54.53,48.39 58.56,44.36 58.56,39.63 59.05,39.14 59.05,37.07 66.01,30.11 66.01,18.57 67.55,17.02 73.86,17.02 74.01,16.87 74.06,16.87 75.24,15.69 77.58,15.69 79.01,14.25 86.68,14.25 88.97,16.54 93.09,16.54 94.02,15.6 103.47,15.6 103.5,15.62 103.75,15.62 104.13,16 104.13,16.26 v1(104.26,16.39)
  L4 w0.254: v1(49.7,81.08) 49.7,81.03 49.96,80.77 49.96,75.72 44.98,70.74 44.98,63.99 44.11,63.12 44.11,60.07 45.61,58.58 45.61,58.42 47.09,56.95 v1(47.09,55.93) ; v1(169.01,17.99) 168.52,18.47 159.28,18.47 159,18.19 159,17.66 158.52,17.17 157.14,17.17 156.59,16.61 155.14,16.61 154.73,16.21 154.12,16.21 153.74,15.83 152.83,15.83 152.34,16.31 140.69,16.31 140.62,16.23 v1(140.33,16.23)
  L6 w0.254: v1(49.7,81.08) 45.4,81.08 44.05,79.73 42.03,79.73 41.17,80.6 40.6,80.6 39.41,81.78 39.41,82.25 v1(37.88,83.78)
  BOTTOM w0.254: PD4408.1 106.42,18.04 104.16,18.04 PD4401.1 104.16,16.39 v1(104.26,16.39)
AD_IA: length 200.1
  TOP w0.102: R2423.2 26.08,27 v1(26.46,27.38) 26.87,27.79 v2(26.89,27.79) ; v1(154.65,10.59) 154.58,10.67 154.58,11.71 153.79,12.5 v1(153.79,15.24)
  L6 w0.102: v1(153.79,15.24) 153.77,15.22 153.77,14.79 153.08,14.1 140.1,14.1 139.74,13.74 128.24,13.74 126.84,12.35 122.75,12.35 121.28,10.87 117.39,10.87 116.38,11.89 110.43,11.89 110.05,11.51 109.65,11.51 109.14,12.02 99.1,12.02 96.97,9.88 96.97,6.12 96.59,5.74 94.81,5.74 94.18,6.38 89.2,6.38 86.61,8.97 79.6,8.97 78,10.57 62.07,10.57 61.97,10.67 61.97,11.86 61.31,12.52 60.04,12.52 59.13,13.44 58.95,13.44 58.85,13.54 56.38,13.54 55.92,14 55.92,14.56 54.93,15.55 52.62,15.55 50.13,18.04 44.27,18.04 43.76,17.53 39.59,17.53 39.39,17.73 38.96,17.73 37.92,18.77 31.36,18.77 30.3,19.84 30.3,20.58 27.81,23.07 27.81,23.62 27.22,24.21 27.22,24.99 26.46,25.75 v1(26.46,27.38) 27.4,28.32 27.4,29.62 26.79,30.23 26.79,33.63 27.63,34.47 27.63,36.6 25.78,38.46 25.78,39.3 26.84,40.36 27.71,40.36 31.08,43.74 31.08,43.79 33.12,45.82 33.63,45.82 37.01,49.2 37.26,49.2 v1(40.41,52.35)
  BOTTOM w0.102: PR4412.1 154.81,10.75 v1(154.65,10.59) ; R2403.1 30.09,52.83 30.27,53.01 35.48,53.01 35.87,53.41 39.07,53.41 39.57,52.91 39.95,52.91 40.41,52.45 v1(40.41,52.35)
AD_OFF_L: length 5.9
  BOTTOM w0.254: v2(27.27,87.33) 27.27,87.07 26.93,86.73 Q4305.1 26.93,84.52 26.38,83.98 26.38,83.29 27.02,82.65 Q4304.C
AD_OFF_R: length 5.4
  BOTTOM w0.254: R4308.1 29.03,85.47 28.01,84.46 Q4305.3 27.58,86.64 28,87.07 v1(28,87.33)
  vias: v2(30.77,88.06)
ALERT#: length 3.7
  TOP w0.102: R2603.2 164.56,105.97 v2(164.56,106.81) 164.03,106.81 163.75,106.53 v1(163.75,105.88)
  BOTTOM w0.102: THM261.6 v1(163.75,105.88)
ALWON: length 228.6
  TOP w0.102: v1(207.03,54.23) 207.03,54.41 v2(206.7,54.74) 206.6,54.74 206.29,54.43 R4009.2 ; v1(41.12,37.04) 41.5,37.42 42.71,37.42 42.97,37.16 42.97,36.67 42.78,36.48 U2401.121
  L6 w0.102: v1(217.57,29.59) 217.42,29.75 206.28,29.75 205.66,30.37 202.37,30.37 201.75,29.75 194.68,29.75 193.3,31.12 191.36,31.12 190.42,32.05 185.19,32.05 183.81,33.43 179.75,33.43 178.84,34.34 177.49,34.34 176.25,35.58 172.6,35.58 v1(171.38,34.36)
  BOTTOM w0.102: v1(171.38,34.36) 169.84,32.81 154.55,32.81 153.8,32.06 70.46,32.06 67.23,35.28 58.52,35.28 57.91,35.89 51.69,35.89 50.57,37.01 49.24,37.01 49.07,37.19 45.34,37.19 44.71,37.82 41.9,37.82 v1(41.12,37.04) ; v1(217.57,29.59) 217.57,29.7 220.8,32.92 220.8,52.06 218.18,54.68 214.31,54.68 213.2,55.78 208.58,55.78 v1(207.03,54.23)
AMBER_LED_BAT: length 11
  TOP w0.254: R6407.1 EC6402.1 11.68,93.39 v1(11.68,92.51)
  BOTTOM w0.254: v1(11.68,92.51) 12.5,93.32 13.66,93.32 v2(13.76,93.42) 13.89,93.42 14.45,92.86 14.45,90.91 14.98,90.38 15.77,90.38 16.2,89.94 Q6403.C
AON_CT_2: length 5.3
  BOTTOM w0.203: 175.86,100.56 175.03,100.56 174.89,100.43 U8601.10
  BOTTOM w0.254: 175.86,100.56 176.14,100.56 176.22,100.49 v2(177.34,100.49) 177.67,100.82 178.58,100.82 C8605.1
AUD_AGND: length 35.5
  TOP w0.203: v1(21.94,19.12) 21.95,19.1 22.27,19.1 22.57,18.8 U2701.19 ; U2701.31 21.46,13.52 21.39,13.45 v1(21.33,13.45)
  TOP w0.508: v1(15.92,20.27) 16.15,20.27 16.66,19.76 C2702.1 ; v1(12.64,10.65) 12.77,10.65 13.51,9.91 R2704.1 14.29,10.42 C2902.2 ; C2710.2 C2711.2 17.8,12.86 17.57,13.09 v1(17.57,13.52) ; v1(12.24,13.39) 12.8,12.83 EC2704.1 13.61,12.73 R2914.2 ; v1(12.64,8.41) 14.07,8.41 R2705.1 ; C2706.2 19.22,21.34 v1(19.02,21.54) 18.51,22.05 C2707.2
  BOTTOM w0.305: R2706.1 21.7,13.08 v1(21.33,13.45)
  BOTTOM w0.406: v1(14.68,15.78) 14.68,15.55 14.7,15.52 14.7,15.34 15.2,14.84 16.17,14.84 EC2703.1
  BOTTOM w0.508: v1(17.57,13.52) 16.94,12.88 EC2906.2 ; C2707.2 18,22.35 EC8958.1 19.02,22.61 C2715.2 ; C2707.2 17.22,22.05 17.22,22.1 EC8954.1 ; C2707.2 18.51,22.05 v1(19.02,21.54) R2702.2 ; EC2908.2 EC2907.2 13.33,8.41 v1(12.64,8.41) ; EC8959.1 EC2701.1 EC2702.1 EC8960.1 22.6,18.6 22.09,19.1 21.95,19.1 v1(21.94,19.12) 21.63,18.81 v2(21.63,18.16) EC2705.1 ; v1(13.15,5.02) 13.37,5.24 EC2905.2 14.4,5.39 R2920.2 ; v1(12.64,10.65) 12.77,10.77 R2919.2
AUD_HP1_JACK_L: length 13.8
  TOP w0.203: v1(19.44,17.06) 19.48,17.02 20.01,17.02 20.83,16.2 U2701.25
  TOP w0.254: v1(19.44,17.06) 19.3,17.2 18.26,17.2 R2913.2 R2908.1 ; R2922.2 v1(17.6,23.02)
  L6 w0.254: v1(17.6,23.02) 18.71,23.02 19.76,21.97 19.76,20.37 19.45,20.07 19.45,17.07 v1(19.44,17.06)
  BOTTOM w0.254: v2(20.14,17.2) 19.58,17.2 v1(19.44,17.06)
AUD_HP1_JACK_L1: length 15.3
  TOP w0.254: v1(15.77,17.58) 16.38,18.19 R2908.2
  L4 w0.254: v1(15.77,17.58) 15.49,17.3 15.49,12.04 v1(12.67,9.22)
  BOTTOM w0.254: v1(12.67,9.22) EC2907.1 13.43,9.81 R2919.1 13.56,10.14 13.79,10.14 v2(14.24,10.59) 14.57,10.26 R2907.1
AUD_HP1_JACK_R: length 14.4
  TOP w0.203: U2701.26 20.74,15.8 20.01,16.54 v1(19.81,16.54)
  TOP w0.254: R2910.1 R2912.2 18,16.16 v2(18.18,16.33) 18.38,16.54 v1(19.81,16.54) ; v1(20.24,23.77) 20.09,23.62 R2921.2
  L6 w0.254: v1(20.24,23.77) 20.26,23.75 20.26,20.14 19.96,19.84 19.96,16.69 v1(19.81,16.54)
AUD_HP1_JACK_R1: length 15.4
  TOP w0.254: R2910.2 15.06,16.94 v1(14.93,17.07) ; R2909.1 v1(12.59,7.11) 12.44,7.27 v2(12.44,7.7)
  L3 w0.254: v1(12.59,7.11) 14.65,9.17 14.65,12.02 15.19,12.55 15.19,16.81 v1(14.93,17.07)
  BOTTOM w0.254: R2920.1 13.53,6.68 EC2908.1 12.92,6.78 v1(12.59,7.11)
AUD_HPJD_N: length 8.6
  TOP w0.203: v1(25.85,19.21) 25.78,19.21 25.37,18.8 U2701.12
  BOTTOM w0.254: R2711.2 22.63,20.73 R2710.2 23.36,21.31 25.19,21.31 26.23,20.27 26.59,20.27 26.87,19.99 26.87,19.54 26.54,19.21 v1(25.85,19.21) 25.85,18.62 25.8,18.57 v2(25.8,18.37)
AUD_PC_BEEP: length 2.4
  TOP w0.203: U2701.11 26.11,18.49 26.38,18.77
  TOP w0.254: 26.38,18.77 26.49,18.87 C2735.2 25.93,19.87 v2(25.6,19.87)
AUD_PC_BEEP_C: length 6.6
  TOP w0.254: v1(23.74,20.81) 24.15,21.21 C2739.1 25.65,21.21 R2735.1 25.7,20.75 26.23,20.22 C2735.1
  BOTTOM w0.254: v1(23.74,20.81) 24.77,20.81 D2703.3 25.81,19.76 v2(26.36,19.76)
AUD_PORTA_L_HPMIC1: length 10.9
  TOP w0.254: ED2911.1 14.52,6.73 v1(14.55,6.71) 14.55,6.3 v2(14.73,6.12)
  L3 w0.254: v1(14.55,6.71) 14.55,5.82 13.66,4.93 13.66,4.81 12.49,3.64 12.49,2.88 12.12,2.51 9.6,2.51 AUD1.1
  BOTTOM w0.254: R2907.2 14.57,6.73 v1(14.55,6.71)
AUD_PORTA_R_HPMIC1: length 14.1
  TOP w0.254: AUD1.2 5.71,1.4 10.48,1.4 12.31,3.23 12.31,5.67 v2(12.44,5.79) R2909.2 13.89,5.79 ED2910.1
AUD_RING: length 4.5
  TOP w0.203: U2701.13 24.97,19.23 v3(25.1,19.35)
  BOTTOM w0.457: v3(17.06,20.63) 17.06,20.58 17,20.52 RN2901.4
  BOTTOM w0.508: EC2905.1 v2(14.24,3.53) 15.49,3.53 v3(15.89,3.94)
AUD_SENSE: length 18.2
  TOP w0.254: C2902.1 R2923.2 16.73,13.43 16.94,13.64 16.94,13.82 v1(17.01,13.9)
  L6 w0.254: v1(17.01,13.9) 17.01,14.51 17.52,15.01 18.76,15.01 19.55,15.8 20.54,15.8 21.08,16.33 21.08,22.05 21.94,22.91 22.45,22.91 v1(22.47,22.94)
  BOTTOM w0.254: v1(22.47,22.94) 22.47,22.86 22.42,22.81 22.42,21.67 R2711.1 22.14,21.59 21.61,21.06 v2(21.61,20.73)
AUD_SLEEVE: length 1.7
  TOP w0.203: v3(24.38,20.15) 24.5,20.03 24.5,19.12 24.57,19.05 U2701.14
  vias: v2(15.56,13.59) v3(15.74,19.41) v3(16.28,13.9)
AUD_SPK_L+: length 13
  TOP w0.203: v3(23.21,11.38) 23.21,11.47 23.77,12.03 23.77,12.17 23.79,12.19 23.79,12.67 23.77,12.69 U2701.35
  L6 w1.016: v3(22.55,3.74) 22.55,4.5 20.42,6.63 20.42,8.44 22.5,10.52 22.5,10.75 23.06,11.31 23.13,11.31 v3(23.21,11.38)
  BOTTOM w0.305: v3(23.21,11.38) v2(23.81,11.98)
AUD_SPK_L+_C: length 10.9
  TOP w0.254: v3(16.76,8.13) 17.09,8.46 AFTP2902.1
  TOP w0.762: v3(22.37,8.56) 22.4,8.54 R2902.2
  L3 w1.016: v3(22.37,8.56) 17.19,8.56 v3(16.76,8.13)
  BOTTOM w0.61: SPK1.4 17.21,8.58 v3(16.76,8.13)
AUD_SPK_L-: length 15.1
  TOP w0.203: v3(24.48,11.64) 24.17,11.94 U2701.36
  L6 w1.016: v3(23.84,3.74) 23.84,4.73 26,6.89 26.97,6.89 27.83,7.75 27.83,8.57 26.82,9.58 25.5,9.58 24.48,10.6 v3(24.48,11.64)
  BOTTOM w0.305: v3(24.48,11.64) 25.01,11.1 v2(25.09,11.1)
AUD_SPK_L-_C: length 13
  TOP w0.305: AFTP2901.1 18.21,8.97 v3(18.21,7.29)
  TOP w0.762: R2901.2 v3(24,8.23)
  L3 w1.016: v3(24,8.23) 23.97,8.23 23.03,7.29 v3(18.21,7.29)
  BOTTOM w0.61: v3(18.21,7.29) SPK1.3
AUD_SPK_R+: length 15
  TOP w0.203: U2701.38 24.97,13.1 25.79,12.28 v2(26.46,12.28) 27.04,12.28 v3(27.15,12.17)
  L6 w1.016: v3(27.05,3.81) 27.49,3.81 30.5,6.82 30.5,9.8 28.13,12.17 v3(27.15,12.17)
AUD_SPK_R+_C: length 20.1
  TOP w0.305: v3(20.16,4.73) 20.16,7.67 AFTP2904.1
  TOP w0.762: R2904.2 26.92,8.08 v3(26.84,8.16)
  L3 w1.016: v3(26.84,8.16) 26.84,6.94 24.63,4.73 v3(20.16,4.73)
  BOTTOM w0.61: v3(20.16,4.73) 20.21,4.78 SPK1.1
AUD_SPK_R-: length 13.7
  TOP w0.203: U2701.37 24.57,12.84 v2(25.18,12.24) v3(25.78,11.64)
  L6 w1.016: v3(25.78,11.64) 26.54,10.87 27.32,10.87 29.1,9.09 29.1,7.22 27.37,5.49 26.93,5.49 25.72,4.29 v3(25.72,3.79)
AUD_SPK_R-_C: length 18.4
  TOP w0.305: AFTP2903.1 21.08,10.49 19.21,8.63 v3(19.21,6.02)
  TOP w0.762: R2903.2 v3(25.39,8.16)
  L3 w1.016: v3(19.21,6.02) 19.24,6 24.11,6 25.39,7.29 v3(25.39,8.16)
  BOTTOM w0.61: SPK1.2 v3(19.21,6.02)
AUD_VREF: length 4.4
  TOP w0.203: U2701.22 21.17,17.4 20.14,18.44
  TOP w0.254: C2702.2 19.12,19.46 v2(19.45,19.13) 20.14,18.44
AUX_EN_WOWL: length 163.4
  TOP w0.102: v1(133.27,43.51) 133.27,42.1 133.12,41.95 133.12,41.04 133.18,40.98 133.18,39.79 125.57,32.18 63.72,32.18 60.37,35.54 v2(60.37,36.88) 60.34,36.91 v1(60.34,37.69) ; v1(30.36,56.97) 30.4,56.94 R2427.1 R6136.2
  L3 w0.102: v1(48.15,57.05) 49.08,56.12 52.34,56.12 53.92,54.54 54.17,54.54 56.56,52.15 56.56,51.86 58.52,49.9 58.52,48.97 58.69,48.8 58.69,48.71 59.47,47.93 59.47,41.39 60.04,40.82 60.07,40.82 60.32,40.56 60.32,40.21 60.03,39.92 60.03,38 v1(60.34,37.69)
  L6 w0.102: v1(30.36,56.97) 30.36,58.29 31.25,59.18 33.22,59.18 33.6,58.8 33.6,58.68 35.89,56.39 41.98,56.39 42.39,56.8 42.39,57.33 43.19,58.13 44.48,58.13 45.49,57.13 47.59,57.13 47.67,57.05 v1(48.15,57.05) ; v1(118.99,65.69) 119.49,65.19 119.49,63.68 122.59,60.58 122.59,57.35 126.61,53.33 126.61,52.97 127.12,52.45 127.12,51.21 127.6,50.73 127.6,47.68 130.99,44.3 132.48,44.3 v1(133.27,43.51)
  BOTTOM w0.102: v1(118.99,65.69) 118.75,65.93 CPU1.BT30
AUX_ON: length 3.4
  TOP w0.102: R2491.2 49.1,36.6 48.79,36.91 v2(48.79,37.04) 48.67,37.04 47.59,38.11 U2401.3
BAT1_LED#: length 25.4
  TOP w0.089: v1(36.32,36.96) 36.47,36.96 36.78,36.65 U2401.106 ; RN2405.4 52.27,33.32 52.67,32.92 v1(53.05,32.92) 53.6,32.92 53.75,33.07 v2(53.77,33.07) 54.2,33.51 54.2,33.74 54.72,34.25 Q2412.4
  BOTTOM w0.089: v1(36.32,36.96) 36.47,36.96 38.42,35 40.53,35 41.14,34.4 41.21,34.4 41.27,34.34 41.62,34.34 41.68,34.4 41.81,34.4 42.77,35.36 43.2,35.36 43.38,35.54 43.4,35.54 43.48,35.61 47.49,35.61 47.54,35.66 48.56,35.66 48.64,35.59 49.24,35.59 51.91,32.92 v1(53.05,32.92)
BAT2_LED#: length 11.1
  TOP w0.089: U2401.1 47.9,37.31 49.24,35.97 v2(51.35,35.97) RN2405.1 52.69,35.97 52.78,36.06 52.78,36.55 53.34,37.11 55.73,37.11 56.02,36.82 Q2412.1
BAT_AMBER: length 14.8
  TOP w0.254: v1(9.44,93.09) 9.52,93.02 R6407.2 ; v1(1.42,98.5) 1.42,99.01 2.4,100 LED1.1
  L6 w0.254: v1(1.42,98.5) 2,97.92 4.9,97.92 9.44,93.38 v1(9.44,93.09)
  BOTTOM w0.254: v2(10.71,92.61) 9.93,92.61 v1(9.44,93.09)
BAT_WHITE: length 13.2
  TOP w0.254: R6406.2 10.99,94.39 v2(10.79,94.19) 10.51,93.91 v1(10.51,93.25) ; LED1.2 2.46,98.5 v1(2.46,98.5)
  L6 w0.254: v1(10.51,93.25) 10.08,93.25 4.82,98.5 v1(2.46,98.5)
