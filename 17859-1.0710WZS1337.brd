# Allegro board 17859-1.0710WZS1337.brd (continued)
## Library data of the parts (continued)
D2502 = SOD323-2513AKH36: tolerance: 83.R2004.J8F
D2503 D2901 D6401 D7601 = SOT-23-9H44: tolerance: 75.BAT54.07D
D2601 = SOD323AKH38: tolerance: 83.R5003.H8H
D4301 = D4724AKH44: tolerance: 083.00624.00AM
D4302 D4304-D4306 = SOT23-2D4-312H44: tolerance: 75.00099.O7D
D4303 = SOT23-2D4-312H60: tolerance: 83.03024.0A1
D4307 = SOD123AK-2H43: tolerance: 83.SMF18.AAH
D4308 PD4409 = SOD323AKH38: tolerance: 83.R2004.G8F
D5701 = SOT23-2D4-312H44: tolerance: 83.00056.Y11
D7001 = SOT23-2D4-312H48: tolerance: 75.00054.R7D
D7203 = D4724AKH44: tolerance: 83.3R010.C8M
D8602 = D1608-035030AKH28: tolerance: 83.1R003.N8F
DBG1 = 87212-1400N: tolerance: 20.F0765.014
DBG3 = 50696-00601-001: tolerance: 20.K0691.006
DCIN1 = 3703K-Q08N-03R-U: tolerance: 20.F2120.008
DM1 DM2 = 40-42271-26001RHF-WD-U: tolerance: 062.10011.M003
EC1201 EC1301 FC1102 FC1103 = C402H22: tolerance: 78.22510.5FLDL
EC1803 FC1801 = C402H22: tolerance: 078.4R7B4.01FD
EC2709-EC2711 EC5504 PC8632 = C402H22: tolerance: 78.22034.1FL
EC4306 EC4309 EC4310 = C402H22: tolerance: 78.10034.1FL
EC4308 = C603H36: tolerance: 78.10424.2BL
EC5501 EC5502 = C402H22: tolerance: 78.6R074.1FLDL
EC5505 ED3501 ED3504 ED5701-ED5703 ED6001 ED7301 ED7302 = DFN10G2510-1H20: tolerance: 075.PUSB3.0073
EC6501-EC6506 = C402H22: tolerance: 78.33034.1FL
ED301 ED1701-ED1704 ED1801 = SOT23-2D4-312H46: tolerance: 75.05125.07D
ED502 ED4001 = SOT23-2D4-312H44: tolerance: 075.52215.007D
ED1217 ED1302 ED2907-ED2912 ED6401 ED7307 = SOD882-10D6-1H20: tolerance: 83.05123.AA0
ED3502 = SOT-6H58: tolerance: 075.09904.0A7C
ED6301 = SLP2510P8-1H22: tolerance: 075.00550.0071
ED7303-ED7306 = SOT883-1D0-321H20: tolerance: 83.05315.0A0
EL3501 = LD85D65-4P-1H20: tolerance: 068.09002.2001; signal model: wistron_EL3501
EL3506 = LD85D65-4P-1H20: tolerance: 068.09002.2001; signal model: wistron_EL3506
EL4301-EL4304 ER7201 ER7202 R2511 R3509 R3510 = R805H24: tolerance: 63.R0031.16L
EL5501 = LD85D65-4P-1H20: tolerance: 068.09002.2001
EL7301 = LD85D65-4P-1H20: tolerance: 068.09002.2001; signal model: wistron_EL7301
EL7302 = LD85D65-4P-1H20: tolerance: 068.09002.2001; signal model: wistron_EL7302
ER5701-ER5704 = R402H16: tolerance: 63.15134.1DL
F5503 = POLYSW-4633-UH43: tolerance: 69.50007.A31
F5504 F5701 F6502 = POLYSW-2114H30: tolerance: 69.48001.081
FAN1 SPK1 = 50224-0040N-001: tolerance: 20.F1639.004
G1801 G6401 G6402 = CON2O-U: tolerance: ZZ.CON2O.XXX
GPU1 = BGA595M23H83: tolerance: 071.0N16S.0A0U
H1-H7 = HOLE276R150: tolerance: ZZ.00PAD.H91
H8 = HOLE335R115: tolerance: ZZ.00PAD.D01
H9 = HOLE335R178: tolerance: ZZ.00PAD.7F1
H10 = HOLE237R170: tolerance: ZZ.00PAD.00K
H11-H15 = HOLE256R126: tolerance: ZZ.00PAD.Z61
H17 = HOLE237R103: tolerance: ZZ.00PAD.EJ1
HDD1 = FFSKL05007N12B: tolerance: 020.K0190.0012
HDMI1 = SKT-HDMI23-188146-1: tolerance: 022.10025.0411
HS1 = STF237R113H86: tolerance: 434.07K0E.0001
IOBD1 LCD1 = 300E40-1010RA-G3: tolerance: 020.F0847.0040
KB1 = 196528-30041-3: tolerance: 020.K0236.0030
KB_BL1 = 50698-00401-W01-U: tolerance: 020.K0298.0004
L7602 L7801 L7901 = L1608-UH38: tolerance: 68.00230.041
L7902 = L603H38: tolerance: 68.00909.261
L8001 = L603H38: tolerance: 68.00335.051
LED1 = LED3020-3P-19H44: tolerance: 083.1212A.0070
PC4416 PC4417 PC4419 PC4424 PC4426 PC4439 PC4440 = C603H36: tolerance: 078.10524.05BD
PC4423 PC4606 PC4707 PC4808 PC4811 PC5005 = C603H36: tolerance: 78.22422.2BLDL
PC4429 PC5304 = C402H22: tolerance: 78.47224.2FLDL
PC4431 PC4628 = C402H22: tolerance: 78.33322.2FL
PC4519 PC5211 PC5216 = C805H56: tolerance: 78.10622.51L
PC4524 PC8617 = C603H36: tolerance: 78.22523.5BL
PC4604 PC4614 PC4629 PC4638 PC4641 = C402H22: tolerance: 78.33124.2FLDL
PC4609 PC4613 PC4615 PC4620 PC4622 PC4635 PC4637 PC4644 PC5213 PC8521 PC8609 = C402H22: tolerance: 78.10322.2FLDL
PC4621 = C402H22: tolerance: 78.68124.2FLDL
PC5104 PC5105 PC5107 PC5109 = C603H40: tolerance: 78.22610.L4L
PC5112 = C603H36: tolerance: 78.47520.L0L
PC5113 PC5114 PC5116 = C402H22: tolerance: 78.10422.L1L
PC5126 PC5301 = C402H22: tolerance: 78.68034.1FLDL
PC5127 PC5302 = C805H54: tolerance: 78.22610.51LDL
PC8508 PC8520 = C402H22: tolerance: 78.33134.1FLDL
PC8519 = C402H22: tolerance: 78.27224.2FLDL
PC8523-PC8525 = C402H22: tolerance: 78.47034.1FLDL
PC8602 = C402H22: tolerance: 78.33124.2FL
PD5101 = SOD323AKH40: tolerance: 083.04024.0AA1
PDA1 PDA2 = GNDPADSR351-131-S-NP: tolerance: ZZ.00PAD.N01
PG4401 PG4402 PG4405 PG4406 PG4408 PG4501-PG4524 PG4527-PG4534 PG4707-PG4718 PG4808 PG4809 PG4813 PG4815-PG4825 PG5001-PG5003 PG5011 PG5101-PG5103 PG5106-PG5111 PG5113 PG5115 PG5116 PG5120-PG5123 PG5201 PG5204 PG5206-PG5216 PG5301-PG5303 PG8605-PG8621 = GAP-CLOSE-PWR-3: tolerance: ZZ.CLOSE.001
PG5223 = GAP-CLOSE-PWR: tolerance: ZZ.CLOSE.011
PL4401 = L11102530H158: tolerance: 68.4R71A.20Q
PL4501 = L4947-1015H119: tolerance: 68.1R550.20C
PL4502 = L7066-1830-UH119: tolerance: 68.1R510.10K
PL4701 PL4801 PL4802 = L7366-1930H158: tolerance: 68.R1510.20A
PL5001 = L7066-1830-UH119: tolerance: 68.R4710.10M
PL5101 PL5201 = L7066-1830-UH119: tolerance: 68.1R01A.20B
PL8508 PL8509 = L7366-1830H119: tolerance: 068.R1510.1171
PL8602 = L2520-D620H48: tolerance: 068.1R010.1281
PL8603 = L4947-1115H119: tolerance: 68.1R010.20R
PQ4402 PQ4417 Q501 Q1802 Q2408 Q2414 Q2501 Q2510 Q2602 Q2705 Q5701 Q6102 Q6505 Q7601 Q7906 Q8101 Q8504 Q8602-Q8605 = SOT23DGS2D4H44: tolerance: 84.2N702.J31
PQ4405 PQ4415 PQ4416 PQ4418 Q401 Q1701 Q1702 Q1801 Q2001 Q2412 Q2417 Q2601 Q4001 Q4349 Q5702 Q6503 Q7001 Q7404 Q7405 Q7901 Q8608 = SOT-363H44: tolerance: 75.27002.F7C
PQ4408 = SOT23CBE2D4H44: tolerance: 84.03906.R11
PR4401 = R1206H38: tolerance: 64.R0105.81L
PR4402 PR4804 PR4810 = R603H22: tolerance: 64.2R205.55L
PR4403 = R805H24: tolerance: 63.2R231.16L
PR4404 R2403 R5710 = R402H16: tolerance: 64.15035.6DL
PR4405 = R402H16: tolerance: 64.4R705.6DL
PR4406 R4315 = R402H16: tolerance: 64.18725.6DL
PR4407 PR4483 PR4496 = R3720H40: tolerance: 64.R0105.7FL
PR4409 PR4417 PR4465 PR4474 PR4629 PR4672 PR4821-PR4824 PR5203 PR5304 PR8636 R1716 R1718 R2441 R2444 R4311 R4369 R4370 R6339 R7405 R7406 R7423-R7428 R7606 R7911 R7915 R7918 R7920 R7926 R7929 R7935 R7938 R7939 R8534 = R402H16: tolerance: 64.10035.6DL
PR4410 = R402H16: tolerance: 64.10535.60L
PR4411 PR4478 PR4627 PR4631 PR4639 PR4659 PR4663 PR8518 PR8521 R503 R719 R720 R726 R807-R810 R1604 = R402H14: tolerance: 64.10005.6DL
PR4412 PR4431 PR4433 PR4462 PR4476 PR8516 PR8519 PR8520 = 0R0402-PAD: tolerance: ZZ.R0402.ZZZ
PR4413 = R402H16: tolerance: 64.12125.6DL
PR4414 = 0R0805-PAD: tolerance: ZZ.R0805.ZZZ
PR4416 PR8502 = R603H22: tolerance: 63.2R233.15L
PR4420 PR4441 PR4443 PR4446 R6143 R6504 R6517 R7250 R7616 R7954 R8601 R8602 R8607-R8610 = R603H22: tolerance: 63.00000.00L
PR4422 = R402H16: tolerance: 64.1R005.6DL
PR4423 PR4424 PR4704 PR4803 PR4813 PR8503 = R402H16: tolerance: 64.2R205.6DL
PR4425 PR4434 PR4437 PR4445 PR4480 PR4484 PR4490 PR4493 R7403 = R402H16: tolerance: 64.R0005.6DL
PR4426 = R402H16: tolerance: 64.19635.6DL
PR4427 PR4429 R1506 R1508 R1510 R1525 R1731 = R402H16: tolerance: 64.10035.L1L
PR4430 PR4473 PR4505 PR4510 PR5104 PR5208 PR8505 R303 R403 R1715 R1724 R1727 R1737 R2417 R2420 R2434 R2436 R2440 R2449-R2452 R2455 R2478 R2489 R2497 R2518 R2520 R2702 R2710 R2716 R2717 R4004 R4031 R4032 R4309 R4318 R4378 R5506 R5528 R5529 R5709 R6505 R6507 R6509 R7018 R7221 R7239 R7241 R7301 R7302 R7404 R7905 R7910 R8640 R8643 R8645 = R402H16: tolerance: 63.10434.1DL
PR4432 PR4614 PR4669 PR8632 R404 R1307 R2003 R2004 R2028 R2405 R2418 R2427 R2428 R2430 R2431 R2467 R2468 R2473 R2477 R2502 R2616 R4007 R4017 R4018 R4020 R4024 R4037 R4039 R4040 R6113 R6114 R6136 R6419 R6601 R6602 R7230 R7231 R7234 R7235 R7303 R8530-R8533 R8542 R8543 R8545 R8546 R8605 R8629 R8638 R8648-R8652 R9154 = R402H15: tolerance: 63.R0034.L0L
PR4435 PR4472 = R402H16: tolerance: 64.10035.L3L
PR4436 PR4513 PR4514 R1841 R2567 R7220 R7222 R7223 R7226 R7242 R7243 R7248 R7249 R7903 R8604 = R402H16: tolerance: 63.10534.1DL
PR4438 PR4453 PR4463 PR4466 PR4495 PR8525-PR8527 PR8561 PR8576 R1708 R2406 R2435 R2476 R2512 R2513 R2517 R2601 R2615 R2737 R3601 R3602 R3605 R3606 R4010 R4033 R5524 R5537 R5538 R5707 R6408 R6511 R6515 R6518 R6519 R6521 R6801-R6803 R7002 R7003 R7008-R7014 R7218 R7219 R7224 R7225 R7229 R7232 R7233 R7236 R7238 R7240 R7304 R7305 R7326 R7604 R7613 R7615 R7618 R7912 R7913 R7940 R7958-R7967 R7973 R7974 R7976-R7978 R8603 R8611 R9110 R9121 R9122 R9137 R9139 R9142-R9144 R9149 R9150 R9152 R9992 R9994-R9996 = R402H16: tolerance: 63.R0034.1DL
PR4439 PR4506 PR4507 PR4509 PR4511 PR4603 PR4615 PR4635 R4379 = R402H16: tolerance: 64.10015.6DL
PR4440 PR4479 = R2512-4H35: tolerance: 64.R0015.77L
PR4444 PR8633 = 0R0603-PAD-U: tolerance: ZZ.R0603.001
PR4447 = R402H16: tolerance: 64.12735.6DL
PR4448 PR4449 R2711 R5711 R7402 R7407-R7409 = R402H16: tolerance: 64.20035.6DL
PR4450 PR4464 PR4503 PR4530 PR5114 PR5204 R2001 R2414 R2448 R2490 R4333 R5547 R7244 R7246 R7602 R7816 R7820 R7821 R7824 R7924 = R402H16: tolerance: 64.10025.6DL
PR4451 = R402H16: tolerance: 64.95325.6DL
PR4475 = R402H16: tolerance: 64.68035.6DL
PR4477 PR4486-PR4489 PR4504 PR4515 PR4516 PR4601 PR4602 PR4612 PR4613 PR4623 PR4647 PR4649 PR4665-PR4668 PR4701 PR4702 PR4706 PR4802 PR4806 PR4811 PR4812 PR5004 PR5105 PR5106 PR5109 PR5116 PR5206 PR5207 PR5301 PR5305 PR8507 PR8623 PR8631 PR8634 PR8635 = 0R0402-PAD: tolerance: ZZ.R0402.001
PR4485 = R402H16: tolerance: 64.18235.6DL
PR4491 = R402H16: tolerance: 64.71515.6DL
PR4492 = NTC-402H24-U: tolerance: 69.60028.031
PR4494 = R402H15: tolerance: 63.47434.L0L
PR4501 PR4502 PR8506 PR8509 = 0R0603-PAD: tolerance: ZZ.R0603.ZZZ
PR4508 PR4512 = R402H16: tolerance: 64.20035.L0L
PR4551 = R402H16: tolerance: 64.34835.6DL
PR4604 PR4607 = R402H16: tolerance: 64.10005.L1L
PR4605 = R402H16: tolerance: 64.75R05.6DL
PR4606 = R402H16: tolerance: 64.45R35.6DL
PR4608 = R402H16: tolerance: 64.76825.6DL
PR4609 PR4662 R1204 R1208 R1211 R1302 R1306 R1310 = R402H15: tolerance: 64.10025.L0L
PR4610 = R402H16: tolerance: 63.1R034.1DL
PR4611 PR4646 PR4650 = NTC-402H22-U: tolerance: 69.60037.011
PR4616 = R402H16: tolerance: 64.80615.6DL
PR4617 PR4654 = NTC-402H22-U: tolerance: 69.60037.021
PR4618 PR4643 PR4652 = R402H16: tolerance: 64.11025.6DL
PR4620 = R402H16: tolerance: 64.43005.6DL
PR4621 PR4655 = R402H16: tolerance: 64.27425.6DL
PR4622 PR4809 PR4815 R2908 R2910 = R402H16: tolerance: 64.10R05.L1L
PR4624 = R402H16: tolerance: 64.49R95.L0L
PR4625 PR4641 PR4653 = R402H16: tolerance: 64.26115.6DL
PR4626 = R402H16: tolerance: 64.33015.6DL
PR4628 = R402H16: tolerance: 64.93115.6DL
PR4630 PR4638 PR4657 = R402H16: tolerance: 64.20015.L0L
PR4632 = R402H16: tolerance: 64.30105.6DL
PR4633 = R402H16: tolerance: 64.25515.6DL
PR4636 PR4658 R302 R6407 = R402H16: tolerance: 64.49905.6DL
PR4637 = R402H16: tolerance: 64.17815.6DL
PR4640 = R402H16: tolerance: 64.24915.L0L
PR4642 = R402H16: tolerance: 64.35705.6DL
PR4644 R7907 = R402H16: tolerance: 64.40225.6DL
PR4645 PR4651 = R402H15: tolerance: 64.10015.L3L
PR4648 = R402H16: tolerance: 64.25505.6DL
PR4656 = R402H16: tolerance: 64.28715.6DL
PR4660 = R402H16: tolerance: 64.19115.6DL
PR4661 R4377 = R402H16: tolerance: 64.84525.6DL
PR4670 = R402H16: tolerance: 64.26705.6DL
PR4671 = R402H16: tolerance: 64.15415.6DL
PR4703 PR4805 PR4814 PR5110 = R1206H28: tolerance: 63.2R232.11L
PR4705 PR5001 = R603H24: tolerance: 64.2R205.L0L
PR4708 PR4808 PR4816 PR5003 = R402H16: tolerance: 64.36515.6DL
PR4712 PR4817 PR4818 = R402H16: tolerance: 64.51115.6DL
PR5101 = R402H16: tolerance: 64.10225.6DL
PR5102 = R402H16: tolerance: 64.64915.6DL
PR5103 = R402H16: tolerance: 64.51035.6DL
PR5107 = R402H16: tolerance: 64.62015.6DL
PR5108 = R402H16: tolerance: 63.10034.L0L
PR5111 = 0R0805-PAD-U: tolerance: ZZ.R0805.001
PR5112 = R402H16: tolerance: 64.29425.6DL
PR5113 = R402H16: tolerance: 64.13725.6DL
PR5115 PR5306 = R402H16: tolerance: 63.47334.1DL
PR5201 = R402H16: tolerance: 64.88725.6DL
PR5202 = R402H16: tolerance: 64.31615.6DL
PR5302 = R402H16: tolerance: 64.13325.6DL
PR5303 = R402H16: tolerance: 64.17425.6DL
PR8501 PR8513 = R805H24: tolerance: 64.2R205.16L
PR8504 = R402H16: tolerance: 64.49935.6DL
PR8508 = R402H16: tolerance: 64.15425.6DL
PR8510 PR8511 R2424 R3603 = R402H16: tolerance: 64.20025.6DL
PR8512 = R402H16: tolerance: 64.20015.6DL
PR8514 = R402H16: tolerance: 64.18025.6DL
PR8515 PR8517 PR8625 R402 R405 R406 R507 R1519 R1606 R1608 R1701 R1707 R1714 R1717 R1721-R1723 R1726 R1738 R1816 R1820-R1822 R1910-R1913 R2002 R2005 R2008-R2011 R2037 R2038 R2041 R2043-R2046 R2050-R2053 R2107 R2109 R2111-R2120 R2415 R2426 R2429 R2475 R2514 R2607 R4003 R4009 R4019 R4048 R4303 R5551 R5553-R5555 R6102 R6137 R6142 R6303 R6304 R6401 R6402 R6502 R7005 R7006 R7306 R7603 R7614 R7818 R7901 R7902 R7917 R7927 R7931 R7933 R7934 R7943 R7944 R7948 R7949 R7952 R7953 R7975 R8529 R8541 R8634 R8635 R8637 R9120 R9140 R9148 R9153 = R402H16: tolerance: 63.10334.1DL
PR8522 R301 R308 R315 R1502 R1503 R1517 R1518 R1527 R1702 R1909 R2432 R2453 R2506 R2735 R2921 R2922 R4005 R6506 R6516 R7318-R7325 R7327 R7340-R7344 R8109-R8112 = R402H16: tolerance: 63.10234.1DL
PR8523 = R402H16: tolerance: 64.13025.6DL
PR8577 = R402H16: tolerance: 64.16035.6DL
PR8613 = R402H16: tolerance: 64.34825.6DL
PR8620 = R402H16: tolerance: 64.51025.6DL
PR8626 = R402H16: tolerance: 64.12025.6DL
PR8627 R4302 R7237 = R402H16: tolerance: 64.15025.6DL
PT4701 PT4801 PT4803 PT8501-PT8503 = CT7343H83: tolerance: 79.33719.20C
PT4702 PT4805 = CT7343H83: tolerance: 79.33612.20L
PU4301 PU4302 U7418 = PPAK-8P-3232H36: tolerance: 84.07403.037
PU4401 = QFN32J4-G2D85H34: tolerance: 074.09538.0073
PU4403-PU4406 = PPAK-8P-3232H36: tolerance: 084.07380.0037
PU4412 PU4413 = PPAK-8P-3232H36: tolerance: 84.07401.037
PU4501 = QFN20Z3-G1D1H36: tolerance: 074.08286.0043
PU4502 = QFN20Z3-G1D1H36: tolerance: 074.08288.0B43
PU4601 = QFN40J5-G3D6-DIFF-H34: tolerance: 074.95859.0D33
PU4701 PU4801 PU4802 = QFN31G5-G4P-9H34: tolerance: 074.05038.0A73
PU5001 = DFN8G2-G1710-U1H40: tolerance: 074.95808.0B73
PU5002 PU5003 = PPAK-8P-3232H36: tolerance: 084.07408.0037
PU5101 = QFN32J4-G3PH32: tolerance: 074.05388.0043
PU5102 PU5301 = SOIC8-G3530H63: tolerance: 074.05934.003D
PU5201 = QFN22G4-G2PH42: tolerance: 074.02262.0043
PU8510 PU8512 PU8515 PU8516 = PPAK-8P-G5324H44-COLAY: tolerance: ZZ.00215.037
PU8514 = QFN20-G1D75H32: tolerance: 74.08812.073
PU8602 = QFN20Z3-G1H36: tolerance: 074.08288.0043
PU8603 = DFN8-G125065H32: tolerance: 074.05797.0073
Q502 Q4301 Q6401 Q7904 Q8601 = SOT23DGS2D4H44: tolerance: 084.00138.0A31
Q2507 Q2704 Q6504 = SOT23DGS2D4H48: tolerance: 084.02421.0031
Q2603 = SOT23CBE2D4H46-U: tolerance: 84.T3904.K11
Q4302 = SOT23CBE2D4H44: tolerance: 84.03904.T11
Q4304 = SOT323CBE2D2H40: tolerance: 84.05212.B11
Q4305 = SC70-2D2-312H44: tolerance: 84.00024.01K
Q4348 Q6101 Q8612 = SOT23DGS2D4H44: tolerance: 084.03415.0031
Q5703 = SOT23CBE2D4H44: tolerance: 84.T3904.H11
Q6402 Q7406 Q7407 Q7907 Q8509 Q8606 Q8607 Q8609 = SOT-363H44: tolerance: 075.00138.0A7C
Q6403 Q6404 Q6502 = SOT23CBE2D6H62: tolerance: 084.02418.0011
Q6501 = SOT23DGS2D4H44: tolerance: 084.03402.0031
R304 R305 R601 = R402H16: tolerance: 64.49R95.6DL
R309-R314 R316-R318 = R402H16: tolerance: 63.51034.1DL
R319 R504 R709 R732 R1303 R1311 R1704 R1706 R1713 R1728 R1814 R1839 R1840 R1842 R1843 R2020 R2021 R2025-R2027 R2401 R2402 R2407 R2416 R2419 R2421 R2422 R2438 R2439 R2445 R2458 R2462 R2469 R2470 R2472 R2474 R2479 R2480 R2491 R2515 R2602 R2611 R2612 R2617 R2708 R2709 R2712 R2719 R2734 R2740 R2741 R2914 R3432 R3512 R4002 R4011 R4029 R4030 R4301 R4368 R5530 R5531 R5712 R6002 R6016 R6105 R6301 R6308 R6404 R6405 R6508 R6512 R7007 R7957 R9806 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11
R401 R1209 R1309 = R402H16: tolerance: 64.24R95.6DL
R501 R8107 R8108 = R402H16: tolerance: 64.12105.6DL
R502 = R402H16: tolerance: 64.80R65.6DL
R505 = R402H16: tolerance: 64.47005.6DL
R506 = R402H16: tolerance: 64.22035.6DL
R723 = R402H16: tolerance: 64.54R95.6DL
R727 = R402H16: tolerance: 63.56034.1DL
R728 = R402H16: tolerance: 63.22134.1DL
R812-R816 = R805H20: tolerance: 063.R0007.0161
R1103 R1104 R1205 R1210 R1212 R2202-R2205 R2446 R2703-R2706 R2715 R2901-R2904 R2906 R2907 R2909 R2911 R2923 R4036 R4038 R4043 R4317 R5523 R6140 R7004 = 0R0603-PAD-1-U: tolerance: ZZ.00PAD.M21
R1206 R1305 = R402H16: tolerance: 64.2R005.6DL
R1215 R1312 = R402H16: tolerance: 64.24005.6DL
R1501 R1515 R1554 R1555 R2029 R2030 R4006 R4008 R4034 R4316 R6115 R6138 = R402H16: tolerance: 63.20334.1DL
R1504 R1507 R1509 R1511-R1514 R1516 R1520-R1522 R1551 = R402H15: tolerance: 63.47234.L0L
R1505 R1523 R1524 R1552 R1553 = R402H16: tolerance: 64.20525.6DL
R1603 = R402H16: tolerance: 64.11305.6DL
R1719 R2503 R4308 = R402H16: tolerance: 64.47025.6DL
R1730 = R402H16: tolerance: 63.33434.1DL
R1803 R7801 R7803 R7806 = R402H16: tolerance: 64.60R45.6DL
R1805 = R402H16: tolerance: 64.33R05.6DL; signal model: wistron_R1805
R1815 R2504 = R402H16: tolerance: 63.10634.1DL
R1818 = R402H16: tolerance: 64.82015.6DL
R1819 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: wistron_R1819
R1823 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: wistron_R1823
R1824 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: wistron_R1824
R1837 = R402H16: tolerance: 63.15434.1DL
R1845 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: wistron_R1845
R1901 R2108 = R402H16: tolerance: 64.20005.6DL
R1908 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: wistron_R1908
R1920 = R402H15: tolerance: 63.R0034.L0L; signal model: wistron_R1920
R1921 = R402H16: tolerance: 63.33034.1DL; signal model: wistron_R1921
R1922 R1923 R2568 R4305 R4306 R6135 = R402H16: tolerance: 63.33034.1DL
R2006 R2007 = R402H16: tolerance: 63.75034.1DL
R2048 R2049 R6503 = R402H16: tolerance: 63.51334.1DL
R2101 = R402H16: tolerance: 64.15005.6DL
R2404 = R402H16: tolerance: 64.11535.6DL
R2423 R2483 = R402H16: tolerance: 63.33134.1DL
R2437 = R402H16: tolerance: 63.43034.1DL
R2442 = R402H16: tolerance: 64.64925.6DL
R2443 R7908 R7909 R7914 R7919 R7925 R7928 = R402H16: tolerance: 64.49925.6DL
R2501 R2505 R2738 R2912 R2913 R6513 R7307 = R402H16: tolerance: 63.47234.1DL
R2507 = R402H16: tolerance: 63.33034.1DL; signal model: wistron_R2507
R2516 R2701 R2707 R2713 R2714 R5559 R5560 R6001 R6302 = 0R0805-PAD-1-U: tolerance: ZZ.00PAD.M31
R2569 = R402H16: tolerance: 63.33034.1DL; signal model: wistron_R2569
R2570 = R402H16: tolerance: 63.33034.1DL; signal model: wistron_R2570
R2571 = R402H16: tolerance: 63.33034.1DL; signal model: wistron_R2571
R2603 R2604 = R402H16: tolerance: 64.75015.6DL
R2608 = R402H16: tolerance: 64.27025.6DL
R2609 = R402H14: tolerance: 64.10R05.6DL
R2610 = NTC-603H38: tolerance: 69.60035.041
R2722 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: wistron_R2722
R2723 = R402H16: tolerance: 63.22034.1DL; signal model: wistron_R2723
R2724 = R402H16: tolerance: 63.22034.1DL; signal model: wistron_R2724
R2736 R2919 R2920 R7247 R8626 = R402H15: tolerance: 63.10334.L0L
R3501 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: Graser_R3501
R3502 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: Graser_R3502
R3503 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: Graser_R3503
R3504 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: Graser_R3504
R3521 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: Graser_R3521
R3522 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: Graser_R3522
R3524 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: Graser_R3524
R3533 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: Graser_R3533
R3604 = R402H16: tolerance: 64.22125.6DL
R3607 = R402H16: tolerance: 63.R0034.1DL; signal model: wistron_R3607
R3608 = R402H16: tolerance: 63.R0034.1DL; signal model: wistron_R3608
R4046 = R1206H26: tolerance: 64.R0105.71L
R4304 = R402H16: tolerance: 63.22234.1DL
R4307 = R603H22: tolerance: 63.24434.15L
R4310 = R402H15: tolerance: 63.10134.L0L
R4376 = R402H16: tolerance: 64.47035.6DL
R5502 R5503 R5556 R5557 = R402H16: tolerance: 64.33R05.6DL
R5518 R8642 R8644 R8646 R8647 = R402H14: tolerance: 63.10134.1DL
R5548 = R402H16: tolerance: 64.31625.6DL
R5558 = R603H22: tolerance: 63.R0033.L0L
R5713 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: wistron_R5713
R5714 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: wistron_R5714
R5715 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: wistron_R5715
R5716 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: wistron_R5716
R5717 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: wistron_R5717
R5720 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: wistron_R5720
R5721 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: wistron_R5721
R5722 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: wistron_R5722
R6109 R6118 = R402H16: tolerance: 63.22034.1DL
R6110 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: Graser_R6110
R6111 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: Graser_R6111
R6119 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: wistron_R6119
R6120 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: wistron_R6120
R6121 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: wistron_R6121
R6122 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: wistron_R6122
R6123 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: wistron_R6123
R6124 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: wistron_R6124
R6125 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: wistron_R6125
R6126 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: wistron_R6126
R6127 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: wistron_R6127
R6128 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: wistron_R6128
R6129 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: wistron_R6129
R6130 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11; signal model: wistron_R6130
R6133 = R402H16: tolerance: 64.71525.6DL
R6134 = R402H16: tolerance: 64.75025.6DL
R6311 = R402H15: tolerance: 63.R0034.L0L; signal model: wistron_R6311
R6312 = R402H15: tolerance: 63.R0034.L0L; signal model: wistron_R6312
R6313 = R402H15: tolerance: 63.R0034.L0L; signal model: wistron_R6313
R6314 = R402H15: tolerance: 63.R0034.L0L; signal model: wistron_R6314
R6315 = R402H15: tolerance: 63.R0034.L0L; signal model: wistron_R6315
R6316 = R402H15: tolerance: 63.R0034.L0L; signal model: wistron_R6316
R6317 = R402H15: tolerance: 63.R0034.L0L; signal model: wistron_R6317
R6318 = R402H15: tolerance: 63.R0034.L0L; signal model: wistron_R6318
R6406 R8101 R8104 = R402H16: tolerance: 64.54905.6DL
R6522 = R603H22: tolerance: 63.10133.15L
R7245 = R402H16: tolerance: 63.43334.1DL
R7252-R7255 = R402H16: tolerance: 63.33234.1DL
R7308 R7309 = R402H16: tolerance: 64.20045.6DL
R7310 = R402H16: tolerance: 63.R0034.1DL; signal model: Graser_R7310
R7311 = R402H16: tolerance: 63.R0034.1DL; signal model: Graser_R7311
R7312 = R402H16: tolerance: 63.R0034.1DL; signal model: Graser_R7312
R7313 = R402H16: tolerance: 63.R0034.1DL; signal model: Graser_R7313
R7314 = R402H16: tolerance: 63.R0034.1DL; signal model: Graser_R7314
R7315 = R402H16: tolerance: 63.R0034.1DL; signal model: Graser_R7315
R7316 = R402H16: tolerance: 63.R0034.1DL; signal model: Graser_R7316
R7317 = R402H16: tolerance: 63.R0034.1DL; signal model: Graser_R7317
R7401 R7422 R7430 = R402H16: tolerance: 64.10045.6DL
R7601 = R402H16: tolerance: 64.24915.6DL
R7605 = R402H16: tolerance: 63.20134.1DL
R7805 R7807 R8113-R8116 = R402H16: tolerance: 64.40R25.6DL
R7904 = R402H16: tolerance: 63.13234.1DL
R7921 R7932 = R402H16: tolerance: 64.49915.6DL
R8102 R8105 = R402H16: tolerance: 64.93105.6DL
R8103 R8106 = R402H16: tolerance: 64.13315.6DL
R8641 = R603H22: tolerance: 63.10033.15L
R9130 = R402H16: tolerance: 63.R0034.1DL; signal model: wistron_R9130
R9132 = R402H16: tolerance: 63.33034.1DL; signal model: wistron_R9132
R9133 = R402H16: tolerance: 63.33034.1DL; signal model: wistron_R9133
R9138 = R402H16: tolerance: 63.33034.1DL; signal model: wistron_R9138
RN401 RN403 RN1811 RN2413 RN2602 RN2901 RN5702 RN6502 = ARES2H16: tolerance: 66.22236.04L
RN1201 RN1301 RN2007 RN2008 = SMD-ARES4H18: tolerance: 66.10236.04L
RN1601 RN1813 RN2403 RN2404 = ARES8-CN24-MUH20: tolerance: 66.10336.08L
RN1602 = SMD-ARES4H20: tolerance: 66.R0036.04L
RN1703 RN1704 RN1810 RN2009 RN2603 RN6504 RN7910 = ARES2H18: tolerance: 66.10336.04L
RN1801 = SMD-ARES4H20: tolerance: 66.20336.04L
RN1806 = ARES8-CN24-MUH20: tolerance: 66.15035.A8L; signal model: wistron_RN1806
RN1807 = ARES8-CN24-UH20: tolerance: 66.22236.A8L
RN2402 RN2501 RN7901 = SMD-ARES4H18: tolerance: 66.47236.04L
RN2405 RN2412 RN2414-RN2416 RN5502 RN7203 = ARES8-CN24H20: tolerance: 66.10436.A8L
RN4302 RN5503 RN5504 RN6401 = SMD-ARES4H18: tolerance: 66.10136.04L
RN5701 RN5703 = ARES8-CN24H20: tolerance: 66.49156.08L
RN6503 = SMD-ARES4H18: tolerance: 66.33036.04L
RN7204 = SMD-ARES4H16: tolerance: 66.10336.L0L
RN7206 RN7701 RN7904 RN7905 = SMD-ARES4H18: tolerance: 66.22236.A4L
RTC1 = 3703K-Q02N-11L-U: tolerance: 20.F1841.002
SBD1 = 50208-01001-001: tolerance: 20.F2191.010
SKT251 = G6179HT0321-001: tolerance: 62.10089.011
SPR1 SPR2 = SPR8035H256: tolerance: 34.41Y19.001
SSD1 = APCI0079-P002A: tolerance: 62.10043.J01
TC3502 = C1206H75: tolerance: 78.10710.52LDL
THM261 = MSOP8-1H44: tolerance: 74.07718.0B9
TP301-TP308 TP402 TP618-TP621 TP1705-TP1714 TP1804 TP1806-TP1808 TP1903 TP2001 TP2002 TP2201 TP2202 TP2402 TP4411 TP4601 TP7201 TP7202 TP7205-TP7207 TP7801 TP7901-TP7906 TP9101 TP9102 TP9104 TP9949-TP9956 = TPAD14-OP: tolerance: ZZ.PAD14.001
TP4401 = TPAD28: tolerance: ZZ.PAD28.XXX
TPAD1 = 196574-08021-3: tolerance: 020.K0255.0008
U2401 = TQFP128-2H48: tolerance: 071.01416.000G
U2501 = SOIC8-1H86: tolerance: 072.25128.0B51
U2502 = SOT-23-5H56: tolerance: 074.06288.007B
U2701 = QFN40J5-G3D75H36: tolerance: 071.03204.0003
U3403 U3502 = SOT-23-5H56: tolerance: 074.06288.009B
U3601 = QFN16-G1D8-UH32: tolerance: 74.02544.073
U4001 U4003 = SON14J3020-G2610H34: tolerance: 074.22976.0091
U4002 U4004 U4006 = DFN8F3-G2517H32: tolerance: 074.05027.0093
U4007 U6402 U7601 U8502 U8604 U8605 = SC70-5H44: tolerance: 73.01G08.L04
U4302 = SOT-23-5H52: tolerance: 074.01004.00BF
U5501 = SOT-23-5H51: tolerance: 74.09724.09F
U5502 = SOT-23-5H58: tolerance: 074.05324.003F
U7001 = LGA12G2H40: tolerance: 074.LNG2D.00BZ
U7204 = BGA96G60-1H40: tolerance: 071.17030.000U
U7205 = DFN8A5060-G435345H32: tolerance: 072.25Q80.0B01
U7301 = QFN40J4060-G2848H32: tolerance: 071.00546.M001
U7419 = CSP15G154256H24: tolerance: 074.20509.007Z
U8601 = DFN14J32-G255D95H32: tolerance: 074.02898.0093
U9101 = QFN32G5-G3D6H32-COLAY: tolerance: ZZ.00PAD.TC1
USB1 = SKT-USB34-124103-U1: tolerance: 022.10005.M021
USB3 USB4 = SKT-USB13-160146-4: tolerance: 022.10005.0EY1
VRAM1 VRAM4 = BGA170D1214H48: tolerance: 072.05424.0A0U
WLAN1 = APCI0019-P002A01-U: tolerance: 62.10043.I91
X1801 = S-OSC3-2016H28: tolerance: 082.30006.0041
X1802 X2401 = SMD49-12H34: tolerance: 082.30003.0301
X7901 = SMD-OSC38H32: tolerance: 082.30008.0421

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
0R0402-PAD
  custom 0.127x0.127 smd: 1(0,0.432) 2(0,-0.432)
0R0402-PAD-1
  custom 0.127x0.127 smd: 1(0,0.432) 2(0,-0.432)
0R0603-PAD
  custom 0.254x0.254 smd: 1(0,0.66) 2(0,-0.66)
0R0603-PAD-1-U
  custom 0.254x0.254 smd: 1(0,0.66) 2(0,-0.66)
0R0603-PAD-U
  custom 0.254x0.254 smd: 1(0,0.66) 2(0,-0.66)
0R0805-PAD
  rect 1.549x1.346 smd: 1(0,0.838) 2(0,-0.838)
0R0805-PAD-1-U
  rect 1.549x1.333 smd: 1(0,0.838) 2(0,-0.838)
0R0805-PAD-U
  rect 1.549x1.333 smd: 1(0,0.838) 2(0,-0.838)
2SJ3166-007111F-U
  oval 1.143x1.93 hole 0.61x1.219: 1(-4.5,7.6) 2(-4.5,2.6) 6(4.5,2.4) MS(4.5,5)
  oval 1.143x1.778 hole 0.61x1.219: 3(-4.5,0) 4(4.5,0)
  oval 1.143x1.727 hole 0.61x1.016: 5(4.5,8.15)
40-42271-26001RHF-WD-U
  round 0.254 hole 1.6 unplated: (-34.4,0)
  round 0.254 hole 1.118 unplated: (34.4,0)
  custom 0.089x0.089 smd: 1(-33.375,-4.1) 2(-33.125,4.1) 3(-32.875,-4.1) 4(-32.625,4.1) 5(-32.375,-4.1) 6(-32.125,4.1) 7(-31.875,-4.1) 8(-31.625,4.1) 9(-31.375,-4.1) 10(-31.125,4.1) 11(-30.875,-4.1) 12(-30.625,4.1) 13(-30.375,-4.1) 14(-30.125,4.1) 15(-29.875,-4.1) 16(-29.625,4.1) 17(-29.375,-4.1) 18(-29.125,4.1) 19(-28.875,-4.1) 20(-28.625,4.1) 21(-28.375,-4.1) 22(-28.125,4.1) 23(-27.875,-4.1) 24(-27.625,4.1) 25(-27.375,-4.1) 26(-27.125,4.1) 27(-26.875,-4.1) 28(-26.625,4.1) 29(-26.375,-4.1) 30(-26.125,4.1) 31(-25.875,-4.1) 32(-25.625,4.1) 33(-25.375,-4.1) 34(-25.125,4.1) 35(-24.875,-4.1) 36(-24.625,4.1) 37(-24.375,-4.1) 38(-24.125,4.1) 39(-23.875,-4.1) 40(-23.625,4.1) 41(-23.375,-4.1) 42(-23.125,4.1) 43(-22.875,-4.1) 44(-22.625,4.1) 45(-22.375,-4.1) 46(-22.125,4.1) 47(-21.875,-4.1) 48(-21.625,4.1) 49(-21.375,-4.1) 50(-21.125,4.1) 51(-20.875,-4.1) 52(-20.625,4.1) 53(-20.375,-4.1) 54(-20.125,4.1) 55(-19.875,-4.1) 56(-19.625,4.1) 57(-19.375,-4.1) 58(-19.125,4.1) 59(-18.875,-4.1) 60(-18.625,4.1) 61(-18.375,-4.1) 62(-18.125,4.1) 63(-17.875,-4.1) 64(-17.625,4.1) 65(-17.375,-4.1) 66(-17.125,4.1) 67(-16.875,-4.1) 68(-16.625,4.1) 69(-16.375,-4.1) 70(-16.125,4.1) 71(-15.875,-4.1) 72(-15.625,4.1) 73(-15.375,-4.1) 74(-15.125,4.1) 75(-14.875,-4.1) 76(-14.625,4.1) 77(-14.375,-4.1) 78(-14.125,4.1) 79(-13.875,-4.1) 80(-13.625,4.1) 81(-13.375,-4.1) 82(-13.125,4.1) 83(-12.875,-4.1) 84(-12.625,4.1) 85(-12.375,-4.1) 86(-12.125,4.1) 87(-11.875,-4.1) 88(-11.625,4.1) 89(-11.375,-4.1) 90(-11.125,4.1) 91(-10.875,-4.1) 92(-10.625,4.1) 93(-10.375,-4.1) 94(-10.125,4.1) 95(-9.875,-4.1) 96(-9.625,4.1) 97(-9.375,-4.1) 98(-9.125,4.1) 99(-8.875,-4.1) 100(-8.625,4.1) 101(-8.375,-4.1) 102(-8.125,4.1) 103(-7.875,-4.1) 104(-7.625,4.1) 105(-7.375,-4.1) 106(-7.125,4.1) 107(-6.875,-4.1) 108(-6.625,4.1) 109(-6.375,-4.1) 110(-6.125,4.1) 111(-5.875,-4.1) 112(-5.625,4.1) 113(-5.375,-4.1) 114(-5.125,4.1) 115(-4.875,-4.1) 116(-4.625,4.1) 117(-4.375,-4.1) 118(-4.125,4.1) 119(-3.875,-4.1) 120(-3.625,4.1) 121(-3.375,-4.1) 122(-3.125,4.1) 123(-2.875,-4.1) 124(-2.625,4.1) 125(-2.375,-4.1) 126(-2.125,4.1) 127(-1.875,-4.1) 128(-1.625,4.1) 129(-1.375,-4.1) 130(-1.125,4.1) 131(-0.875,-4.1) 132(-0.625,4.1) 133(-0.375,-4.1) 134(-0.125,4.1) 135(0.125,-4.1) 136(0.375,4.1) 137(0.625,-4.1) 138(0.875,4.1) 139(1.125,-4.1) 140(1.375,4.1) 141(1.625,-4.1) 142(1.875,4.1) 143(2.125,-4.1) 144(2.375,4.1) 145(4.625,-4.1) 146(4.875,4.1) 147(5.125,-4.1) 148(5.375,4.1) 149(5.625,-4.1) 150(5.875,4.1) 151(6.125,-4.1) 152(6.375,4.1) 153(6.625,-4.1) 154(6.875,4.1) 155(7.125,-4.1) 156(7.375,4.1) 157(7.625,-4.1) 158(7.875,4.1) 159(8.125,-4.1) 160(8.375,4.1) 161(8.625,-4.1) 162(8.875,4.1) 163(9.125,-4.1) 164(9.375,4.1) 165(9.625,-4.1) 166(9.875,4.1) 167(10.125,-4.1) 168(10.375,4.1) 169(10.625,-4.1) 170(10.875,4.1) 171(11.125,-4.1) 172(11.375,4.1) 173(11.625,-4.1) 174(11.875,4.1) 175(12.125,-4.1) 176(12.375,4.1) 177(12.625,-4.1) 178(12.875,4.1) 179(13.125,-4.1) 180(13.375,4.1) 181(13.625,-4.1) 182(13.875,4.1) 183(14.125,-4.1) 184(14.375,4.1) 185(14.625,-4.1) 186(14.875,4.1) 187(15.125,-4.1) 188(15.375,4.1) 189(15.625,-4.1) 190(15.875,4.1) 191(16.125,-4.1) 192(16.375,4.1) 193(16.625,-4.1) 194(16.875,4.1) 195(17.125,-4.1) 196(17.375,4.1) 197(17.625,-4.1) 198(17.875,4.1) 199(18.125,-4.1) 200(18.375,4.1) 201(18.625,-4.1) 202(18.875,4.1) 203(19.125,-4.1) 204(19.375,4.1) 205(19.625,-4.1) 206(19.875,4.1) 207(20.125,-4.1) 208(20.375,4.1) 209(20.625,-4.1) 210(20.875,4.1) 211(21.125,-4.1) 212(21.375,4.1) 213(21.625,-4.1) 214(21.875,4.1) 215(22.125,-4.1) 216(22.375,4.1) 217(22.625,-4.1) 218(22.875,4.1) 219(23.125,-4.1) 220(23.375,4.1) 221(23.625,-4.1) 222(23.875,4.1) 223(24.125,-4.1) 224(24.375,4.1) 225(24.625,-4.1) 226(24.875,4.1) 227(25.125,-4.1) 228(25.375,4.1) 229(25.625,-4.1) 230(25.875,4.1) 231(26.125,-4.1) 232(26.375,4.1) 233(26.625,-4.1) 234(26.875,4.1) 235(27.125,-4.1) 236(27.375,4.1) 237(27.625,-4.1) 238(27.875,4.1) 239(28.125,-4.1) 240(28.375,4.1) 241(28.625,-4.1) 242(28.875,4.1) 243(29.125,-4.1) 244(29.375,4.1) 245(29.625,-4.1) 246(29.875,4.1) 247(30.125,-4.1) 248(30.375,4.1) 249(30.625,-4.1) 250(30.875,4.1) 251(31.125,-4.1) 252(31.375,4.1) 253(31.625,-4.1) 254(31.875,4.1) 255(32.125,-4.1) 256(32.375,4.1) 257(32.625,-4.1) 258(32.875,4.1) 259(33.125,-4.1) 260(33.375,4.1)
  rect 3.505x4.597 smd: 261(33.8,-12) 262(-33.8,-12)
300E40-1010RA-G3
  rect 0.305x0.889 smd: 1(-9.75,2.82) 2(-9.25,2.82) 3(-8.75,2.82) 4(-8.25,2.82) 5(-7.75,2.82) 6(-7.25,2.82) 7(-6.75,2.82) 8(-6.25,2.82) 9(-5.75,2.82) 10(-5.25,2.82) 11(-4.75,2.82) 12(-4.25,2.82) 13(-3.75,2.82) 14(-3.25,2.82) 15(-2.75,2.82) 16(-2.25,2.82) 17(-1.75,2.82) 18(-1.25,2.82) 19(-0.75,2.82) 20(-0.25,2.82) 21(0.25,2.82) 22(0.75,2.82) 23(1.25,2.82) 24(1.75,2.82) 25(2.25,2.82) 26(2.75,2.82) 27(3.25,2.82) 28(3.75,2.82) 29(4.25,2.82) 30(4.75,2.82) 31(5.25,2.82) 32(5.75,2.82) 33(6.25,2.82) 34(6.75,2.82) 35(7.25,2.82) 36(7.75,2.82) 37(8.25,2.82) 38(8.75,2.82) 39(9.25,2.82) 40(9.75,2.82)
  rect 0.559x0.889 smd: 41(-10.65,2.82) 42(10.65,2.82)
  rect 1.397x1.905 smd: 43(-12.849,0) 44(12.849,0)
3703K-Q02N-11L-U
  rect 0.61x1.549 smd: 1(-0.5,3.775) 2(0.5,3.775)
  rect 1.194x2.007 smd: 3(-1.8,0) 4(1.8,0)
3703K-Q08N-03R-U
  rect 0.61x1.549 smd: 1(-3.5,3.775) 2(-2.5,3.775) 3(-1.5,3.775) 4(-0.5,3.775) 5(0.5,3.775) 6(1.5,3.775) 7(2.5,3.775) 8(3.5,3.775)
  rect 1.194x2.007 smd: 9(-4.8,0) 10(4.8,0)
3806K-F10N-03L
  rect 0.813x1.905 smd: 1(-5.625,4.875) 2(-4.375,4.875) 3(-3.125,4.875) 4(-1.875,4.875) 5(-0.625,4.875) 6(0.625,4.875) 7(1.875,4.875) 8(3.125,4.875) 9(4.375,4.875) 10(5.625,4.875)
  rect 1.295x3.353 smd: 11(-8.475,0) 12(8.475,0)
50208-01001-001
  rect 0.508x0.991 smd: 1(3.6,1.95) 2(2.8,1.95) 3(2,1.95) 4(1.2,1.95) 5(0.4,1.95) 6(-0.4,1.95) 7(-1.2,1.95) 8(-2,1.95) 9(-2.8,1.95) 10(-3.6,1.95)
  rect 1.194x1.702 smd: 11(4.897,0) 12(-4.897,0)
50224-0040N-001
  rect 0.61x1.549 smd: 1(-1.5,3.875) 2(-0.5,3.875) 3(0.5,3.875) 4(1.5,3.875)
  rect 1.194x1.803 smd: 5(-2.797,0) 6(2.797,0)
50696-00601-001
  rect 0.305x0.813 smd: 1(1.25,2.5) 2(0.75,2.5) 3(0.25,2.5) 4(-0.25,2.5) 5(-0.75,2.5) 6(-1.25,2.5)
  rect 0.406x0.813 smd: 7(2.25,0) 8(-2.25,0)
50698-00401-W01-U
  rect 0.305x1.6 smd: 1(1.5,5.2) 2(0.5,5.2) 3(-0.5,5.2) 4(-1.5,5.2)
  rect 1.803x2.007 smd: 5(4.21,0) 6(-4.21,0)
87212-1400N
  rect 0.61x1.549 smd: 1(-6.5,-2.525) 2(-5.5,-2.525) 3(-4.5,-2.525) 4(-3.5,-2.525) 5(-2.5,-2.525) 6(-1.5,-2.525) 7(-0.5,-2.525) 8(0.5,-2.525) 9(1.5,-2.525) 10(2.5,-2.525) 11(3.5,-2.525) 12(4.5,-2.525) 13(5.5,-2.525) 14(6.5,-2.525)
  rect 1.194x1.803 smd: 15(-7.797,0) 16(7.797,0)
196528-30041-3
  rect 0.508x1.092 smd: 1(-11.6,1.75) 2(-10.8,1.75) 3(-10,1.75) 4(-9.2,1.75) 5(-8.4,1.75) 6(-7.6,1.75) 7(-6.8,1.75) 8(-6,1.75) 9(-5.2,1.75) 10(-4.4,1.75) 11(-3.6,1.75) 12(-2.8,1.75) 13(-2,1.75) 14(-1.2,1.75) 15(-0.4,1.75) 16(0.4,1.75) 17(1.2,1.75) 18(2,1.75) 19(2.8,1.75) 20(3.6,1.75) 21(4.4,1.75) 22(5.2,1.75) 23(6,1.75) 24(6.8,1.75) 25(7.6,1.75) 26(8.4,1.75) 27(9.2,1.75) 28(10,1.75) 29(10.8,1.75) 30(11.6,1.75)
  rect 1.651x1.295 smd: 31(-13.625,0) 32(13.625,0)
196574-08021-3
  rect 0.305x0.991 smd: 1(-3.5,3.2) 2(-2.5,3.2) 3(-1.5,3.2) 4(-0.5,3.2) 5(0.5,3.2) 6(1.5,3.2) 7(2.5,3.2) 8(3.5,3.2)
  rect 0.406x0.991 smd: 9(-5.185,0) 10(5.185,0)
AFTE14P-75
  round 0.356 smd: 1(0,0)
APCI0019-P002A01-U
  round 0.254 hole 1.6 unplated: (-10,0)
  round 0.254 hole 1.118 unplated: (10,0)
  rect 0.305x1.295 smd: 1(9.25,-5.148) 2(9,2.148) 3(8.75,-5.148) 4(8.5,2.148) 5(8.25,-5.148) 6(8,2.148) 7(7.75,-5.148) 8(7.5,2.148) 9(7.25,-5.148) 10(7,2.148) 11(6.75,-5.148) 12(6.5,2.148) 13(6.25,-5.148) 14(6,2.148) 15(5.75,-5.148) 16(5.5,2.148) 17(5.25,-5.148) 18(5,2.148) 19(4.75,-5.148) 20(4.5,2.148) 21(4.25,-5.148) 22(4,2.148) 23(3.75,-5.148) 32(1.5,2.148) 33(1.25,-5.148) 34(1,2.148) 35(0.75,-5.148) 36(0.5,2.148) 37(0.25,-5.148) 38(0,2.148) 39(-0.25,-5.148) 40(-0.5,2.148) 41(-0.75,-5.148) 42(-1,2.148) 43(-1.25,-5.148) 44(-1.5,2.148) 45(-1.75,-5.148) 46(-2,2.148) 47(-2.25,-5.148) 48(-2.5,2.148) 49(-2.75,-5.148) 50(-3,2.148) 51(-3.25,-5.148) 52(-3.5,2.148) 53(-3.75,-5.148) 54(-4,2.148) 55(-4.25,-5.148) 56(-4.5,2.148) 57(-4.75,-5.148) 58(-5,2.148) 59(-5.25,-5.148) 60(-5.5,2.148) 61(-5.75,-5.148) 62(-6,2.148) 63(-6.25,-5.148) 64(-6.5,2.148) 65(-6.75,-5.148) 66(-7,2.148) 67(-7.25,-5.148) 68(-7.5,2.148) 69(-7.75,-5.148) 70(-8,2.148) 71(-8.25,-5.148) 72(-8.5,2.148) 73(-8.75,-5.148) 74(-9,2.148) 75(-9.25,-5.148)
  rect 1.194x2.743 smd: 76(10.35,-4.5) 77(-10.35,-4.5)
APCI0079-P002A
  round 0.254 hole 1.6 unplated: (-10,0)
  round 0.254 hole 1.118 unplated: (10,0)
  rect 0.305x1.549 smd: 1(9.25,-5.275) 2(9,2.275) 3(8.75,-5.275) 4(8.5,2.275) 5(8.25,-5.275) 6(8,2.275) 7(7.75,-5.275) 8(7.5,2.275) 9(7.25,-5.275) 10(7,2.275) 11(6.75,-5.275) 12(6.5,2.275) 13(6.25,-5.275) 14(6,2.275) 15(5.75,-5.275) 16(5.5,2.275) 17(5.25,-5.275) 18(5,2.275) 19(4.75,-5.275) 20(4.5,2.275) 21(4.25,-5.275) 22(4,2.275) 23(3.75,-5.275) 24(3.5,2.275) 25(3.25,-5.275) 26(3,2.275) 27(2.75,-5.275) 28(2.5,2.275) 29(2.25,-5.275) 30(2,2.275) 31(1.75,-5.275) 32(1.5,2.275) 33(1.25,-5.275) 34(1,2.275) 35(0.75,-5.275) 36(0.5,2.275) 37(0.25,-5.275) 38(0,2.275) 39(-0.25,-5.275) 40(-0.5,2.275) 41(-0.75,-5.275) 42(-1,2.275) 43(-1.25,-5.275) 44(-1.5,2.275) 45(-1.75,-5.275) 46(-2,2.275) 47(-2.25,-5.275) 48(-2.5,2.275) 49(-2.75,-5.275) 50(-3,2.275) 51(-3.25,-5.275) 52(-3.5,2.275) 53(-3.75,-5.275) 54(-4,2.275) 55(-4.25,-5.275) 56(-4.5,2.275) 57(-4.75,-5.275) 58(-5,2.275) 67(-7.25,-5.275) 68(-7.5,2.275) 69(-7.75,-5.275) 70(-8,2.275) 71(-8.25,-5.275) 72(-8.5,2.275) 73(-8.75,-5.275) 74(-9,2.275) 75(-9.25,-5.275)
  rect 1.194x2.743 smd: 76(10.35,-4.5) 77(-10.35,-4.5)
ARES2H16
  rect 0.457x0.635 smd: 1(-0.335,-0.44) 2(0.335,-0.44) 3(0.335,0.44) 4(-0.335,0.44)
ARES2H18
  rect 0.457x0.635 smd: 1(-0.335,-0.44) 2(0.335,-0.44) 3(0.335,0.44) 4(-0.335,0.44)
ARES8-CN24-MUH20
  rect 0.457x0.61 smd: 1(-0.838,-0.445) 4(0.838,-0.445) 5(0.838,0.445) 8(-0.838,0.445)
  rect 0.305x0.61 smd: 2(-0.25,-0.445) 3(0.25,-0.445) 6(0.25,0.445) 7(-0.25,0.445)
ARES8-CN24-UH20
  rect 0.457x0.61 smd: 1(-0.838,-0.445) 4(0.838,-0.445) 5(0.838,0.445) 8(-0.838,0.445)
  rect 0.305x0.61 smd: 2(-0.25,-0.445) 3(0.25,-0.445) 6(0.25,0.445) 7(-0.25,0.445)
ARES8-CN24H20
  rect 0.457x0.559 smd: 1(-0.838,-0.483) 4(0.838,-0.483) 5(0.838,0.483) 8(-0.838,0.483)
  rect 0.305x0.559 smd: 2(-0.25,-0.483) 3(0.25,-0.483) 6(0.25,0.483) 7(-0.25,0.483)
BGA96G60-1H40
  round 0.356 smd: A1(-2.5,2.5) A7(0.5,2.5) A11(2.5,2.5) B1(-2.5,2) B2(-2,2) B3(-1.5,2) B4(-1,2) B5(-0.5,2) B6(0,2) B7(0.5,2) B8(1,2) B9(1.5,2) B10(2,2) B11(2.5,2) C2(-2,1.5) C10(2,1.5) C11(2.5,1.5) D2(-2,1) D5(-0.5,1) D6(0,1) D7(0.5,1) D8(1,1) D10(2,1) E2(-2,0.5) E4(-1,0.5) E5(-0.5,0.5) E6(0,0.5) E7(0.5,0.5) E8(1,0.5) E10(2,0.5) F2(-2,0) F4(-1,0) F5(-0.5,0) F6(0,0) F7(0.5,0) F8(1,0) F10(2,0) G2(-2,-0.5) G4(-1,-0.5) G5(-0.5,-0.5) G6(0,-0.5) G7(0.5,-0.5) G8(1,-0.5) G10(2,-0.5) H2(-2,-1) H4(-1,-1) H5(-0.5,-1) H6(0,-1) H7(0.5,-1) H8(1,-1) H10(2,-1) J2(-2,-1.5) J10(2,-1.5) J11(2.5,-1.5) K2(-2,-2) K3(-1.5,-2) K4(-1,-2) K5(-0.5,-2) K6(0,-2) K7(0.5,-2) K8(1,-2) K9(1.5,-2) K10(2,-2) K11(2.5,-2) L1(-2.5,-2.5) L11(2.5,-2.5)
  oval 0.229x0.356 smd: A2(-2,2.5) A3(-1.5,2.5) A4(-1,2.5) A5(-0.5,2.5) A6(0,2.5) A8(1,2.5) A9(1.5,2.5) A10(2,2.5) L2(-2,-2.5) L3(-1.5,-2.5) L4(-1,-2.5) L5(-0.5,-2.5) L6(0,-2.5) L7(0.5,-2.5) L8(1,-2.5) L9(1.5,-2.5) L10(2,-2.5)
  oval 0.356x0.229 smd: C1(-2.5,1.5) D1(-2.5,1) D11(2.5,1) E1(-2.5,0.5) E11(2.5,0.5) F1(-2.5,0) F11(2.5,0) G1(-2.5,-0.5) G11(2.5,-0.5) H1(-2.5,-1) H11(2.5,-1) J1(-2.5,-1.5) K1(-2.5,-2)
BGA170D1214H48
  round 0.406 smd: A1(-5.2,6.4) A2(-4.4,6.4) A3(-3.6,6.4) A12(3.6,6.4) A13(4.4,6.4) A14(5.2,6.4) B1(-5.2,5.6) B2(-4.4,5.6) B3(-3.6,5.6) B12(3.6,5.6) B13(4.4,5.6) B14(5.2,5.6) C1(-5.2,4.8) C2(-4.4,4.8) C3(-3.6,4.8) C12(3.6,4.8) C13(4.4,4.8) C14(5.2,4.8) R1(-5.2,-4.8) R2(-4.4,-4.8) R3(-3.6,-4.8) R12(3.6,-4.8) R13(4.4,-4.8) R14(5.2,-4.8) T1(-5.2,-5.6) T2(-4.4,-5.6) T3(-3.6,-5.6) T12(3.6,-5.6) T13(4.4,-5.6) T14(5.2,-5.6) U1(-5.2,-6.4) U2(-4.4,-6.4) U3(-3.6,-6.4) U12(3.6,-6.4) U13(4.4,-6.4) U14(5.2,-6.4)
  round 0.356 smd: A4(-2.8,6.4) A5(-2,6.4) A10(2,6.4) A11(2.8,6.4) B4(-2.8,5.6) B5(-2,5.6) B10(2,5.6) B11(2.8,5.6) C4(-2.8,4.8) C5(-2,4.8) C10(2,4.8) C11(2.8,4.8) D1(-5.2,4) D2(-4.4,4) D3(-3.6,4) D4(-2.8,4) D5(-2,4) D10(2,4) D11(2.8,4) D12(3.6,4) D13(4.4,4) D14(5.2,4) E1(-5.2,3.2) E2(-4.4,3.2) E3(-3.6,3.2) E4(-2.8,3.2) E5(-2,3.2) E10(2,3.2) E11(2.8,3.2) E12(3.6,3.2) E13(4.4,3.2) E14(5.2,3.2) F1(-5.2,2.4) F2(-4.4,2.4) F3(-3.6,2.4) F4(-2.8,2.4) F5(-2,2.4) F10(2,2.4) F11(2.8,2.4) F12(3.6,2.4) F13(4.4,2.4) F14(5.2,2.4) G1(-5.2,1.6) G2(-4.4,1.6) G3(-3.6,1.6) G4(-2.8,1.6) G5(-2,1.6) G10(2,1.6) G11(2.8,1.6) G12(3.6,1.6) G13(4.4,1.6) G14(5.2,1.6) H1(-5.2,0.8) H2(-4.4,0.8) H3(-3.6,0.8) H4(-2.8,0.8) H5(-2,0.8) H10(2,0.8) H11(2.8,0.8) H12(3.6,0.8) H13(4.4,0.8) H14(5.2,0.8) J1(-5.2,0) J2(-4.4,0) J3(-3.6,0) J4(-2.8,0) J5(-2,0) J10(2,0) J11(2.8,0) J12(3.6,0) J13(4.4,0) J14(5.2,0) K1(-5.2,-0.8) K2(-4.4,-0.8) K3(-3.6,-0.8) K4(-2.8,-0.8) K5(-2,-0.8) K10(2,-0.8) K11(2.8,-0.8) K12(3.6,-0.8) K13(4.4,-0.8) K14(5.2,-0.8) L1(-5.2,-1.6) L2(-4.4,-1.6) L3(-3.6,-1.6) L4(-2.8,-1.6) L5(-2,-1.6) L10(2,-1.6) L11(2.8,-1.6) L12(3.6,-1.6) L13(4.4,-1.6) L14(5.2,-1.6) M1(-5.2,-2.4) M2(-4.4,-2.4) M3(-3.6,-2.4) M4(-2.8,-2.4) M5(-2,-2.4) M10(2,-2.4) M11(2.8,-2.4) M12(3.6,-2.4) M13(4.4,-2.4) M14(5.2,-2.4) N1(-5.2,-3.2) N2(-4.4,-3.2) N3(-3.6,-3.2) N4(-2.8,-3.2) N5(-2,-3.2) N10(2,-3.2) N11(2.8,-3.2) N12(3.6,-3.2) N13(4.4,-3.2) N14(5.2,-3.2) P1(-5.2,-4) P2(-4.4,-4) P3(-3.6,-4) P4(-2.8,-4) P5(-2,-4) P10(2,-4) P11(2.8,-4) P12(3.6,-4) P13(4.4,-4) P14(5.2,-4) R4(-2.8,-4.8) R5(-2,-4.8) R10(2,-4.8) R11(2.8,-4.8) T4(-2.8,-5.6) T5(-2,-5.6) T10(2,-5.6) T11(2.8,-5.6) U4(-2.8,-6.4) U5(-2,-6.4) U10(2,-6.4) U11(2.8,-6.4)
BGA595M23H83
  round 0.432 smd: A2(-9.9,10.7) A3(-9.1,10.7) A25(9.1,10.7) A26(9.9,10.7) AE1(-10.7,-9.1) AE2(-9.9,-9.1) AE3(-9.1,-9.1) AE25(9.1,-9.1) AE26(9.9,-9.1) AE27(10.7,-9.1) AF1(-10.7,-9.9) AF2(-9.9,-9.9) AF3(-9.1,-9.9) AF25(9.1,-9.9) AF26(9.9,-9.9) AF27(10.7,-9.9) AG2(-9.9,-10.7) AG3(-9.1,-10.7) AG25(9.1,-10.7) AG26(9.9,-10.7) B1(-10.7,9.9) B2(-9.9,9.9) B3(-9.1,9.9) B25(9.1,9.9) B26(9.9,9.9) B27(10.7,9.9) C1(-10.7,9.1) C2(-9.9,9.1) C3(-9.1,9.1) C25(9.1,9.1) C26(9.9,9.1) C27(10.7,9.1)
  round 0.381 smd: A4(-8.3,10.7) A6(-6.6,10.7) A7(-5.8,10.7) A9(-4.12,10.7) A10(-3.32,10.7) A12(-1.64,10.7) A13(-0.84,10.7) A15(0.84,10.7) A16(1.64,10.7) A18(3.32,10.7) A19(4.12,10.7) A21(5.8,10.7) A22(6.6,10.7) A24(8.3,10.7) AA1(-10.7,-5.8) AA2(-9.9,-5.8) AA3(-9.1,-5.8) AA4(-8.3,-5.8) AA5(-7.5,-5.8) AA6(-6.66,-5.8) AA7(-5.8,-5.8) AA8(-4.96,-5.8) AA9(-4.12,-5.86) AA10(-3.32,-5.86) AA12(-1.64,-5.86) AA13(-0.84,-5.86) AA14(0,-5.86) AA15(0.84,-5.86) AA16(1.64,-5.86) AA18(3.32,-5.86) AA19(4.12,-5.86) AA20(4.96,-5.8) AA21(5.8,-5.8) AA22(6.66,-5.8) AA23(7.5,-5.8) AA24(8.3,-5.8) AA25(9.1,-5.8) AA26(9.9,-5.8) AA27(10.7,-5.8) AB1(-10.7,-6.6) AB2(-9.9,-6.6) AB3(-9.1,-6.6) AB4(-8.3,-6.6) AB5(-7.5,-6.6) AB6(-6.6,-6.6) AB7(-5.8,-6.66) AB8(-4.96,-6.66) AB9(-4.12,-6.66) AB10(-3.32,-6.66) AB11(-2.48,-6.66) AB12(-1.64,-6.66) AB13(-0.84,-6.66) AB14(0,-6.66) AB15(0.84,-6.66) AB16(1.64,-6.66) AB17(2.48,-6.66) AB18(3.32,-6.66) AB19(4.12,-6.66) AB20(4.96,-6.66) AB21(5.8,-6.66) AB22(6.6,-6.6) AB23(7.5,-6.6) AB24(8.3,-6.6) AB25(9.1,-6.6) AB26(9.9,-6.6) AB27(10.7,-6.6) AC2(-9.9,-7.45) AC3(-9.1,-7.45) AC4(-8.3,-7.45) AC5(-7.45,-7.45) AC6(-6.6,-7.5) AC7(-5.8,-7.5) AC8(-4.96,-7.5) AC9(-4.12,-7.5) AC10(-3.32,-7.5) AC11(-2.48,-7.5) AC12(-1.64,-7.5) AC13(-0.84,-7.5) AC14(0,-7.5) AC15(0.84,-7.5) AC16(1.64,-7.5) AC17(2.48,-7.5) AC18(3.32,-7.5) AC19(4.12,-7.5) AC20(4.96,-7.5) AC21(5.8,-7.5) AC22(6.6,-7.5) AC23(7.45,-7.45) AC24(8.3,-7.45) AC25(9.1,-7.45) AC26(9.9,-7.45) AD1(-10.7,-8.3) AD2(-9.9,-8.3) AD3(-9.1,-8.3) AD4(-8.3,-8.3) AD5(-7.45,-8.3) AD6(-6.6,-8.3) AD7(-5.8,-8.3) AD8(-4.96,-8.3) AD9(-4.12,-8.3) AD10(-3.32,-8.3) AD11(-2.48,-8.3) AD12(-1.64,-8.3) AD13(-0.84,-8.3) AD14(0,-8.3) AD15(0.84,-8.3) AD16(1.64,-8.3) AD17(2.48,-8.3) AD18(3.32,-8.3) AD19(4.12,-8.3) AD20(4.96,-8.3) AD21(5.8,-8.3) AD22(6.6,-8.3) AD23(7.45,-8.3) AD24(8.3,-8.3) AD25(9.1,-8.3) AD26(9.9,-8.3) AD27(10.7,-8.3) AE4(-8.3,-9.1) AE5(-7.45,-9.1) AE6(-6.6,-9.1) AE7(-5.8,-9.1) AE8(-4.96,-9.1) AE9(-4.12,-9.1) AE10(-3.32,-9.1) AE11(-2.48,-9.1) AE12(-1.64,-9.1) AE13(-0.84,-9.1) AE14(0,-9.1) AE15(0.84,-9.1) AE16(1.64,-9.1) AE17(2.48,-9.1) AE18(3.32,-9.1) AE19(4.12,-9.1) AE20(4.96,-9.1) AE21(5.8,-9.1) AE22(6.6,-9.1) AE23(7.45,-9.1) AE24(8.3,-9.1) AF4(-8.3,-9.9) AF5(-7.45,-9.9) AF6(-6.6,-9.9) AF7(-5.8,-9.9) AF8(-4.96,-9.9) AF9(-4.12,-9.9) AF10(-3.32,-9.9) AF11(-2.48,-9.9) AF12(-1.64,-9.9) AF13(-0.84,-9.9) AF14(0,-9.9) AF15(0.84,-9.9) AF16(1.64,-9.9) AF17(2.48,-9.9) AF18(3.32,-9.9) AF19(4.12,-9.9) AF20(4.96,-9.9) AF21(5.8,-9.9) AF22(6.6,-9.9) AF23(7.45,-9.9) AF24(8.3,-9.9) AG4(-8.3,-10.7) AG6(-6.6,-10.7) AG7(-5.8,-10.7) AG9(-4.12,-10.7) AG10(-3.32,-10.7) AG12(-1.64,-10.7) AG13(-0.84,-10.7) AG15(0.84,-10.7) AG16(1.64,-10.7) AG18(3.32,-10.7) AG19(4.12,-10.7) AG21(5.8,-10.7) AG22(6.6,-10.7) AG24(8.3,-10.7) B4(-8.3,9.9) B5(-7.45,9.9) B6(-6.6,9.9) B7(-5.8,9.9) B8(-4.96,9.9) B9(-4.12,9.9) B10(-3.32,9.9) B11(-2.48,9.9) B12(-1.64,9.9) B13(-0.84,9.9) B14(0,9.9) B15(0.84,9.9) B16(1.64,9.9) B17(2.48,9.9) B18(3.32,9.9) B19(4.12,9.9) B20(4.96,9.9) B21(5.8,9.9) B22(6.6,9.9) B23(7.45,9.9) B24(8.3,9.9) C4(-8.3,9.1) C5(-7.45,9.1) C6(-6.6,9.1) C7(-5.8,9.1) C8(-4.96,9.1) C9(-4.12,9.1) C10(-3.32,9.1) C11(-2.48,9.1) C12(-1.64,9.1) C13(-0.84,9.1) C14(0,9.1) C15(0.84,9.1) C16(1.64,9.1) C17(2.48,9.1) C18(3.32,9.1) C19(4.12,9.1) C20(4.96,9.1) C21(5.8,9.1) C22(6.6,9.1) C23(7.45,9.1) C24(8.3,9.1) D1(-10.7,8.3) D2(-9.9,8.3) D3(-9.1,8.3) D4(-8.3,8.3) D5(-7.45,8.3) D6(-6.6,8.3) D7(-5.8,8.3) D8(-4.96,8.3) D9(-4.12,8.3) D10(-3.32,8.3) D11(-2.48,8.3) D12(-1.64,8.3) D13(-0.84,8.3) D14(0,8.3) D15(0.84,8.3) D16(1.64,8.3) D17(2.48,8.3) D18(3.32,8.3) D19(4.12,8.3) D20(4.96,8.3) D21(5.8,8.3) D22(6.6,8.3) D23(7.45,8.3) D24(8.3,8.3) D25(9.1,8.3) D26(9.9,8.3) D27(10.7,8.3) E2(-9.9,7.45) E3(-9.1,7.45) E4(-8.3,7.45) E5(-7.45,7.45) E6(-6.6,7.5) E7(-5.8,7.5) E8(-4.96,7.5) E9(-4.12,7.5) E10(-3.32,7.5) E11(-2.48,7.5) E12(-1.64,7.5) E13(-0.84,7.5) E14(0,7.5) E15(0.84,7.5) E16(1.64,7.5) E17(2.48,7.5) E18(3.32,7.5) E19(4.12,7.5) E20(4.96,7.5) E21(5.8,7.5) E22(6.6,7.5) E23(7.45,7.45) E24(8.3,7.45) E25(9.1,7.45) E26(9.9,7.45) F1(-10.7,6.6) F2(-9.9,6.6) F3(-9.1,6.6) F4(-8.3,6.6) F5(-7.5,6.6) F6(-6.6,6.6) F7(-5.8,6.66) F8(-4.96,6.66) F9(-4.12,6.66) F10(-3.32,6.66) F11(-2.48,6.66) F12(-1.64,6.66) F13(-0.84,6.66) F14(0,6.66) F15(0.84,6.66) F16(1.64,6.66) F17(2.48,6.66) F18(3.32,6.66) F19(4.12,6.66) F20(4.96,6.66) F21(5.8,6.66) F22(6.6,6.6) F23(7.5,6.6) F24(8.3,6.6) F25(9.1,6.6) F26(9.9,6.6) F27(10.7,6.6) G1(-10.7,5.8) G2(-9.9,5.8) G3(-9.1,5.8) G4(-8.3,5.8) G5(-7.5,5.8) G6(-6.66,5.8) G7(-5.8,5.8) G8(-4.96,5.8) G9(-4.12,5.86) G10(-3.32,5.86) G12(-1.64,5.86) G13(-0.84,5.86) G14(0,5.86) G15(0.84,5.86) G16(1.64,5.86) G18(3.32,5.86) G19(4.12,5.86) G20(4.96,5.8) G21(5.8,5.8) G22(6.66,5.8) G23(7.5,5.8) G24(8.3,5.8) G25(9.1,5.8) G26(9.9,5.8) G27(10.7,5.8) H2(-9.9,4.96) H3(-9.1,4.96) H4(-8.3,4.96) H5(-7.5,4.96) H6(-6.66,4.96) H22(6.66,4.96) H23(7.5,4.96) H24(8.3,4.96) H25(9.1,4.96) H26(9.9,4.96) J1(-10.7,4.12) J2(-9.9,4.12) J3(-9.1,4.12) J4(-8.3,4.12) J5(-7.5,4.12) J6(-6.66,4.12) J7(-5.86,4.12) J21(5.86,4.12) J22(6.66,4.12) J23(7.5,4.12) J24(8.3,4.12) J25(9.1,4.12) J26(9.9,4.12) J27(10.7,4.12) K1(-10.7,3.32) K2(-9.9,3.32) K3(-9.1,3.32) K4(-8.3,3.32) K5(-7.5,3.32) K6(-6.66,3.32) K7(-5.86,3.32) K21(5.86,3.32) K22(6.66,3.32) K23(7.5,3.32) K24(8.3,3.32) K25(9.1,3.32) K26(9.9,3.32) K27(10.7,3.32) L2(-9.9,2.48) L3(-9.1,2.48) L4(-8.3,2.48) L5(-7.5,2.48) L6(-6.66,2.48) L22(6.66,2.48) L23(7.5,2.48) L24(8.3,2.48) L25(9.1,2.48) L26(9.9,2.48) M1(-10.7,1.64) M2(-9.9,1.64) M3(-9.1,1.64) M4(-8.3,1.64) M5(-7.5,1.64) M6(-6.66,1.64) M7(-5.86,1.64) M21(5.86,1.64) M22(6.66,1.64) M23(7.5,1.64) M24(8.3,1.64) M25(9.1,1.64) M26(9.9,1.64) M27(10.7,1.64) N1(-10.7,0.84) N2(-9.9,0.84) N3(-9.1,0.84) N4(-8.3,0.84) N5(-7.5,0.84) N6(-6.66,0.84) N7(-5.86,0.84) N21(5.86,0.84) N22(6.66,0.84) N23(7.5,0.84) N24(8.3,0.84) N25(9.1,0.84) N26(9.9,0.84) N27(10.7,0.84) P2(-9.9,0) P3(-9.1,0) P4(-8.3,0) P5(-7.5,0) P6(-6.66,0) P22(6.66,0) P23(7.5,0) P24(8.3,0) P25(9.1,0) P26(9.9,0) R1(-10.7,-0.84) R2(-9.9,-0.84) R3(-9.1,-0.84) R4(-8.3,-0.84) R5(-7.5,-0.84) R6(-6.66,-0.84) R7(-5.86,-0.84) R21(5.86,-0.84) R22(6.66,-0.84) R23(7.5,-0.84) R24(8.3,-0.84) R25(9.1,-0.84) R26(9.9,-0.84) R27(10.7,-0.84) T1(-10.7,-1.64) T2(-9.9,-1.64) T3(-9.1,-1.64) T4(-8.3,-1.64) T5(-7.5,-1.64) T6(-6.66,-1.64) T7(-5.86,-1.64) T21(5.86,-1.64) T22(6.66,-1.64) T23(7.5,-1.64) T24(8.3,-1.64) T25(9.1,-1.64) T26(9.9,-1.64) T27(10.7,-1.64) U2(-9.9,-2.48) U3(-9.1,-2.48) U4(-8.3,-2.48) U5(-7.5,-2.48) U6(-6.66,-2.48) U22(6.66,-2.48) U23(7.5,-2.48) U24(8.3,-2.48) U25(9.1,-2.48) U26(9.9,-2.48) V1(-10.7,-3.32) V2(-9.9,-3.32) V3(-9.1,-3.32) V4(-8.3,-3.32) V5(-7.5,-3.32) V6(-6.66,-3.32) V7(-5.86,-3.32) V21(5.86,-3.32) V22(6.66,-3.32) V23(7.5,-3.32) V24(8.3,-3.32) V25(9.1,-3.32) V26(9.9,-3.32) V27(10.7,-3.32) W1(-10.7,-4.12) W2(-9.9,-4.12) W3(-9.1,-4.12) W4(-8.3,-4.12) W5(-7.5,-4.12) W6(-6.66,-4.12) W7(-5.86,-4.12) W21(5.86,-4.12) W22(6.66,-4.12) W23(7.5,-4.12) W24(8.3,-4.12) W25(9.1,-4.12) W26(9.9,-4.12) W27(10.7,-4.12) Y2(-9.9,-4.96) Y3(-9.1,-4.96) Y4(-8.3,-4.96) Y5(-7.5,-4.96) Y6(-6.66,-4.96) Y22(6.66,-4.96) Y23(7.5,-4.96) Y24(8.3,-4.96) Y25(9.1,-4.96) Y26(9.9,-4.96)
  round 0.457 smd: K10(-4,4) K11(-3,4) K12(-2,4) K13(-1,4) K14(0,4) K15(1,4) K16(2,4) K17(3,4) K18(4,4) L10(-4,3) L11(-3,3) L12(-2,3) L13(-1,3) L14(0,3) L15(1,3) L16(2,3) L17(3,3) L18(4,3) M10(-4,2) M11(-3,2) M12(-2,2) M13(-1,2) M14(0,2) M15(1,2) M16(2,2) M17(3,2) M18(4,2) N10(-4,1) N11(-3,1) N12(-2,1) N13(-1,1) N14(0,1) N15(1,1) N16(2,1) N17(3,1) N18(4,1) P10(-4,0) P11(-3,0) P12(-2,0) P13(-1,0) P14(0,0) P15(1,0) P16(2,0) P17(3,0) P18(4,0) R10(-4,-1) R11(-3,-1) R12(-2,-1) R13(-1,-1) R14(0,-1) R15(1,-1) R16(2,-1) R17(3,-1) R18(4,-1) T10(-4,-2) T11(-3,-2) T12(-2,-2) T13(-1,-2) T14(0,-2) T15(1,-2) T16(2,-2) T17(3,-2) T18(4,-2) U10(-4,-3) U11(-3,-3) U12(-2,-3) U13(-1,-3) U14(0,-3) U15(1,-3) U16(2,-3) U17(3,-3) U18(4,-3) V10(-4,-4) V11(-3,-4) V12(-2,-4) V13(-1,-4) V14(0,-4) V15(1,-4) V16(2,-4) V17(3,-4) V18(4,-4)
