# Allegro board 17859-1.0710WZS1337.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ61: length 85.8
  L4 w0.089: v1(169.35,23.96) 168.9,24.41 168.9,28.15 156.66,40.39 156.66,41.82 152.91,45.57 152.91,46.47 143.45,55.93 134.46,55.93 134.35,56.04 134.35,56.22 134.25,56.32 134.1,56.32 134,56.22 134,56.04 133.89,55.93 133.75,55.93 133.64,56.04 133.64,56.22 133.54,56.32 133.39,56.32 133.29,56.22 133.29,56.04 133.18,55.93 133.03,55.93 132.93,56.04 132.93,56.22 132.83,56.32 132.68,56.32 132.57,56.22 132.57,56.04 132.47,55.93 132.32,55.93 132.22,56.04 132.22,56.22 132.11,56.32 131.97,56.32 131.86,56.22 131.86,56.04 131.76,55.93 128.78,55.93 126.63,58.09 122.93,58.09 122.14,58.88 120.57,58.88 119.07,60.38 118.63,60.38 116.53,62.48 115.44,62.48 114.29,63.63 114.14,63.63 113.94,63.83 113.46,63.83 113.1,64.19 113.1,64.54 113.28,64.72 113.28,65.28 113.18,65.37 113.18,65.9 v1(113.53,66.25)
  BOTTOM w0.089: CPU1.BG30 113.33,66.19 113.47,66.19 v1(113.53,66.25) ; DM2.236 169.64,23.67 v1(169.35,23.96)
M_B_DQ62: length 86.5
  L4 w0.089: v1(115.35,65.67) 115.83,65.19 116.09,65.19 117.04,64.24 119.13,64.24 121.39,61.98 124.1,61.98 125.42,60.66 132.99,60.66 135.82,63.49 138.47,63.49 140.2,61.75 140.2,60.51 141.16,59.55 141.31,59.55 141.78,60.02 141.93,60.02 142.03,59.92 142.03,59.77 141.56,59.3 141.56,59.15 141.66,59.05 141.81,59.05 142.28,59.52 142.43,59.52 142.54,59.42 142.54,59.27 142.06,58.79 142.06,58.65 142.16,58.54 142.31,58.54 142.79,59.02 142.93,59.02 143.61,58.35 144.16,58.35 155.13,47.38 155.13,46.45 158.9,42.68 158.9,41.38 173.64,26.64 173.64,26.11 173.18,25.65 v1(173.16,25.65)
  BOTTOM w0.089: DM2.249 172.89,26.7 172.79,26.6 172.79,26.02 v1(173.16,25.65) ; CPU1.BK30 114.99,65.93 115.25,65.67 v1(115.35,65.67)
M_B_DQ63: length 87.3
  L4 w0.089: v1(173.16,24.34) 173.44,24.06 173.9,24.06 173.98,24.15 173.98,26.74 159.21,41.51 159.21,42.55 159.21,42.81 155.45,46.58 155.45,47.24 155.45,47.25 155.45,47.51 144.29,58.66 143.74,58.66 138.6,63.8 135.68,63.8 132.8,60.92 127.39,60.92 126.8,61.51 124.9,61.51 124.23,62.18 121.46,62.18 119.2,64.44 117.09,64.44 116.68,64.85 116.68,65.28 115.64,66.32 v1(115.36,66.32)
  BOTTOM w0.089: v1(173.16,24.34) 172.98,24.34 171.89,25.43 DM2.245 ; v1(115.36,66.32) CPU1.BK29
M_B_DQS_DN0: length 52.1
  L6 w0.102: v1(111.06,25.61) 111.32,25.61 111.32,25.61 111.35,25.61 111.45,25.5 111.45,25.31 111.58,25.19 112,25.19 112.1,25.29 112.1,26.77 112,26.88 110.94,26.88 110.71,27.1 110.71,27.46 110.97,27.71 111.93,27.71 112.05,27.83 112.05,28.5 111.94,28.6 110.93,28.6 105.87,33.66 105.87,38.22 105.22,38.87 105.05,38.87 104.65,38.47 104.3,38.47 104.06,38.71 104.06,39.06 104.46,39.46 104.46,39.63 103.84,40.25 103.84,51.98 104.29,52.43 104.29,55.68 104.45,55.84 104.45,57.21 104.4,57.26 104.35,57.31 104.2,57.31 v1(103.99,57.1)
  BOTTOM w0.076: CPU1.AP35 104.97,62.49 104.97,62.43 104.84,62.06 104.84,61.86 104.89,61.71 104.89,60.49 104.67,60.27 104.67,59.92 104.86,59.73 104.86,58.35 104.46,57.95 104.46,56.95 104.39,56.87 104.22,56.87 v1(103.99,57.1)
  BOTTOM w0.089: v1(111.06,25.61) 111.06,25.57 111.37,25.26 111.52,25.26 111.69,25.43 111.69,26.68 111.39,26.99 DM2.11
M_B_DQS_DN1: length 50.4
  L6 w0.102: v1(107.07,55.99) 107.68,55.38 107.68,54.93 107.77,54.84 107.77,53.27 107.4,52.9 107.4,41.72 109.27,39.85 109.27,38.35 114.34,33.28 114.34,32.2 117.09,29.46 117.09,24.03 117.29,23.83 117.29,22.37 116.97,22.05 v1(116.14,22.05)
  BOTTOM w0.076: 107.52,58.96 107.52,58.98 107.53,58.99 107.53,59.34 107.08,59.78 107.08,60.48 107.25,60.65 107.25,61.5 107.21,61.74 107.18,61.87 107.18,62.09 107.2,62.15 107.37,62.74 CPU1.AV34
  BOTTOM w0.089: DM2.32 116.64,20.82 116.66,20.84 116.66,21.96 116.57,22.05 v1(116.14,22.05) ; v1(107.07,55.99) 107.23,55.84 107.37,55.84 107.52,55.98 107.52,58.96
M_B_DQS_DN2: length 84
  L4 w0.102: v1(103.46,64.96) 103.59,64.96 103.69,64.85 103.69,64.65 103.59,64.54 103.12,64.54 102.89,64.32 102.89,63.69 106.66,59.92 106.66,53.23 111.31,48.58 113.09,48.58 116.92,44.74 119.93,44.74 120.46,44.21 141,44.21 145.33,39.88 145.68,39.88 146.29,39.27 146.29,37.81 153.78,30.32 153.78,27.7 153.92,27.56 154.64,27.56 154.88,27.31 154.88,26.97 154.64,26.72 154.35,26.72 154.25,26.62 154.25,25.3 154.38,25.17 154.53,25.17 154.78,25.42 v1(154.78,25.45)
  BOTTOM w0.089: DM2.177 154.89,27 154.97,26.91 155.11,26.91 155.19,26.82 155.19,26.45 155.64,26 155.64,25.09 155.55,25 155.31,25 155.23,25.09 155.23,25.44 155.09,25.57 154.91,25.57 v1(154.78,25.45) ; v1(103.46,64.96) 103.37,64.86 103.24,64.86 103,65.1 103,65.23 CPU1.AL31
M_B_DQS_DN3: length 85.3
  L4 w0.102: v1(159.75,22.2) 159.92,22.04 160.27,22.04 160.37,22.14 160.37,22.61 160.66,22.9 160.66,24.15 159.34,25.47 159.34,30.17 149.42,40.08 149.42,41.02 142.09,48.35 122.66,48.35 120.66,50.35 120.66,51.48 119.11,53.04 116.3,53.04 115.08,54.26 111.37,54.26 110.99,54.64 110.99,60.33 110.8,60.52 110.8,60.84 109.29,62.35 108.92,62.35 106.94,64.33 106.94,64.92 107.04,65.02 v1(107.15,65.02)
  BOTTOM w0.089: v1(107.15,65.02) CPU1.AU31 ; v1(159.75,22.2) 159.75,22.26 159.84,22.35 160.02,22.35 160.37,22 160.37,21.23 160.14,21 DM2.198
M_B_DQS_DN4: length 50.8
  L6 w0.102: v1(110.08,55.35) 110.48,55.35 110.56,55.27 110.56,54.98 110.64,54.9 111.08,54.9 111.43,54.56 111.43,53.7 110.1,52.38 110.1,50.32 110.22,50.21 110.27,50.21 110.67,49.8 110.67,43.4 121.27,32.81 121.27,28.46 121.08,28.28 121.08,24.99 121.23,24.85 121.37,24.85 121.52,25 121.62,25.13 v1(121.62,25.25)
  BOTTOM w0.076: CPU1.BB35 110.19,62.59 110.36,62.13 110.38,62.07 110.38,62.06 110.38,61.86 110.37,61.82 110.36,61.81 110.36,61.79 110.35,61.78 110.26,61.52 110.26,60.46 110.53,60.19 110.53,58.22 110.81,57.94 110.81,57.41 110.81,57.41 110.81,57.39
  BOTTOM w0.089: DM2.53 121.88,27.01 122.19,26.7 122.19,25.33 121.89,25.02 121.71,25.02 121.62,25.11 v1(121.62,25.25) ; 110.81,57.39 110.81,56.29 111.18,55.91 111.18,54.97 111.09,54.88 110.55,54.88 110.46,54.97 110.46,55.26 110.37,55.35 v1(110.08,55.35)
M_B_DQS_DN5: length 53.1
  L6 w0.102: v1(127.77,22.98) 128.29,23.49 128.29,31 121.18,38.11 121.18,42.78 119.66,44.29 119.66,48.9 119.3,49.26 119.3,52.61 118.84,53.08 116.75,53.08 115.03,54.79 114.29,54.79 113.81,55.27 113.81,58.8 113.71,58.9 v1(112.9,58.9)
  BOTTOM w0.076: CPU1.BF34 112.98,62.52 113.05,62.18 113.08,62.09 113.08,61.82 113.06,61.77 113.05,61.76 113.03,61.72 113.01,61.65 113.01,60.81 113.42,60.41 113.42,59.26
  BOTTOM w0.089: v1(112.9,58.9) 113.06,58.9 113.42,59.26 ; v1(127.77,22.98) 127.14,22.34 DM2.74
M_B_DQS_DN6: length 83.1
  L4 w0.102: v1(166.08,24.82) 165.99,24.82 164.98,25.82 164.98,29.02 152.34,41.66 152.34,42.23 150.76,43.82 150.76,45.58 143.39,52.95 127.41,52.95 125.93,54.43 125.76,54.43 125.3,53.97 124.95,53.97 124.7,54.21 124.7,54.56 125.17,55.02 125.17,55.19 124.93,55.44 124.78,55.44 124.26,54.92 123.86,54.92 123.29,55.49 119.51,55.49 119.12,55.88 118.92,55.88 118.18,56.62 118.18,57.84 114.29,61.72 113.22,61.72 111.79,63.15 111.79,63.38 111.54,63.63 111.32,63.63 111.01,63.94 111.01,64.11 111.01,64.81 v1(110.8,65.02)
  BOTTOM w0.089: DM2.219 165.38,26.82 165.06,26.49 165.06,25.51 165.06,25.35 165.25,25.17 165.72,25.17 v1(166.08,24.82) ; v1(110.8,65.02) CPU1.BC31
M_B_DQS_DN7: length 85.2
  L4 w0.102: v1(114.43,65.03) 114.6,65.03 114.7,64.93 114.7,64.72 114.86,64.56 114.86,63.95 115.35,63.46 115.91,63.46 116.17,63.73 116.48,63.73 116.94,63.27 117.22,63.27 118.04,62.45 119.06,62.45 121.39,60.11 122.38,60.11 122.92,60.65 123.35,60.65 125.14,58.85 133.62,58.85 135.44,57.04 143.77,57.04 153.93,46.88 153.93,45.95 157.7,42.18 157.7,40.74 172.05,26.39 172.05,22.54 171.87,22.36 171.7,22.36 171.41,22.66 v1(171.41,22.76)
  BOTTOM w0.089: v1(171.41,22.76) 171.14,22.76 171.05,22.67 171.05,22.32 170.79,22.06 170.79,20.79 170.64,20.63 DM2.240 ; CPU1.BH31 113.99,65 114.09,64.9 114.3,64.9 v1(114.43,65.03)
M_B_DQS_DP0: length 52
  L6 w0.102: v1(111.06,24.97) 112.08,24.97 112.31,25.2 112.31,26.86 112.08,27.09 111.03,27.09 110.93,27.19 110.93,27.37 111.06,27.5 112.02,27.5 112.26,27.74 112.26,28.59 112.03,28.82 111.02,28.82 106.09,33.75 106.09,38.31 105.31,39.09 104.96,39.09 104.56,38.68 104.39,38.68 104.27,38.8 104.27,38.97 104.67,39.37 104.67,39.72 104.06,40.34 104.06,51.89 104.5,52.34 104.5,55.59 104.66,55.75 104.66,57.3 104.44,57.52 104.2,57.52 104.2,57.52 v1(103.99,57.73)
  BOTTOM w0.076: v1(103.99,57.73) 104.69,58.43 104.69,59.65 104.49,59.85 104.49,60.34 104.72,60.57 104.72,61.68 104.66,61.83 104.66,62.09 104.79,62.46 104.79,62.96 CPU1.AP34
  BOTTOM w0.089: v1(111.06,24.97) 111.15,25.07 111.6,25.07 111.88,25.35 DM2.13
M_B_DQS_DP1: length 50.4
  L6 w0.102: v1(116.14,22.76) 116.4,22.76 116.55,22.61 116.55,22.37 116.66,22.27 116.88,22.27 117.08,22.46 117.08,23.74 116.87,23.94 116.87,29.37 114.13,32.11 114.13,33.19 109.05,38.26 109.05,39.76 107.18,41.63 107.18,52.99 107.55,53.36 107.55,54.75 107.46,54.84 107.46,55.25 107.36,55.35 v1(107.07,55.35)
  BOTTOM w0.076: 107.71,58.96 107.71,58.98 107.7,58.99 107.7,59.41 107.26,59.86 107.26,60.4 107.43,60.57 107.43,61.52 107.38,61.77 107.36,61.89 107.36,62.06 107.36,62.07 107.36,62.07 107.39,62.14 107.4,62.15 107.41,62.18 CPU1.AV35
  BOTTOM w0.089: 107.71,58.96 107.71,55.91 107.45,55.65 107.36,55.65 v1(107.07,55.35) ; v1(116.14,22.76) 116.56,22.76 116.65,22.67 116.65,22.24 116.85,22.04 116.85,20.89 117.14,20.61 DM2.34
M_B_DQS_DP2: length 83.9
  L4 w0.102: v1(154.78,24.81) 154.64,24.95 154.29,24.95 154.03,25.21 154.03,26.71 154.26,26.94 154.55,26.94 154.67,27.06 154.67,27.22 154.55,27.34 153.83,27.34 153.56,27.61 153.56,30.23 146.07,37.72 146.07,39.18 145.59,39.66 145.24,39.66 140.91,44 120.37,44 119.84,44.53 116.83,44.53 113,48.36 111.22,48.36 106.45,53.14 106.45,59.83 102.67,63.6 102.67,64.41 103.03,64.76 103.03,65.19 v1(103.51,65.67)
  BOTTOM w0.089: v1(103.51,65.67) CPU1.AL30 ; v1(154.78,24.81) 155.63,24.81 155.83,25.01 155.83,26.08 155.39,26.53 DM2.179
M_B_DQS_DP3: length 85.3
  L4 w0.102: v1(159.75,22.89) 160.34,22.89 160.45,22.99 160.45,24.06 159.13,25.38 159.13,30.08 149.21,40 149.21,40.93 142,48.14 122.57,48.14 120.45,50.26 120.45,51.39 119.02,52.82 116.21,52.82 114.99,54.04 111.28,54.04 110.78,54.55 110.78,60.24 110.59,60.43 110.59,60.75 109.2,62.14 108.83,62.14 106.72,64.24 106.72,65.25 v1(107.15,65.67)
  BOTTOM w0.089: v1(159.75,22.89) 160.56,22.08 160.56,21.23 160.64,21.15 DM2.200 ; v1(107.15,65.67) CPU1.AU30
M_B_DQS_DP4: length 50.9
  L6 w0.102: v1(110.08,54.69) 110.99,54.69 111.21,54.47 111.21,53.79 109.89,52.47 109.89,50.23 110.13,49.99 110.18,49.99 110.46,49.71 110.46,43.31 121.05,32.72 121.05,28.55 120.87,28.37 120.87,24.9 121.14,24.63 121.62,24.63 v1(121.7,24.57)
  BOTTOM w0.076: CPU1.BB34 110.37,62.74 110.53,62.17 110.55,62.11 110.56,62.09 110.56,61.82 110.52,61.72 110.44,61.49 110.44,60.54 110.45,60.52 110.45,60.52 110.71,60.26 110.71,58.3 110.99,58.01 110.99,57.41 111,57.41 111,57.39
  BOTTOM w0.089: 111,57.39 111,56.37 111.37,55.99 111.37,54.89 111.17,54.69 v1(110.08,54.69) ; v1(121.7,24.57) 122.39,25.25 DM2.55
M_B_DQS_DP5: length 53.1
  L6 w0.102: v1(127.8,22.29) 127.97,22.29 128.2,22.52 128.2,23.1 128.51,23.41 128.51,31.09 121.39,38.2 121.39,42.87 119.88,44.38 119.88,48.99 119.51,49.35 119.51,52.7 118.93,53.29 116.83,53.29 115.12,55.01 114.38,55.01 114.03,55.36 114.03,58.89 113.8,59.12 113.48,59.12 113.38,59.22 113.38,59.44 113.28,59.54 v1(112.93,59.54)
  BOTTOM w0.076: v1(112.93,59.54) 112.99,59.47 113.16,59.47 113.24,59.55 113.24,60.33 112.83,60.74 112.83,61.68 112.87,61.78 112.87,61.79 112.88,61.81 112.89,61.83 112.9,61.86 112.9,62.06 112.88,62.11 112.87,62.14 112.85,62.15 CPU1.BF35
  BOTTOM w0.089: v1(127.8,22.29) 127.64,22.45 127.51,22.45 127.33,22.26 127.33,20.97 127.63,20.67 DM2.76
M_B_DQS_DP6: length 83
  L4 w0.102: v1(166.08,25.53) 165.58,25.53 165.2,25.91 165.2,29.11 152.56,41.75 152.56,42.32 150.97,43.91 150.97,45.67 143.48,53.16 127.5,53.16 126.02,54.65 125.67,54.65 125.21,54.18 125.04,54.18 124.92,54.3 124.92,54.47 125.38,54.94 125.38,55.28 125.01,55.65 124.69,55.65 124.17,55.13 123.95,55.13 123.38,55.7 119.6,55.7 119.21,56.1 119.01,56.1 118.4,56.71 118.4,57.93 114.38,61.94 113.31,61.94 112.01,63.24 112.01,63.47 111.63,63.85 111.41,63.85 111.23,64.03 111.23,65.24 v1(110.8,65.67)
  BOTTOM w0.089: v1(166.08,25.53) 165.91,25.36 165.33,25.36 165.26,25.43 165.26,26.42 165.89,27.05 DM2.221 ; v1(110.8,65.67) CPU1.BC30
M_B_DQS_DP7: length 85
  L4 w0.102: v1(114.44,65.67) 114.91,65.2 114.91,64.81 115.08,64.65 115.08,64.04 115.44,63.68 115.82,63.68 116.08,63.95 116.57,63.95 117.03,63.49 117.31,63.49 118.13,62.66 119.15,62.66 121.48,60.33 122.3,60.33 122.83,60.86 123.44,60.86 125.23,59.07 133.71,59.07 135.53,57.25 143.86,57.25 154.15,46.97 154.15,46.04 157.91,42.27 157.91,40.83 172.26,26.48 172.26,22.45 171.96,22.15 171.51,22.15 v1(171.41,22.05)
  BOTTOM w0.089: CPU1.BH30 114.18,65.93 v1(114.44,65.67) ; v1(171.41,22.05) 171.05,22.05 170.98,21.98 170.98,20.73 171.08,20.63 171.08,19.84 171.14,19.79 DM2.242
M_B_PARITY: length 88
  L4 w0.142: v1(144.77,23.27) 144.09,23.96 143.82,23.96 143.2,24.57 143.2,26.24 142.09,27.35 141.85,27.35 141.73,27.23 141.5,27.23 141.33,27.4 141.33,27.63 141.45,27.75 141.45,27.99 141.28,28.16 141.05,28.16 140.93,28.04 140.69,28.04 140.53,28.2 140.53,28.44 140.64,28.56 140.64,28.79 136.84,32.6 111.34,32.6 110.69,33.25 108.13,33.25 99.66,41.72 99.66,50.54 99.68,50.57 99.68,54.05 99.07,54.66 99.07,55.34 v1(98.69,55.71)
  BOTTOM w0.076: CPU1.AE34 99.66,63.33 99.66,62.82 99.64,62.76 99.64,62.49 99.66,62.41 99.66,62.21 99.64,62.11 99.64,61.81 99.69,61.68 99.69,61.59 99.69,61.58 99.69,61.41 99.7,61.41 99.7,60.64 99.66,60.6 99.66,60.39 98.11,58.84 98.11,55.79 98.19,55.71 v1(98.69,55.71)
  BOTTOM w0.14: v1(144.77,23.27) 145.41,23.27 145.61,23.47 145.61,23.92 145.45,24.08 144.81,24.08 144.65,24.24 144.65,24.48 144.81,24.64 145.45,24.64 145.61,24.8 145.61,25.03 145.45,25.2 144.81,25.2 144.65,25.36 144.65,25.59 144.81,25.76 145.45,25.76 145.61,25.92 145.61,26.43 145.47,26.57 144.75,26.57 144.39,26.93 DM2.143
M_VREF_CA_DIMMA: length 8
  TOP w0.254: R1206.1 72.05,19.99 C1229.1 73.13,19.74 RN1201.3 73.15,18.97 73.37,18.75 73.5,18.75 73.8,19.05 RN1201.4 74.24,19.76 74.44,19.97 74.44,21.31 v1(74.52,21.39)
  BOTTOM w0.254: v1(74.52,21.39) 74.62,21.29 74.62,21.01 74.63,20.99 DM1.164
M_VREF_CA_DIMMB: length 6.5
  TOP w0.254: R1305.1 C1301.1 150.72,19.15 151.05,19.48 RN1301.3 151.48,19.57 151.61,19.69 151.61,20.09 151.48,20.22 RN1301.4 151.05,20.58 151.3,20.83 v1(151.3,21.36)
  BOTTOM w0.254: DM2.164 151.63,20.98 151.38,21.24 151.38,21.29 v1(151.3,21.36)
MASK_BASE_LEDS#: length 80.8
  TOP w0.102: U6402.4 30.2,57.77 30.76,58.33 31.33,58.33 31.33,58.32 32.07,58.32 v1(32.46,58.7) 32.89,59.14 R6419.2 ; Q6402.2 Q6402.5 v2(18.43,98.86) 17.5,98.86 15.64,97.01 14.09,97.01 13.89,96.8 13.89,96.37 v1(14.09,96.17)
  L3 w0.102: v1(14.07,56.24) 12.62,57.69 12.62,60.81 13.74,61.93 13.74,65.71 12.04,67.41 12.04,71.79 11.81,72.02 11.81,80.22 13,81.41 13,82.63 13.63,83.26 13.63,83.77 13.38,84.03 12.74,84.03 12.36,84.41 12.36,87.58 12.62,87.84 12.62,93.4 12.36,93.65 12.36,95.84 13.06,96.54 13.72,96.54 v1(14.09,96.17)
  L4 w0.102: v1(14.07,56.24) 14.52,56.24 14.88,56.59 16.05,56.59 18.43,54.21 21.58,54.21 21.84,54.46 21.84,54.46 21.96,54.59 22.75,54.59 23.55,55.39 24.14,55.39 26.16,57.41 29.59,57.41 29.59,57.41 30.83,57.41 31.23,57.81 31.82,57.81 32.46,58.45 v1(32.46,58.7)
MASK_SATA_LED#: length 89.7
  TOP w0.102: v1(36.77,52.71) 36.38,52.32 U2401.56 ; Q6401.G v2(26.54,96) 25.99,95.46 25.5,95.46 24.96,94.92 v1(24.96,94.72)
  L3 w0.102: v1(14.04,59.21) 14.04,59.36 v1(13.2,60.2)
  L4 w0.102: v1(13.2,60.2) 13.2,61.32 12.54,61.98 12.54,70.97 13.46,71.88 13.46,77.18 17.33,81.05 19.78,81.05 21.03,82.3 21.03,85.07 21.51,85.55 21.51,87.15 17.6,91.06 17.6,93.55 18.18,94.14 18.46,94.14 19.4,95.07 20.39,95.07 v1(20.81,95.49) ; v1(14.04,59.21) 12.62,57.79 12.62,57.74 12.52,57.64 12.52,55.55 12.62,55.45 12.62,54.82 15.82,51.62 18.87,51.62 19.07,51.82 20.95,51.82 22.24,53.11 25.34,53.11 27.55,55.32 30.28,55.32 30.43,55.48 34,55.48 v1(36.77,52.71)
  BOTTOM w0.102: v1(24.96,94.72) 24.43,95.25 21.05,95.25 v1(20.81,95.49) 21,95.68 R6401.2
ME_FWP: length 141.5
  TOP w0.102: R9806.1 84.91,103.89 84.42,104.37 v1(84.2,104.37) 84.3,104.47 v2(84.3,105.07) ; U2401.80 33.53,43.71 v1(33.8,43.44)
  L3 w0.102: v1(20.77,43.97) 20.77,44.03 19.65,45.15 19.65,49.05 18.28,50.42 18.28,52.58 19.7,54 19.7,55.37 18.64,56.44 18.64,63.35 19.07,63.78 19.07,67.34 20.19,68.46 20.19,69.09 20.85,69.75 20.85,72.8 22.46,74.41 22.46,78.54 21.08,79.93 21.08,84.74 21.94,85.6 21.94,87.33 21.63,87.63 21.63,92.01 23.56,93.94 27.35,93.94 28.16,94.74 31.67,94.74 33.14,96.22 34.94,96.22 38.42,99.7 62.02,99.7 69.34,107.01 73.4,107.01 v1(74.29,106.12)
  L4 w0.102: v1(33.8,43.44) 33.8,43.16 33.52,42.88 33.52,42.75 33.02,42.24 31.74,42.24 31.53,42.46 27.64,42.46 27.43,42.24 23.77,42.24 23.41,42.6 22.77,42.6 21.45,43.92 20.82,43.92 v1(20.77,43.97)
  BOTTOM w0.102: v1(84.2,104.37) 84.16,104.34 83.7,104.34 83.38,104.66 83.36,104.66 83.25,104.78 82.43,104.78 81.97,105.23 76.88,105.23 76.63,104.98 75.43,104.98 v1(74.29,106.12)
ME_FWP_SW: length 203.3
  TOP w0.102: v1(83.51,105.26) 83.54,105.23 83.54,104.98 83.76,104.76 83.76,104.16 84.04,103.88 R9806.2 ; v1(66.29,45.55) v2(67.52,46.78) 68.88,48.14 74.83,48.14 76.53,49.84 78.25,49.84 v1(78.48,49.61) ; v1(24.07,60.53) 24.2,60.4 28.5,60.4 28.96,60.86 29.94,60.86 30.4,61.32 30.4,61.47 v1(30.14,61.72) ; R1909.1 110.66,46.18 110.76,46.08 v1(111.17,46.08)
  L3 w0.102: v1(66.29,45.55) 66.29,47.42 62.85,50.87 62.85,51.98 57.68,57.15 56.64,57.15 55.85,57.94 53.56,57.94 52.13,59.38 50.6,59.38 v1(50.41,59.18) ; v1(83.51,105.26) 83.48,105.29 81.86,105.29 80.69,104.12 79.78,104.12 79.45,103.79 77.87,103.79 77.5,104.16 68,104.16 62.5,98.66 39.01,98.66 32.23,91.87 27.14,91.87 23.84,88.58 23.84,83.09 24.15,82.79 24.15,80.15 23.39,79.39 23.39,79.28 23.54,79.12 23.54,73.56 23.39,73.41 23.39,73.31 21.91,71.83 21.91,68.25 20.7,67.03 20.7,64.26 22.75,62.21 22.75,61.85 v1(24.07,60.53)
  L6 w0.102: v1(50.41,59.18) 47.95,61.65 46.6,61.65 45.51,62.74 44.52,62.74 44.49,62.77 38.32,62.77 37.54,61.98 31.67,61.98 31.41,61.72 v1(30.14,61.72)
  BOTTOM w0.102: v1(78.48,49.61) 78.98,49.61 80.97,47.62 109.4,47.62 110.98,46.04 111.13,46.04 v1(111.17,46.08)
ME_SUS_PWR_ACK_R: length 11.6
  TOP w0.127: v1(120.31,56.37) 121.13,55.54 121.13,53.28 R1708.1 R1738.2
  BOTTOM w0.076: CPU1.BV34 119.94,63 119.94,62.54 119.94,62.53 119.94,62.52 119.98,62.41 119.98,62.19 119.97,62.17 119.97,62.17 119.93,62.05 119.93,61.87 119.97,61.75 119.97,61.75 120.09,61.63 120.09,60.37 119.81,60.09 119.81,59.09 120.06,58.84
  BOTTOM w0.127: v1(120.31,56.37) 120.06,56.62 v2(120.06,57.43) 120.06,58.84
MEC_XTAL1_R: length 5
  TOP w0.089: X2401.1 43.81,32.54 C2425.2 44.34,33.16 44.63,33.45 44.63,34.21 v2(44.22,34.62) 43.58,35.26 U2401.123
MEC_XTAL2: length 3.1
  TOP w0.089: R2458.1 45.08,33.12 R2428.1 45.08,34.3 44.38,35 U2401.125
MIC2_VREFO: length 7.2
  TOP w0.203: U2701.23 21.02,17 19.83,18.19
  TOP w0.254: v1(18.74,18.42) 18.82,18.42 18.89,18.49 19.53,18.49 19.83,18.19
  BOTTOM w0.254: RN2901.1 18.63,19.67 v2(18.84,19.46) 18.84,19.18 18.66,19 RN2901.2 17.88,18.51 18.06,18.33 18.65,18.33 v1(18.74,18.42)
MIC_CAP: length 9.5
  TOP w0.203: U2701.15 24.17,19.53 23.85,19.85 v1(23.18,19.85)
  L3 w0.254: v1(23.18,19.85) 23.18,20.22 20.87,22.53 v1(20.87,23.8)
  BOTTOM w0.254: v2(20.62,21.47) 20.62,22.35 C2715.1 v1(20.87,23.8)
MIC_GND: length 3
  TOP w0.305: R5531.1 51.66,90.63 51.66,91.09 v1(51.63,91.11) 51.73,91.21 v2(52.47,91.21)
  BOTTOM w0.305: v1(51.63,91.11) 51.66,91.11 52.06,91.51 LCD1.29
MODEL_ID: length 5.4
  TOP w0.102: R2442.2 36.34,31.52 36.34,32.13 36.29,32.18 v2(36.29,32.26) 36.9,32.87 R2441.1 36.9,33.73 37,33.84 C2407.2 37,34.34 37.64,34.98 37.8,34.98 37.98,35.16 U2401.109
MSATA_RST#: length 3.7
  TOP w0.102: R6308.2 218.66,9.1 219.04,9.48 v2(219.04,9.76) 218.79,10.01 v1(218.13,10.01)
  BOTTOM w0.102: SSD1.50 217.94,10.2 v1(218.13,10.01)
MUX_HPD_PD: length 3.7
  TOP w0.102: R7326.1 32.36,69.8 v2(31.92,69.35) 31.88,69.32 30.8,69.32 30.08,70.05 U7301.23
N12P_JTAG_TCK: length 9.3
  BOTTOM w0.102: TP7906.1 165.07,83.95 165.6,84.48 168.18,84.48 168.93,85.23 168.93,85.31 170.18,86.57 170.91,86.57 171.81,85.67 GPU1.AE5
N12P_JTAG_TDI: length 9
  BOTTOM w0.102: TP7905.1 166.8,85.78 166.8,85.27 167.19,84.88 168.29,84.88 168.6,85.19 168.6,85.39 169.98,86.77 171.97,86.77 172.27,86.47 172.79,86.47 GPU1.AE6
N12P_JTAG_TDO: length 5.7
  BOTTOM w0.102: GPU1.AF6 172.28,86.97 167.38,86.97 TP7901.1
N12P_JTAG_TMS: length 9.9
  TOP w0.102: v1(172.97,84.51) 172.97,83.95 170.63,81.61 168.32,81.61 TP7902.1
  BOTTOM w0.102: v1(172.97,84.51) 172.97,84.58 173.55,85.17 GPU1.AD6
N12P_JTAG_TRST: length 6.9
  BOTTOM w0.102: 170.65,86.2 170.1,86.2 169.13,85.23 169.13,84.82 166.68,82.37 v2(166.49,82.37) R7975.1
N12P_XTAL_OUTBUFF: length 15.1
  TOP w0.102: R7917.2 R7902.1 197.31,68.27 v2(197.31,68.58) 197.5,68.77 197.5,69.47 197.02,69.95 196.69,69.95 193.92,72.72 192.27,72.72 190.42,74.58 v1(188.76,74.58)
  BOTTOM w0.102: v1(188.76,74.58) 188.74,74.58 188.18,75.14 188.18,75.19 188.18,75.19 GPU1.C10
NAZ_GND1: length 4.4
  TOP w0.102: R9137.2 207.21,35.13 v2(207.02,34.94) 205.96,33.88 U9101.2
NAZ_GND2: length 2.8
  TOP w0.102: R9142.1 205.78,39.09 v2(205.78,38.36) 205.05,38.36 204.87,38.18 U9101.9
NB_MODE#: length 113.4
  TOP w0.102: Q2001.3 129.02,47.15 R2002.2 127.98,46.94 128.54,46.38 R2050.1 128.62,45.82 128.62,45.39 128.47,45.24 128.44,45.21 128.44,43.31 129.1,42.65 129.1,40.87 122.4,34.17 73.35,34.17 v2(71.55,35.97) 70.63,36.88 62.63,36.88 v1(62.45,37.06) ; U2401.34 45.18,50.27 45.36,50.09 45.36,49.58 45.08,49.3 44.24,49.3 v1(44.09,49.46)
  L4 w0.102: v1(55.24,39.8) 55.26,39.83 55.26,41.76 52.98,44.05 52.98,45.67 52.9,45.75 52.9,46.28 54.73,48.11 54.73,49.63 53.92,50.45 52.67,50.45 52.65,50.42 51.07,50.42 50.03,49.38 45.64,49.38 45.41,49.15 44.42,49.15 44.11,49.46 v1(44.09,49.46)
  BOTTOM w0.102: v1(55.24,39.8) 55.7,39.8 57.47,38.03 58.78,38.03 59.97,36.83 62.22,36.83 v1(62.45,37.06)
NB_MUTE#: length 38.2
  TOP w0.102: U2401.119 41.98,36.5 42.46,36.99 v1(42.54,36.99)
  L4 w0.102: v1(42.54,36.99) 41.5,35.94 33.85,35.94 30.96,33.05 30.96,32.51 29.8,31.36 28.61,31.36 28.26,31.01 v1(28.26,30.97)
  BOTTOM w0.102: v1(28.26,30.97) 28.26,30.96 28.26,30.37 28.49,30.13 28.49,28.78 28.92,28.35 29.25,28.35 29.64,27.97 29.64,26.44 29.11,25.92 29.11,19.4 v2(30.91,17.6) 31.67,16.84 31.67,16.16 30.91,15.4 R2712.1 30.5,15.45 R2717.2
NC_AUX_EN_WOWL_EC: length 27
  TOP w0.102: U2401.97 33.18,36.77 35.88,39.47 35.88,40.26 34.39,41.76 34.39,44.63 v1(34.08,44.94) ; v2(31.52,56.19) 31.49,56.16 31.49,55.93 30.8,55.25 R2427.2 30.4,55.05 29.6,54.25 v1(29.6,53.75)
  L3 w0.102: v1(29.6,53.75) 29.6,53.4 30.02,52.99 32.3,52.99 32.96,52.33 32.99,52.33 33.34,51.97 33.34,50.24 32.68,49.58 32.68,49.23 33.04,48.87 33.04,48.29 33.67,47.65 33.67,45.34 v1(34.08,44.94)
NCT7718_DXN: length 206.1
  L6 w0.254: v1(171.34,61.42) 171.34,61.42 171.47,61.55 171.47,66.86 172.03,67.41 172.03,68.92 173.02,69.91 173.02,70.04 173.6,70.61 173.72,70.61 174.03,70.93 174.03,73.97 168.35,79.66 168.35,80.21 168.08,80.47 167.1,80.47 163.06,84.51 162.01,84.51 160.22,86.3 160.22,99.81 164.35,103.94 166.9,103.94 167.97,102.88 v1(168.43,102.88)
  BOTTOM w0.254: v1(171.34,61.42) 171.34,60.48 173.22,58.59 173.22,55.36 172.22,54.36 166.41,54.36 162.78,50.73 162.78,47.63 163.39,47.02 163.39,45.82 164.74,44.47 164.74,43.52 163.57,42.35 163.57,41.31 161.36,39.09 148.81,39.09 147.62,37.9 117.43,37.9 112.63,42.7 109.26,42.7 108.59,43.38 79.33,43.38 69.34,53.37 61.49,53.37 61.18,53.68 61.18,54.64 61.46,54.92 v2(61.51,54.92) 61.49,54.95 Q2603.E ; THM261.3 169.76,105.88 170.07,105.56 C2607.2 170.07,104.88 169.82,104.63 168.98,104.63 C2606.2 168.14,103.17 v1(168.43,102.88)
NCT7718_DXP: length 208.8
  L6 w0.254: v1(169.3,102.89) 168.73,102.31 167.81,102.31 166.69,103.43 164.56,103.43 160.73,99.6 160.73,86.52 162.22,85.02 163.27,85.02 167.31,80.98 168.29,80.98 168.85,80.42 168.85,79.87 174.54,74.18 174.54,70.72 173.93,70.11 173.81,70.11 173.53,69.83 173.53,69.7 172.54,68.71 172.54,67.2 171.98,66.65 v1(171.98,60.84)
  BOTTOM w0.254: v1(171.98,60.84) 171.98,60.55 v2(172.47,60.07) 173.73,58.8 173.73,55.15 172.43,53.85 166.63,53.85 163.29,50.52 163.29,47.84 163.9,47.23 163.9,46.03 165.25,44.68 165.25,43.31 164.08,42.14 164.08,41.1 161.57,38.59 149.02,38.59 147.83,37.39 117.22,37.39 112.41,42.19 109.05,42.19 108.38,42.87 79.12,42.87 69.13,52.86 61.28,52.86 60.67,53.47 60.67,54.75 Q2603.C 60.54,56.08 Q2603.B ; v1(169.3,102.89) 169.46,103.05 C2606.1 169.79,104.12 170.03,104.12 170.26,104.35 170.38,104.35 C2607.1 170.73,105.21 170.73,105.62 169.82,106.53 THM261.2
NRB_BIT: length 15.5
  TOP w0.102: v1(129.18,56.52) 129.18,58.75 128.54,59.39 128.54,61.75 127.12,63.17 R1502.2 127.12,65.07 126.93,65.26 126.93,65.73 125.8,66.86 v1(125.37,66.86)
  BOTTOM w0.089: CPU1.CE29 124.3,66.87 125.36,66.87 v1(125.37,66.86)
  BOTTOM w0.102: v1(129.18,56.52) 129.18,55.92 v2(129.39,55.7) 129.44,55.65 R1503.1
NZ_VHIO: length 3.1
  TOP w0.254: U9101.14 202.37,38.47 v2(202.51,38.61) 202.53,38.64 203.45,38.64 203.93,39.12 R9139.1
P2800_VGA_DXN: length 2.2
  TOP w0.102: TP7903.1 188.36,75.92 188.36,77.3 v1(188.2,77.46)
  BOTTOM w0.102: v1(188.2,77.46) 188.23,77.5 GPU1.E12
P2800_VGA_DXP: length 1.1
  TOP w0.102: TP7904.1 187.69,79.23 v1(187.64,79.18)
  BOTTOM w0.089: GPU1.F12 v1(187.64,79.18)
PANEL_BKEN_EC: length 24.3
  TOP w0.102: v1(41.1,33.94) 41.02,34.02 41.02,35 41.18,35.17 U2401.117
  BOTTOM w0.102: D2401.1 23.54,37.16 v2(23.54,35.94) 23.54,35.54 24.51,34.57 25.9,34.57 25.93,34.6 26.21,34.6 26.23,34.57 26.52,34.57 27.99,33.1 29,33.1 30.3,31.8 31.59,31.8 32.05,32.26 32.86,32.26 34.94,34.34 40.69,34.34 v1(41.1,33.94)
PBAT_CHG_SMBCLK: length 157.2
  TOP w0.089: U2401.9 48.21,40.51 48.76,39.96 v1(48.76,39.75) 49.16,40.16 RN2402.3 ; RN4302.2 115.38,11.23 115.69,10.92 116.28,10.92 v1(116.38,10.82) v2(116.82,10.38) 116.82,8.42 117.05,8.19 117.05,5.32 D4306.3 116.79,4.29 EC4309.1 117.82,3.26 136.71,3.26 137.08,3.63 155.19,3.63 155.47,3.91 155.47,4.93 157.3,6.76 157.73,6.76 158.01,7.04 158.59,7.04 159.38,7.83 v1(159.38,8.08)
  L4 w0.114: v1(116.38,10.82) 116.03,11.17 110.9,11.17 109.5,9.76 96.65,9.76 96.29,9.4 94.38,9.4 92.75,7.78 88.36,7.78 86.96,6.38 85.97,6.38 84.96,5.36 63.04,5.36 61.44,6.96 61.44,9.63 59.48,11.59 57.82,11.59 57.08,12.32 55.21,12.32 54.67,12.86 54.67,14.3 55.02,14.64 55.02,15.08 51.02,19.08 51.02,25.17 50.21,25.99 50.21,26.77 49.39,27.59 49.39,34.83 48.15,36.08 48.15,38.73 48.76,39.35 v1(48.76,39.75)
  BOTTOM w0.089: v1(159.38,8.08) 159.38,8.31 159.69,8.62 PU4401.22
PBAT_CHG_SMBDAT: length 157.5
  TOP w0.089: v1(160.01,8.08) 158.69,6.76 158.11,6.76 157.83,6.48 157.39,6.48 155.75,4.83 155.75,3.76 155.35,3.37 137.21,3.37 136.82,2.97 117.42,2.97 v2(117.27,3.12) 116.25,4.15 116.25,5.41 116.75,5.91 116.75,8.1 115.3,9.56 D4305.3 114.9,9.56 114.32,10.14 v1(114.32,10.54) 114.37,10.49 EC4310.1 114.9,10.87 114.73,11.05 RN4302.1 ; U2401.8 47.8,40.11 48.23,39.68 48.23,39.55 48.18,39.51 v1(48.18,39.42) 48.3,39.3 49.02,39.3 49.22,39.5 RN2402.4
  L4 w0.114: v1(48.18,39.42) 47.82,39.06 47.82,38.93 47.75,38.86 47.75,35.94 48.98,34.71 48.98,34.05 49.02,34.01 49.02,33.66 48.94,33.58 48.94,25.38 49.55,24.77 49.55,19 49.65,18.9 49.65,18.23 54.07,13.81 54.07,12.91 54.27,12.7 54.27,12.68 54.96,11.99 54.99,11.99 55.04,11.94 56.92,11.94 57.65,11.2 59.33,11.2 61,9.53 61,9.45 61,9.45 61,6.86 62.88,4.98 87.93,4.98 90.34,7.39 92.91,7.39 94.53,9.02 96.44,9.02 96.79,9.38 109.65,9.38 109.67,9.4 109.72,9.4 111.12,10.8 114.07,10.8 v1(114.32,10.54)
  BOTTOM w0.089: v1(160.01,8.08) 160.01,8.09 160.09,8.17 PU4401.21
PBAT_PRES1#: length 10.1
  TOP w0.102: R4310.2 113.36,12.44 112.62,13.19 112.62,13.85 AFTP4309.1 112.82,14.05 v1(113.96,14.05)
  BOTTOM w0.102: v1(113.96,14.05) 114.85,14.94 117.47,14.94 118.88,16.35 BATT1.6
PBAT_PRES#: length 189.3
  TOP w0.102: v1(45.94,48.95) 46.38,48.51 U2401.29 47.59,48.51 47.71,48.63 47.81,48.73 47.81,48.74 47.97,48.9 50.19,48.9 50.67,49.37 R2415.2 ; v1(112.08,10.19) 112.03,10.24 D4304.3 111.93,11.49 EC4306.2 112.49,12.42 v1(112.59,12.32) 112.59,12.11 v2(113.02,11.69) 113.13,11.58 R4310.1
  L4 w0.102: v1(157.33,5.73) 156.69,5.73 156.18,5.21 154.93,5.21 154.6,4.88 154.07,4.88 153.13,3.94 131.67,3.94 130.19,5.41 129.03,5.41 126.77,7.67 126.77,11.66 125.37,13.06 118.12,13.06 116.81,11.75 116.81,10.64 116.56,10.39 115.89,10.39 115.59,10.09 112.19,10.09 v1(112.08,10.19) ; v1(36.62,40.08) 40.02,40.08 41.73,41.79 42.87,41.79 44.6,40.06 47.64,40.06 47.77,40.19 48.94,40.19 49.19,39.93 49.19,39.25 48.51,38.56 48.51,36.25 49.75,35 49.75,34.17 50.57,33.35 50.57,32.95 49.75,32.14 49.75,27.59 50.46,26.88 50.46,26.19 51.28,25.38 51.28,19.36 55.38,15.26 55.38,14.42 55.04,14.07 55.04,13.01 55.29,12.75 57.17,12.75 57.96,11.97 58.9,11.97 58.95,12.02 66.24,12.02 67.11,11.14 69.5,11.14 69.87,10.77 69.87,9.82 73.95,5.74 84.8,5.74 85.82,6.76 86.81,6.76 88.21,8.16 92.6,8.16 94.23,9.78 96.13,9.78 97.17,10.82 100.83,10.82 100.91,10.9 106.19,10.9 106.65,10.44 109.37,10.44 111.25,12.32 v1(112.59,12.32)
  L6 w0.102: v1(45.94,48.95) 45.73,48.74 44.76,48.74 44.42,48.4 43.91,48.4 43.6,48.08 43.6,46.25 40.39,43.04 38.99,43.04 36.67,40.72 36.67,40.13 v1(36.62,40.08)
  BOTTOM w0.102: PR4409.2 157.02,6.04 v1(157.33,5.73)
PBAT_SMBCLK1: length 8.5
  TOP w0.254: v1(117.14,13.95) AFTP4311.1 116.43,13.95 115.38,12.9 RN4302.3
  BOTTOM w0.254: v1(117.14,13.95) 118.56,13.95 120.31,15.7 120.69,15.7 121.39,16.39 BATT1.4
PBAT_SMBDAT1: length 8.8
  TOP w0.254: v1(115.62,14.05) 114.73,14.05 AFTP4310.1 114.57,13.26 114.73,13.1 RN4302.4
  BOTTOM w0.254: v1(115.62,14.05) 116.12,14.56 118.41,14.56 120.14,16.28 BATT1.5
PCH_BATLOW#: length 14.4
  TOP w0.102: R1722.2 119.37,50.98 119.37,51.64 119.58,51.84 119.85,51.84 120.09,52.08 120.09,52.78 R1723.1 119.65,53.51 v1(118.84,54.33)
  BOTTOM w0.076: CPU1.BV36 120.26,61.89 120.26,61.8 120.26,61.8 120.26,60.3 119.98,60.02 119.98,59.26 120.4,58.84 120.4,57.01 120.71,56.71 120.71,55.82 v2(119.7,54.82)
  BOTTOM w0.102: v2(119.7,54.82) 119.22,54.33 v1(118.84,54.33)
PCH_DPWROK: length 15.2
  TOP w0.102: v1(118.13,65.61) 118.54,65.2 118.54,64.67 117.72,63.86 117.72,61.65 116.66,60.58 116.66,57.1 118.1,55.65 118.1,54.23 118,54.13 v2(118,53.65) 118,52.78 R1704.2
  BOTTOM w0.102: CPU1.BP30 117.81,65.93 v1(118.13,65.61)
PCH_ESPI_CLK: length 16.3
  TOP w0.089: v1(120.8,64.36) 120.8,62.91 122.16,61.56 122.16,58.94 123.74,57.36 v2(123.74,53.57) 123.74,53.11 123.26,52.63 123.26,52.12 123.16,52.02 123.15,52.02 123.06,51.93 123.06,50.96 123.44,50.57 R1805.1
  BOTTOM w0.089: v1(120.8,64.36) 120.53,64.63 CPU1.BV32
PCH_ESPI_IO0: length 19.7
  TOP w0.089: v1(122.65,66.32) 122.6,66.32 122.07,65.79 122.07,65.17 122.64,64.6 122.64,63.44 125.01,61.07 v2(125.01,52.63) 125.13,52.52 125.13,51.16 126.41,49.88 RN1806.1
  BOTTOM w0.089: CPU1.CA29 v1(122.65,66.32)
PCH_ESPI_IO1: length 19.2
  TOP w0.089: v1(121.74,66.32) 121.72,66.3 121.72,65.02 122.28,64.45 122.28,63.47 122.27,63.45 122.27,63.3 124.5,61.06 124.5,52.89 124.48,52.86 124.48,51.34 v2(124.5,51.31) 124.5,50.73 125.32,49.91 RN1806.3
  BOTTOM w0.089: v1(121.74,66.32) CPU1.BY29
PCH_ESPI_IO2: length 20.9
  TOP w0.089: RN1806.2 125.82,49.94 v2(125.62,50.14) 124.86,50.91 124.86,51.67 124.66,51.87 124.66,52.78 124.7,52.83 124.7,61.13 122.46,63.37 122.46,64.53 121.89,65.09 121.89,65.91 122.14,66.15 122.14,67.19 v1(121.74,67.59)
  BOTTOM w0.089: CPU1.BY27 v1(121.74,67.59)
PCH_ESPI_IO3: length 21.6
  TOP w0.089: v1(120.8,67.61) 120.8,67.61 121.23,67.18 121.23,63.88 121.05,63.71 121.05,63.02 122.4,61.67 122.4,59.08 124.1,57.38 124.1,53.22 123.44,52.56 123.44,52.05 123.23,51.84 123.23,51.03 123.46,50.8 123.67,50.8 v2(124.38,50.09) 124.73,49.74 RN1806.4
  BOTTOM w0.089: CPU1.BV27 120.41,67.88 120.74,67.67 v1(120.8,67.61)
PCH_JTAG_TCK: length 3.1
  TOP w0.089: v1(95.14,80.5) 94.74,80.1 94.74,79.58 94.84,79.48 v2(94.84,79.17) R318.1
  BOTTOM w0.089: v1(95.14,80.5) CPU1.W6
PCH_JTAG_TDI: length 18.4
  L4 w0.089: v1(94.21,81.79) 94.21,82.56 93.38,83.4 89.76,83.4 89.45,83.09 86.61,83.09 85.82,83.87 85.15,83.87 v1(84.92,84.1)
  BOTTOM w0.089: R312.1 84,90.22 R9995.2 v2(84,88.55) 84,84.5 84.4,84.1 v1(84.92,84.1) ; v1(94.21,81.79) CPU1.U5
PCH_JTAG_TDO: length 19.3
  L4 w0.089: v1(95.15,81.18) 95.57,81.6 95.57,82.3 95.32,82.55 95.14,82.55 95.12,82.58 94.85,82.58 93.5,83.92 92.55,83.92 92.25,84.23 85.4,84.23 v1(84.85,84.78)
  BOTTOM w0.089: CPU1.W5 95.21,81.18 v1(95.15,81.18) ; v1(84.85,84.78) 84.99,84.91 v2(84.99,87.48) 84.99,88.71 84.82,88.89 R9994.2 84.94,89.61 R313.1
PCH_JTAG_TMS: length 11.2
  BOTTOM w0.089: R314.1 90.45,89.8 R9992.2 90.01,89.28 89.41,88.69 89.41,88.62 89.33,88.53 v2(89.33,88.52) 89.31,88.52 89.22,88.43 89.22,86.82 90.57,85.47 90.77,85.47 91.13,85.12 91.13,84.91 91.28,84.76 91.36,84.76 91.64,84.48 91.64,84.23 92.03,83.84 92.03,82.44 92.02,82.43 92.02,82.2 92.65,81.57 CPU1.P5
PCH_PLTRST#: length 53.1
  TOP w0.127: R1713.2 129.36,44.43 129.53,44.25 v2(129.53,43.03) v1(129.53,41.38)
  BOTTOM w0.127: CPU1.BJ35 114.81,62.64 114.81,61.78 115.59,61 115.59,60.35 115.56,60.33 115.56,57 115.15,56.58 115.15,55.24 113.66,53.75 110.84,53.75 109.47,52.38 109.47,49.96 112.68,46.75 112.68,46.26 113.08,45.87 113.48,45.87 113.77,46.16 113.77,47.57 112.94,48.4 112.94,49.7 113.2,49.97 113.55,49.97 113.84,49.69 113.84,49.12 114.51,48.44 115.82,48.44 116.55,47.7 116.55,46.61 118.7,44.47 120.37,44.47 122.75,42.09 124.05,42.09 125.39,40.75 128.91,40.75 v1(129.53,41.38)
PCH_POPIRCOMP: length 4
  TOP w0.508: v1(120.95,69.22) 120.96,69.21 120.96,69.03 121.38,68.61 v2(123.11,68.61) 124.02,68.61 R305.1
  BOTTOM w0.305: v1(120.95,69.22) 120.95,69.11 CPU1.BW25
PCH_RSMRST#: length 80.9
  TOP w0.127: U2401.27 47.68,47.71 TP2402.1 48.62,48.66 50.29,48.66 51.19,49.56 52.15,49.56 52.16,49.55 52.53,49.55 52.54,49.56 52.8,49.56 53.74,50.5 53.74,51.12 53.79,51.17 v1(53.79,51.36) ; 116.88,45.72 EC1712.1 115.73,46.17 115.06,46.17 114.45,45.56 114.45,45.19 113.79,44.53 110.69,44.53 106.08,39.92 101.05,39.92 100,38.86 79.48,38.86 73.59,44.76 v1(73.31,44.76)
  BOTTOM w0.127: v1(73.31,44.76) 71.42,46.64 71.42,46.94 70.66,47.69 68.71,47.69 68.43,47.41 61.74,47.41 59.94,49.22 59.94,49.26 58.91,50.29 58.85,50.29 58.46,50.68 57.32,50.68 56.75,51.25 53.91,51.25 v1(53.79,51.36)
PCH_SMBCLK: length 191.5
  TOP w0.089: RN1810.3 174.98,9.8 R6515.1 EC6505.1 173.68,9.38 v1(173.68,9.21)
  L3 w0.114: v1(149.34,75.67) 149.9,75.1 149.9,74.9 150.5,74.3 152.97,74.3 158.29,68.98 158.29,58.04 163.16,53.16 163.16,52.91 163.19,52.89 163.19,50.88 163.39,50.68 163.39,49.71 164.02,49.08 164.46,49.08 166.01,47.53 166.01,46.66 179.17,33.51 179.17,29.85 179.69,29.32 179.69,25.14 v1(179.29,24.74)
  L4 w0.089: v1(177.24,20.68) 177.24,21.74 178.78,23.29 178.78,24.39 179.14,24.74 v1(179.29,24.74)
  L6 w0.089: v1(98.04,24.55) 98.04,24.39 98.56,23.87 98.56,21.51 99.9,20.17 102.99,20.17 104.57,18.6 134.89,18.6 135.52,17.97 136.12,17.97 136.7,18.54 136.83,18.67 145.82,18.67 146.4,19.26 174.77,19.26 175.45,19.94 176.76,19.94 176.77,19.94 176.92,19.94 177.24,20.25 v1(177.24,20.68)
  BOTTOM w0.089: 177.26,20.7 177.26,20.7 177.69,20.28 v2(177.69,17.63) 177.69,17.43 177.13,16.88 175.95,16.88 175.94,16.87 175.71,16.87 175.28,16.44 175.06,16.44 174.57,15.94 174.57,14.62 175.04,14.14 175.49,14.14 175.74,13.9 175.74,13.54 174.44,12.23 174.44,9.96 v1(173.68,9.21) ; 177.26,20.7 v1(177.24,20.68) ; 177.26,20.7 177.16,20.81 177.16,21.71 175.91,22.96 174.7,22.96 173.89,23.77 DM2.253 ; v1(149.34,75.67) 148.02,74.35 145.87,74.35 145.63,74.59 Q1801.4 ; v1(98.04,24.55) 98.02,24.54 97.66,24.54 96.88,25.31 DM1.253
PCH_SMBDATA: length 186.5
  TOP w0.089: R6511.1 v1(177.44,7.24) ; v1(172.33,7.29) 172.97,7.93 v2(173.27,7.93) 173.45,7.93 173.93,8.41 173.93,8.66 174.02,8.75 RN1810.4
  L3 w0.114: v1(179.24,24.11) 178.85,24.49 178.85,25.04 179.32,25.51 179.32,29.16 178.78,29.7 178.78,33.16 169.88,42.07 168.98,42.07 168.17,42.88 168.17,43.69 165.63,46.23 165.63,47.37 164.31,48.69 163.88,48.69 162.99,49.59 162.99,50.55 162.81,50.73 162.81,52.73 162.78,52.76 162.78,53.01 157.91,57.89 157.91,57.99 157.84,58.05 157.84,68.9 152.83,73.91 150.37,73.91 149.52,74.76 149.52,74.84 v1(148.7,75.66)
  L4 w0.114: v1(174.01,12.12) 174.01,10.26 172.33,8.59 v1(172.33,7.29) ; v1(174.54,18.49) 176.22,18.49 177.17,19.45 177.17,19.88 177.95,20.65 177.95,21.92 179.24,23.22 v1(179.24,24.11)
  L6 w0.089: v1(98.05,23.77) 98.13,23.7 98.13,21.38 99.64,19.87 102.82,19.87 104.4,18.29 134.77,18.29 135.43,17.63 136.22,17.63 137.03,18.44 145.89,18.44 146.48,19.03 170.71,19.03 171.19,18.54 174.49,18.54 v1(174.54,18.49)
  BOTTOM w0.089: v1(98.05,23.77) 98.13,23.7 98.13,23.36 97.07,22.3 97.07,20.4 97.13,20.34 DM1.254 ; v1(177.44,7.24) 177.13,6.93 172.7,6.93 v1(172.33,7.29) ; Q1801.1 148.32,76.04 v1(148.7,75.66) ; DM2.254 174.14,18.9 v1(174.54,18.49) 174.85,18.19 175.34,18.19 175.66,17.87 EC6506.1 175.66,17.2 175.18,16.72 174.74,16.72 173.89,15.87 173.89,12.24 v1(174.01,12.12)
PCIE_RCOMPN: length 3.7
  TOP w0.305: R1604.1 125.77,79.66 124.86,80.57 v2(123.75,80.57) v1(123.75,81.23)
  BOTTOM w0.305: CPU1.CE6 123.92,81.23 v1(123.75,81.23)
PCIE_RCOMPP: length 3.2
  TOP w0.305: v1(123.78,81.87) 124.29,81.87 v2(124.73,81.43) 124.73,81.32 125.55,80.5 R1604.2
  BOTTOM w0.305: v1(123.78,81.87) 123.94,81.87 CPU1.CE5
PCIE_WAKE#: length 10.2
  TOP w0.102: U2401.4 47.59,38.51 48.71,37.39 R2406.2 50.06,37.77 50.46,38.18 54.27,38.18 54.91,38.81 v2(55.01,38.81) R2476.2
PCIE_WAKE#_CPU: length 18
  TOP w0.102: v1(119.91,65.68) 119.45,65.22 119.45,64.81 119.27,64.63 119.27,63.94 119.34,63.86 119.34,60.27 118.36,59.29 118.36,58.65 119.51,57.5 119.51,54.91 120.28,54.14 120.28,52 119.76,51.49 v2(119.73,51.49) 119.73,51.34 119.58,51.18 119.58,50.9 119.52,50.85 RN1704.4
  BOTTOM w0.102: v1(119.91,65.68) 119.67,65.93 CPU1.BU30
PD4403_A: length 6.6
  BOTTOM w0.102: PD4404.A 171.98,17.3 171.6,17.68 v2(171.55,17.68) 171.42,17.81 171.42,17.86 170.68,18.6 168.7,18.6 167.61,17.51 PQ4408.B
PD4403_K: length 78.2
  TOP w0.102: PR4477.1 172.18,14.79 v1(172.46,15.06) ; v1(118.05,12.09) 117.95,12.09 v2(117.41,12.63) 117.41,13.61 117.57,13.77 117.57,13.77 PR4466.1
  L4 w0.102: v1(172.46,15.06) 172.79,14.73 172.79,9.58 171.39,8.18 170.48,8.18 170.2,7.9 170.2,7.19 171.32,6.07 171.32,4.88 171.19,4.75 169.49,4.75 168.32,3.58 165.88,3.58 165.2,2.9 159.38,2.9 159,3.28 125.77,3.28 120.31,8.74 120.31,10.47 118.69,12.09 v1(118.05,12.09)
  BOTTOM w0.102: PD4404.K 174.26,17.27 172.46,15.47 v1(172.46,15.06)
PD_EE_WP_N: length 8
  BOTTOM w0.089: R7253.2 81.83,92.43 82,92.26 82,91.63 82,91.63 82,91.29 81.33,90.61 v2(79.36,90.61) 79.12,90.61 78.55,91.19 78.55,91.85 77.99,92.41 U7205.3
PD_HOLD_N: length 18.9
  BOTTOM w0.089: R7252.2 82.6,92.99 82.6,92.48 82.87,92.2 82.87,91.57 82.74,91.43 82.74,90.88 81.69,89.82 v2(81.43,89.82) 71.45,89.82 70.67,90.6 70.67,91.95 71.04,92.32 71.04,93.45 71.27,93.68 U7205.7
PD_OVP_TRIP_P1: length 22.2
  TOP w0.089: 73.75,98.88 73.88,99.01 74.76,99.01 U7204.E10
  TOP w0.102: R7246.2 83.81,102.57 v2(84.58,101.8) 84.65,101.72 v1(84.65,101.07) ; R7249.1 71.47,100.31 v1(72.11,100.31) 72.11,99.18 72.45,98.83 72.79,98.83 72.83,98.88 73.75,98.88
  L3 w0.102: v1(72.11,100.31) 72.31,100.51 74.19,100.51 74.42,100.28 78.78,100.28 79.09,100.59 80.94,100.59 81.51,101.15 81.51,102.17 81.78,102.44 82.19,102.44 83.56,101.07 v1(84.65,101.07)
PD_VBUS_C_CTRL1: length 70.3
  TOP w0.089: U7204.G10 74.75,100.02 74.15,100.02 73.13,101.03 v1(73.04,101.03)
  TOP w0.102: Q7406.5 30.19,81.82 30.32,81.95 30.36,81.99 30.36,82.76 29.85,83.26 27.03,83.26 v2(26.65,82.88) 26.06,82.88 v1(25.91,83.02)
  L3 w0.102: v1(73.04,101.03) 71.18,101.03 67.79,97.64 64.66,97.64 63.59,96.57 50.43,96.57 50.01,96.14 47.97,96.14 47.19,96.93 47.16,96.93 47.1,96.99 38.61,96.99 32.48,90.86 27.6,90.86 24.53,87.79 24.53,84.13 25.63,83.02 v1(25.91,83.02)
  BOTTOM w0.102: Q7405.2 25.29,82.4 v1(25.91,83.02)
PD_VBUS_C_CTRL1_A: length 11.2
  TOP w0.127: Q7404.3 28.25,79.66 29.12,78.8 29.12,78.43 28.85,78.17 28.49,78.17 28.21,78.44 28.21,78.55 27.49,79.28 26.77,79.28 26.56,79.49 26.56,79.76 26.46,79.86 26.46,82.25 26.21,82.5 25.7,82.5 25.41,82.8 v2(25.38,82.8) 25.35,82.83 25.35,83.29 v1(25.66,83.61)
  BOTTOM w0.127: v1(25.66,83.61) 25.1,83.05 Q7405.1
PD_VBUS_C_CTRL1_R: length 6
  BOTTOM w0.127: Q7405.6 22.31,83.05 R7408.1 22.88,82.4 Q7405.5 23.64,82.4 24.05,81.99 24.05,81.59 24.81,80.83 24.81,80.72 24.89,80.65 v2(24.89,80.6) 24.71,80.42 R7426.2
PD_VBUS_C_EN: length 14.9
  TOP w0.254: v1(22.3,83.75) 23.67,83.75 25.47,81.94 25.75,81.94 v1(25.83,81.87)
  BOTTOM w0.254: v1(25.83,81.87) 25.83,81.82 26.36,81.28 27.53,81.28 28.25,82.01 v2(28.25,82.36) 29.06,83.18 30.31,83.18 30.32,83.19 30.41,83.19 30.67,83.44 Q7407.3 ; R7427.2 22.6,84.05 v1(22.3,83.75) 22.12,83.75 21.76,83.39 21.76,83.16 R7422.1 21.38,83.04 21.38,83.77 21.82,84.21 U7419.A3
PD_VBUS_C_EN_A: length 21.1
  TOP w0.254: R7425.2 20.71,85.13 R7407.1 20.71,84.02 v2(21.51,83.23) 23.63,83.23 25.31,81.55 25.31,81.19 v1(25.26,81.14)
  BOTTOM w0.254: Q7405.3 24.95,81.45 v1(25.26,81.14) 25.44,80.96 25.44,80.47 24.25,79.28 24.25,78.77 24.76,78.26 26.18,78.26 26.54,78.62 27.5,78.62 28.8,79.91 29.34,79.91 29.76,80.34 29.76,80.77 29.71,80.83 ; Q7407.6 29.37,81.17 29.71,80.83 ; Q7407.5 30.02,81.13 29.71,80.83
PDB_R: length 6.7
  TOP w0.102: v1(27.1,13.67) 27.02,13.74 26,13.74 U2701.40
  BOTTOM w0.102: v2(31.46,14.99) 31.01,14.53 R2712.2 30.4,14.53 29.99,14.94 28.29,14.94 27.55,14.2 27.55,14.14 27.1,13.68 v1(27.1,13.67)
PECI_CPU: length 129.6
  TOP w0.102: v1(26.88,35.64) 27.05,35.47 R2437.2 ; v2(43.83,64.52) 43.5,64.19 v1(43.5,64.04)
  L3 w0.102: v1(31.69,57.23) 31.69,56.54 29.99,54.84 29.7,54.84 29.1,54.24 29.1,53.26 29.36,53 29.36,50.24 28.68,49.57 28.68,47.31 28.29,46.92 28.29,44.78 28.44,44.63 28.44,40.24 27.96,39.75 27.96,36.61 26.99,35.64 v1(26.88,35.64) ; v1(43.5,64.04) 42.64,64.9 42.64,66.88 41.29,68.23 41.29,70.03 42.16,70.89 42.16,71.91 43.63,73.38 43.63,74.32 44.47,75.16 44.47,77.37 45.79,78.69 45.79,79.63 46.91,80.75 46.91,84.48 50.67,88.24 56.03,88.24 56.36,88.57 59.25,88.57 59.79,88.04 68.1,88.04 68.91,88.85 94.14,88.85 96.62,86.37 100.38,86.37 101.92,87.91 103,87.91 104.77,86.15 104.77,85.78 v1(105.68,84.87)
  L4 w0.102: v1(43.5,64.04) 43.5,63.85 43.33,63.68 43.33,63.66 42.62,62.94 42.59,62.94 42.11,62.46 37.71,62.46 37.59,62.33 37.18,62.33 36.04,61.19 36.04,60.68 35.96,60.61 35.96,59.66 34.47,58.17 32.76,58.17 31.83,57.23 v1(31.69,57.23)
  BOTTOM w0.102: CPU1.AR1 105.83,84.73 v1(105.68,84.87)
PEX_PLLVDD: length 12.1
  L6 w1.016: v1(179.93,105.54) 180.74,104.73 180.74,102.29 180.18,101.73 180.18,100.61 179.11,99.55 179.11,95.66
  BOTTOM w0.356: GPU1.AA14 179.95,89.19 v1(179.98,89.23) 180.53,89.23 GPU1.AA15
  vias: v1(179.42,94.41) v2(178.12,93.32)
PEX_SVDD: length 14.6
  L3 w0.381: v1(177.54,95.99) 177.54,95.94 177.57,95.91 177.57,95.37 175.47,93.27 175.47,92.92 175.37,92.83 175.37,92.32 176.5,91.19 176.5,90.05 173.59,87.14 173.59,86.64 173.92,86.31 174.67,86.31 v1(175.28,85.71)
  BOTTOM w0.305: GPU1.AB8 175.28,85.7 v1(175.28,85.71)
  vias: v2(179.04,97.44)
PEX_TERMP: length 5.1
  BOTTOM w0.102: 183.52,97.94 182.97,97.94 180.41,100.49 v2(180.41,100.54) 180.41,100.59 R7601.1
PEX_TSTCLK_OUT: length 5.7
  TOP w0.089: R7605.1 184.5,96.6 183.69,96.6 182.95,97.34 v2(182.95,97.46) 182.75,97.46 182.44,97.77 181.48,97.77 v1(181.07,97.36)
  BOTTOM w0.089: v1(181.07,97.36) 181.76,96.68 GPU1.AF22
PEX_TSTCLK_OUT#: length 8.4
  TOP w0.089: v1(180.38,97.34) 180.38,97.39 181.25,98.25 184.09,98.25 v2(184.37,97.97) 184.4,97.97 R7605.2
  BOTTOM w0.089: v1(180.38,97.34) 180.38,97.03 181.81,95.6 GPU1.AE22
PIRQA#: length 112.6
  TOP w0.102: R9152.2 197.96,40.03 199.28,40.03 v1(199.43,39.88) ; R2053.2 137.36,52.99 v2(137.36,53.7) 137.94,53.7 v1(137.97,53.67)
  L6 w0.102: v1(198.32,32.13) 198.07,31.88 195.66,31.88 193.06,34.49 193.06,35.36 191.81,36.6 191.79,36.6 191.23,37.16 184.86,37.16 184.3,36.6 180.72,36.6 180.69,36.58 180.54,36.58 176.17,40.95 169.82,40.95 169.36,40.49 168.04,40.49 167.33,39.78 157.74,39.78 155.86,41.66 149.55,41.66 148.25,40.36 141.42,40.36 139.4,42.38 139.4,42.92 140,43.51 140,46.36 139.4,46.95 139.4,51.81 137.97,53.24 v1(137.97,53.67) 137.94,53.7 137.94,54.58 137.22,55.3 129.38,55.3 125.94,58.74 125.94,61.91 123.56,64.3 v1(123.53,64.3)
  BOTTOM w0.089: v1(123.53,64.3) 123.48,64.45 CPU1.CC32
  BOTTOM w0.102: v1(198.32,32.13) 198.32,34.01 198.44,34.14 198.44,38.97 199.36,39.88 v1(199.43,39.88)
PLT_RST#: length 474.1
  TOP w0.102: R2616.1 21.43,45.9 v1(21.25,46.08) ; v1(201.7,55.3) 202.38,55.98 203.57,55.98 204.9,57.31 AFTP6108.1 204.9,58.45 205.45,59.01 v1(205.56,59.01) ; C1701.1 131.26,44.83 R1715.1 131.26,43.55 ED1701.1 131.91,41.86 131,41.86 130.68,41.54 130.68,41.3 122.83,33.45 70.02,33.45 67.66,35.82 66.67,35.82 66.43,35.58 65.02,34.17 64.23,34.17 61.67,36.74 61.67,37.82 61.79,37.94 61.79,38.63 61.31,39.1 59.67,39.1 58.36,37.8 v1(55.16,37.8) ; C1701.1 131.13,45.7 131.49,46.05 131.54,46.05 131.64,46.15 v1(131.64,46.18) ; C1701.1 130.42,44.96 R1713.1 ; R6308.1 v1(218.18,7.37) ; R9110.1 199.1,38.86 v1(198.97,38.73)
  L3 w0.102: v1(216.61,36.82) 217.52,35.91 217.52,31.37 217.34,31.19 217.34,29.98 216.4,29.04 216.4,28.02 216.61,27.82 216.61,25.25 218.12,23.74 218.12,22.77 216.4,21.06 216.4,15.64 218.66,13.38 218.66,7.85 v1(218.18,7.37)
  L4 w0.102: v1(216.61,36.82) 216.14,37.29 216.14,39.77 217.85,41.49 217.85,47.06 217,47.91 v1(216.94,47.91) 218,48.97 219.25,48.97 221.81,51.54 221.81,57.79 221.66,57.94 221.66,61.67 v1(222.17,62.18) 223.51,63.53 223.51,99.6 217.06,106.05 214.22,106.05 214.06,106.2 196.87,106.2 194.63,108.44 188.23,108.44 v1(187.67,107.88) ; v1(55.16,37.8) 53.16,39.8 53.16,41.51 49.47,45.19 49.22,45.19 48.97,45.44 48.97,45.7 48.2,46.46 47.77,46.46 47.75,46.48 47.49,46.48 47.47,46.46 46.93,46.46 46.6,46.13 44.67,46.13 44.34,46.46 44.03,46.46 43.3,47.2 41.98,47.2 40.79,48.39 39.62,48.39 39.34,48.67 36.7,48.67 36.49,48.87 36.49,48.9 35.06,50.33 34.67,50.33 34.42,50.08 34.42,50.05 33.25,48.88 31.66,48.88 28.62,51.92 25.7,51.92 25.22,51.44 23.54,51.44 23.21,51.11 22.68,51.11 20.29,48.72 20.29,47.04 v1(21.25,46.08) ; v1(205.56,59.01) 205.56,59.11 206.62,60.17 212.47,60.17 212.72,59.92 212.72,58.95 212.52,58.75 212.52,57.05 211.93,56.47 210.23,56.47 207.54,53.78 207.54,51.67 206.52,50.65 206.52,47.54 203.3,44.33 202.81,44.33 198.97,40.48 v1(198.97,38.73)
  L6 w0.102: v1(148.2,46.1) 148.2,45.47 151.05,42.62 158.24,42.62 160.14,40.72 167.16,40.72 168.45,42.01 176.33,42.01 179.63,38.71 182.42,38.71 182.95,38.18 191.39,38.18 194.41,35.16 194.41,34.67 194.92,34.16 v1(194.92,34.01) ; v1(205.56,59.01) 205.56,59.01 205.65,59.1 209.66,59.1 210.36,58.4 212.85,58.4 214.04,59.59 219.58,59.59 v1(222.17,62.18) ; v1(162.74,86.33) 162.83,86.43 162.83,87.76 167.46,92.38 167.46,96.75 166.72,97.49 166.72,99.83 167.05,100.15 167.79,100.15 168.42,99.52 172.18,99.52 173.12,100.46 173.12,101.02 178.48,106.38 186.18,106.38 v1(187.67,107.88)
  BOTTOM w0.102: v1(216.94,47.91) 217.28,48.25 IOBD1.10 ; v1(131.64,46.18) 136.04,46.18 136.83,45.39 141.42,45.39 142.13,46.1 v1(148.2,46.1) ; U7601.2 160.83,84.46 162.47,86.11 162.52,86.11 v1(162.74,86.33) ; WLAN1.52 200.96,54.57 v1(201.7,55.3) ; v1(198.97,38.73) 198.83,38.59 198.83,32.34 198.75,32.26 198.75,31.78 198.65,31.68 197.17,31.68 194.92,33.93 v1(194.92,34.01)
PLT_RST#_Q_TPM: length 2.8
  TOP w0.102: R9110.2 199.94,38.15 v2(199.94,37.95) 200.17,37.72 200.17,37.06 200.35,36.88 U9101.17
PM_LAN_ENABLE: length 190.3
  TOP w0.102: R2491.1 51.33,37.34 v2(51.45,37.34) 52.17,37.34 v1(52.24,37.26) ; v1(215.16,39.91) 215.16,40.19 217.09,42.12 R6602.2
  L6 w0.102: v1(215.16,39.91) 213.56,39.91 210.79,37.14 209,37.14 207.43,38.71 202.36,38.71 198.37,42.7 185.52,42.7 184.53,43.69 184.52,43.69 183.29,44.92 183.29,46.17 183.29,47.68 182.23,48.75 179.32,48.75 v1(178.02,50.04)
  BOTTOM w0.102: v1(178.02,50.04) 172.64,44.66 172.64,37.09 171.49,35.94 169.97,35.94 167.32,33.3 154.35,33.3 153.6,32.54 70.66,32.54 67.43,35.77 58.74,35.77 57.5,37.01 56.41,37.01 55.8,36.4 54.44,36.4 53.58,37.26 v1(52.24,37.26)
PM_LAN_ENABLE_R: length 10.1
  TOP w0.102: R6602.1 R6601.1 218.08,43.67 217.49,44.25 v2(217.49,44.8) 217.49,47.2 218.33,48.03 218.33,49.59 v1(218.99,50.25)
  BOTTOM w0.102: v1(218.99,50.25) IOBD1.6
PM_PCH_PWROK: length 15.4
  TOP w0.102: R1706.2 117,53.1 RN1703.3 116.51,53.8 117.04,54.33 117.39,54.33 117.72,54.66 117.72,55.5 116.45,56.77 116.45,60.66 117.47,61.67 117.47,64.37 v2(117.65,64.54) 118.05,64.95 v1(118.1,64.95)
  BOTTOM w0.102: CPU1.BP31 117.77,65.28 v1(118.1,64.95)
PM_RSMRST#: length 25
  TOP w0.102: RN1703.4 115.84,53.85 116.96,54.97 v1(117.32,54.97) ; R1704.1 v1(118.87,51.06) 118.76,51.06 118.09,50.38 118.09,48.75 118.03,48.69 118.03,47.93 v2(118.1,47.86) 118.03,47.78 118.03,46 R1702.1 117.29,45.27 117.29,45.1 Q1701.3 117.76,44.72 118.15,44.33 Q1702.2
  BOTTOM w0.076: 117.86,57.38 118.05,57.57 118.05,59.08 118.46,59.49 118.46,60.33 118.17,60.62 118.17,61.07 118.58,61.49 118.58,61.76 118.55,61.82 118.5,61.87 118.5,61.87 118.45,61.92 118.33,62.17 CPU1.BR36
  BOTTOM w0.102: 117.86,57.38 117.37,56.89 TP1707.1 117.37,55.02 v1(117.32,54.97) 117.32,52.61 v1(118.87,51.06)
PM_RSMRST#_M: length 3.5
  TOP w0.127: Q1702.6 120.63,44.98 120.75,44.86 121.15,44.86 v2(121.33,44.68) ; v2(121.33,44.68) 120.97,44.33 Q1702.5 ; v2(121.33,44.68) 121.33,43.87 R1737.2
PM_SLP_S0#: length 240.6
  TOP w0.102: v1(160.52,72.5) 160.47,72.44 160.27,72.24 157.12,72.24 156.66,71.78 152.55,71.78 149.68,68.91 147.92,68.91 147.9,68.89 147.47,68.89 147.03,68.46 147.03,67.55 145.73,66.25 145.44,66.25 142.62,66.25 141.73,65.36 133.63,65.36 v1(133.55,65.44) ; R2476.1 57.4,38.81 v1(57.65,38.56) ; R9121.2 209.19,31.45 209.19,31.65 v1(209.24,31.7) 209.8,31.7 R1724.2
  L3 w0.102: v1(160.52,72.5) 160.52,71.71 161.06,71.17 161.06,64.85 165.68,60.23 165.68,59.36 166.46,58.58 168.73,58.58 170.33,56.97 170.33,52.61 v1(170.1,52.38)
  L4 w0.102: v1(50.36,55.07) 50.64,55.35 51.99,55.35 55.59,51.74 55.59,49.96 56.41,49.15 56.41,44.91 56.42,44.89 56.42,43.06 56.84,42.65 56.84,41.78 57.65,40.97 v1(57.65,38.56) ; v1(209.24,31.7) 209.24,31.75 209.37,31.88 209.37,32.93 206.19,36.11 206.19,37.52 v1(206.55,37.87)
  L6 w0.102: v1(170.1,52.38) 172.51,52.38 181.76,43.13 184.27,43.13 185.29,42.12 198.14,42.12 199.94,40.31 199.94,39.17 200.98,38.13 206.29,38.13 v1(206.55,37.87) ; v1(114.75,59.98) 114.9,60.14 114.9,67.85 115.13,68.07 116.4,68.07 116.81,67.67 117.32,67.67 117.88,68.23 123.25,68.23 124.63,69.61 124.63,69.77 124.87,70.01 126.58,70.01 126.93,69.65 126.93,69.36 130.25,66.04 133,66.04 133.55,65.5 v1(133.55,65.44)
  BOTTOM w0.102: R4018.1 160.83,72.8 v1(160.52,72.5) ; CPU1.BJ37 114.75,61.4 v1(114.75,59.98) 114.75,59.11 115.19,58.67 TP9956.1 115.19,56.92 114.93,56.66 114.93,55.31 114.61,54.99 TP1709.1 111.63,54.08 110.73,54.08 107.81,51.16 86.91,51.16 83.93,54.14 72.55,54.14 71.34,55.35 70.91,55.35 70.4,54.84 63.3,54.84 63.19,54.95 63.19,57.22 62.46,57.95 59.54,57.95 57.37,55.78 55.59,55.78 54.88,55.07 v1(50.36,55.07)
