# Allegro board 17859-1.0710WZS1337.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB2_USB30_RX_P: length 162.3
  L6 w0.089: v1(22.98,44.23) 22.98,43.99 23.12,43.85 23.99,43.85 24.26,44.13 24.26,47.61 23.84,48.03 23.35,48.03 22.42,48.96 22.42,54.54 25.44,57.56 25.44,59.9 25.9,60.35 25.9,64.31 24.12,66.08 24.12,71.71 24.45,72.04 24.45,78.05 27.63,81.22 27.63,81.43 32.27,86.07 33.41,86.07 34.97,87.63 36.85,87.63 38.63,89.41 46.6,89.41 49,91.81 53.74,91.81 54.51,92.59 62.81,92.59 64.56,90.83 69.72,90.83 71.09,89.46 79.55,89.46 79.75,89.26 94.49,89.26 96.87,91.63 103.63,91.63 104.09,91.18 105.11,91.18 106.45,89.84 106.45,83.64 108.02,82.07 108.02,78.62 109.02,77.61 115.84,77.61 116.83,78.6 121.35,78.6 121.55,78.8 121.55,79.03 121.32,79.26 v1(120.99,79.26)
  BOTTOM w0.102: 22.35,43.92 21.39,43.92 20.94,43.47 20.41,43.47 19.98,43.89 R3521.1 ; 22.35,43.92 22.88,43.92 22.98,44.02 v1(22.98,44.23) ; 22.35,43.92 v2(22.35,44.1) ; CPU1.BY9 121.28,78.97 v1(120.99,79.26)
USB2_USB30_TX_CMC_N: length 1
  BOTTOM w0.102: R3533.1 19.54,44.7 20.43,44.7 C3514.2
USB2_USB30_TX_CMC_P: length 1
  BOTTOM w0.102: C3520.2 20.45,45.38 19.54,45.38 R3524.1
USB2_USB30_TX_CON_N: length 9.4
  BOTTOM w0.102: USB4.8 11.05,47.55 12.07,47.55 14.67,44.95 14.66,44.95 14.73,44.89 15.87,44.89 16.01,44.75 ED3504.4 ED3504.7 18.54,44.75 R3533.2
USB2_USB30_TX_CON_P: length 10.1
  BOTTOM w0.102: R3524.2 18.47,45.25 ED3504.6 ED3504.5 16.01,45.25 15.87,45.11 14.83,45.11 12.16,47.78 11.55,47.78 10.65,48.68 USB4.9
USB2_USB30_TX_N: length 162.1
  L6 w0.089: v1(110.05,91.22) 109.84,91.44 108.26,91.44 106.37,93.32 105.07,93.32 104.06,94.34 96.06,94.34 95.52,93.8 75.2,93.8 74.59,94.41 67.72,94.41 66.74,95.39 63.75,95.39 63.47,95.11 53.98,95.11 52.86,93.99 47.06,93.99 46.06,92.99 46.05,92.99 45.88,92.83 42.64,92.83 41.49,91.67 33.24,91.67 31.81,90.24 31.81,90.06 29.89,88.14 29.89,88.01 29.41,87.53 29.41,87.34 26.95,84.88 25.12,84.88 24.87,84.63 24.87,82.92 20.72,78.76 17.86,78.76 16.94,77.84 16.94,74.41 20.21,71.14 20.21,68.15 19.04,66.98 19.04,66.14 18.51,65.61 18.51,56.71 21.44,53.78 21.44,48.44 22.1,47.79 22.1,47.02 v1(22.44,46.69)
  BOTTOM w0.102: 22.12,45.44 22.12,45.15 21.88,44.91 21.69,44.91 C3514.1 ; 22.12,45.44 v2(22.27,45.44) ; 22.12,45.44 22.12,46.37 v1(22.44,46.69) ; CPU1.CA2 121.6,83.8 121.33,84.07 121.33,86.78 121.7,87.15 121.7,91.13 120.16,92.66 113.73,92.66 112.94,91.87 110.89,91.87 110.53,91.52 110.36,91.52 v1(110.05,91.22)
USB2_USB30_TX_P: length 161.5
  L6 w0.089: v1(110.04,91.92) 109.74,91.63 108.33,91.63 106.45,93.51 105.15,93.51 104.14,94.53 95.98,94.53 95.44,94 75.28,94 74.67,94.61 67.8,94.61 66.82,95.58 63.67,95.58 63.39,95.3 53.9,95.3 52.78,94.18 46.98,94.18 45.98,93.18 45.97,93.18 45.81,93.02 42.56,93.02 41.41,91.86 33.16,91.86 33.15,91.85 33.14,91.85 31.62,90.33 31.62,90.14 29.7,88.22 29.7,88.09 29.22,87.61 29.22,87.42 26.87,85.07 25.04,85.07 24.68,84.71 24.68,82.99 20.64,78.95 17.78,78.95 16.75,77.92 16.75,74.34 20.02,71.06 20.02,68.23 18.85,67.06 18.85,66.22 18.32,65.69 18.32,56.63 21.25,53.7 21.25,48.36 21.91,47.71 21.91,47.02 v1(21.57,46.69)
  BOTTOM w0.102: C3520.1 21.69,45.14 21.79,45.14 21.89,45.24 21.89,46.37 v1(21.57,46.69) ; CPU1.CA1 121.55,84.31 121.55,86.69 121.93,87.06 121.93,91.22 120.26,92.89 113.63,92.89 112.85,92.1 110.8,92.1 110.44,91.75 110.21,91.75 v1(110.04,91.92)
USB2_VBUSSENSE: length 16.7
  L6 w0.102: v1(132.57,86.71) 132.05,87.23 130.93,87.23 130.61,87.54 126.55,87.54 123.27,84.27 123.27,81.55 v1(122.85,81.14)
  BOTTOM w0.089: v1(122.85,81.14) CPU1.CC6
  BOTTOM w0.102: RN1602.1 133.09,87.68 v2(132.73,87.33) 132.57,87.16 v1(132.57,86.71)
USB3_USB20_N: length 130.9
  TOP w0.102: v2(205.43,42.37) 205.91,42.37 v1(205.99,42.3)
  L6 w0.089: v1(127.77,86.57) 127.77,86.31 127.68,86.22 127.42,86.22 127.3,86.1 127.3,85.8 127.6,85.5 128.52,85.5 129.1,86.08 132.71,86.08 137.17,81.63 140.7,81.63 140.86,81.46 144.82,81.46 146.22,80.06 146.22,78.76 148.52,76.46 153,76.46 154.05,75.42 154.05,73.39 158.78,68.65 158.78,61.12 164.26,55.64 176.46,55.64 178.28,57.46 191.08,57.46 193.8,54.74 195.37,54.74 198.34,51.77 198.34,50.12 199.33,49.13 199.33,47.12 200.35,46.1 200.35,43.77 202.48,41.63 204.72,41.63 204.85,41.76 206.12,41.76 206.2,41.85 206.2,42.21 206.12,42.3 v1(205.99,42.3)
  BOTTOM w0.076: 125.61,84.89 125.6,84.88 125.56,84.88 125.1,84.41 125.1,84.19 125.13,84.08 125.13,83.86 125.1,83.68 125.1,83.51 125.14,83.42 125.18,83.38 125.26,83.31 CPU1.CG3
  BOTTOM w0.102: v1(127.77,86.57) 127.69,86.57 127.4,86.28 127.4,86.12 126.76,85.47 126.19,85.47 125.61,84.89 ; IOBD1.21 217.32,42.75 217.18,42.89 216.71,42.89 213.94,40.11 208.1,40.11 206.35,41.86 206.1,41.86 205.99,41.97 v1(205.99,42.3)
USB3_USB20_P: length 131
  TOP w0.102: v2(206.5,42.98) 206.5,42.45 v1(206.62,42.32)
  L6 w0.089: v1(127.11,86.57) 127.11,85.72 127.47,85.36 127.52,85.31 128.6,85.31 129.18,85.89 132.63,85.89 137.09,81.44 140.62,81.44 140.78,81.27 144.74,81.27 146.03,79.98 146.03,78.68 148.44,76.27 152.92,76.27 153.85,75.34 153.85,73.31 158.59,68.57 158.59,61.04 164.18,55.45 176.54,55.45 178.36,57.27 191,57.27 193.72,54.55 195.29,54.55 198.15,51.69 198.15,50.04 199.14,49.05 199.14,47.04 200.16,46.02 200.16,43.69 202.4,41.44 204.8,41.44 204.92,41.57 206.19,41.57 206.39,41.77 206.39,42.09 v1(206.62,42.32)
  BOTTOM w0.076: 125.45,85.05 125.44,85.04 125.44,85 124.92,84.49 124.92,84.16 124.95,84.05 124.95,83.87 124.92,83.72 124.92,83.47 124.98,83.33 125.1,83.21 125.1,82.82 125.14,82.77 CPU1.CG4
  BOTTOM w0.102: IOBD1.20 217.32,43.25 217.18,43.11 216.62,43.11 213.84,40.34 208.19,40.34 206.62,41.91 v1(206.62,42.32) ; 125.45,85.05 126.1,85.7 126.66,85.7 127.17,86.21 127.17,86.51 v1(127.11,86.57)
USB4_USB20_N: length 76.7
  TOP w0.089: 77.74,101.98 77.74,101.94 77.75,101.93 77.75,101.51 U7204.K5
  TOP w0.102: v1(77.68,102.88) 77.62,102.83 77.62,102.68 77.74,102.56 77.74,101.98
  L4 w0.102: v1(125.24,87.63) 125.13,87.52 124.79,87.52 124.69,87.62 124.69,88.04 124.59,88.15 124.38,88.15 124.05,88.48 124.05,89.34 124.17,89.47 124.17,89.99 123.01,91.16 118.55,91.16 117,92.72 116.19,92.72 115.97,92.94 115.97,93.75 115.76,93.96 114.67,93.96 114.56,93.84 114.56,93.15 114.32,92.92 113.98,92.92 113.74,93.15 113.74,93.84 113.62,93.96 113.46,93.96 113.34,93.84 113.34,93.15 113.1,92.92 112.76,92.92 112.52,93.15 112.52,93.84 112.4,93.96 110.98,93.96 110.11,94.83 109.94,94.83 108.94,93.83 108.61,93.83 108.37,94.07 108.37,94.4 109.37,95.41 109.37,95.57 108.7,96.24 107.69,96.24 107.59,96.35 106.87,96.35 106.63,96.58 106.63,97.67 106.53,97.77 106.37,97.77 106.22,97.62 106.22,96.58 105.99,96.35 105.65,96.35 105.41,96.58 105.41,97.64 105.29,97.76 105.15,97.76 105.01,97.62 105.01,96.58 104.67,96.24 90.59,96.24 89.34,97.49 85.44,97.49 84.65,98.28 84.07,98.28 82.98,99.37 82.98,100.03 80.41,102.59 79.25,102.59 78.17,103.67 77.86,103.67 77.73,103.53 77.73,103.41 77.95,103.18 77.95,102.95 77.88,102.88 v1(77.68,102.88)
  BOTTOM w0.083: CPU1.CD3 123.47,83.45 123.55,83.53 123.55,85.54 124.42,86.4 124.45,86.4 124.46,86.41
  BOTTOM w0.102: v1(125.24,87.63) 125.24,87.81 125.02,88.03 124.9,88.03 124.73,87.86 124.73,87.12 ; 124.46,86.41 124.73,86.69 124.73,87.12 ; v2(124.89,87.12) 124.73,87.12
USB4_USB20_P: length 76.6
  TOP w0.102: v1(77.18,103.28) 77.27,103.19 77.27,102.71 77.51,102.48 U7204.L5
  L4 w0.102: v1(77.18,103.28) 77.78,103.87 78.26,103.87 79.33,102.8 80.5,102.8 83.18,100.11 83.18,99.45 84.15,98.48 84.74,98.48 85.52,97.69 89.42,97.69 90.67,96.45 104.58,96.45 104.8,96.67 104.8,97.71 105.06,97.97 105.37,97.97 105.62,97.73 105.62,96.67 105.73,96.55 105.9,96.55 106.02,96.67 106.02,97.71 106.29,97.97 106.61,97.97 106.83,97.75 106.83,96.67 106.95,96.55 107.67,96.55 107.77,96.45 108.78,96.45 109.57,95.66 109.57,95.32 108.57,94.32 108.57,94.15 108.69,94.03 108.86,94.03 109.86,95.03 110.2,95.03 111.07,94.16 112.49,94.16 112.73,93.92 112.73,93.24 112.85,93.12 113.01,93.12 113.13,93.24 113.13,93.92 113.37,94.16 113.71,94.16 113.95,93.92 113.95,93.24 114.07,93.12 114.23,93.12 114.35,93.24 114.35,93.92 114.59,94.16 115.84,94.16 116.17,93.83 116.17,93.03 116.28,92.92 117.08,92.92 118.64,91.37 123.09,91.37 124.38,90.08 124.38,89.39 124.25,89.26 124.25,88.56 124.46,88.35 v1(125.28,88.35)
  BOTTOM w0.083: 124.3,86.58 124.29,86.56 124.29,86.53 123.37,85.62 123.37,83.6 123.21,83.44 123.21,83.14 123.47,82.87 CPU1.CD4
  BOTTOM w0.102: v1(125.28,88.35) 125.19,88.26 124.81,88.26 124.5,87.96 124.5,86.78 124.3,86.58
USB4_USB30_RX_C_N: length 6
  TOP w0.102: C7306.2 20.61,67.71 20.61,67.89 20.85,68.13 21.66,68.13 21.76,68.23 21.76,69.43 22.09,69.76 22.09,70.34 22.51,70.76 23.22,70.76 23.31,70.84 U7301.4
USB4_USB30_RX_C_P: length 5.8
  TOP w0.102: v2(22.27,69.4) 22.16,69.51 ; 22.16,69.51 21.99,69.34 21.99,68.13 21.76,67.9 20.94,67.9 20.84,67.8 20.84,67.65 C7305.2 ; 22.16,69.51 22.32,69.67 22.32,70.24 22.61,70.53 23.22,70.53 23.31,70.45 U7301.5
USB4_USB30_RX_N: length 131.7
  TOP w0.102: 21.81,66.12 21.81,65.95 21.58,65.71 20.82,65.71 20.58,65.95 20.58,66.23 C7306.1 ; 21.81,66.12 v2(21.97,66.12) ; 21.81,66.12 21.81,66.53 21.91,66.63 22.26,66.63 v1(22.42,66.46)
  L6 w0.089: v1(120.96,80.61) 120.75,80.85 120.57,81.1 120.57,82.17 120.23,82.51 108.59,82.51 106.88,84.23 106.88,90.2 105.51,91.57 104.31,91.57 103.83,92.05 95.57,92.05 93.76,90.24 76.24,90.24 75.25,91.23 64.85,91.23 63.1,92.98 54.33,92.98 53.57,92.23 48.86,92.23 46.45,89.82 38.47,89.82 36.67,88.03 34.81,88.03 33.24,86.46 32.11,86.46 27.22,81.58 27.22,81.38 25.52,79.68 24.84,79.68 23.88,78.73 23.88,74.19 23.1,73.41 23.1,72.61 23.63,72.08 23.63,66.93 23.23,66.53 22.78,66.53 22.71,66.46 v1(22.42,66.46)
  BOTTOM w0.102: v1(120.96,80.61) 120.85,80.61 CPU1.BW6
USB4_USB30_RX_P: length 131.7
  TOP w0.102: v1(22.42,67.33) 22.42,67.06 22.22,66.86 21.82,66.86 21.58,66.62 21.58,66.04 21.48,65.94 20.91,65.94 20.81,66.04 20.81,66.23 C7305.1
  L6 w0.089: v1(22.42,67.33) 22.79,67.33 22.88,67.24 22.88,66.8 22.97,66.72 23.15,66.72 23.44,67.01 23.44,72 22.9,72.53 22.9,73.48 23.69,74.27 23.69,78.81 24.76,79.87 25.44,79.87 27.03,81.46 27.03,81.65 32.03,86.65 33.16,86.65 34.73,88.22 36.6,88.22 38.39,90.01 46.37,90.01 48.78,92.42 53.49,92.42 54.25,93.17 63.18,93.17 64.93,91.42 75.33,91.42 76.32,90.43 93.69,90.43 95.5,92.24 103.91,92.24 104.39,91.76 105.58,91.76 107.07,90.28 107.07,84.31 108.67,82.71 120.3,82.71 120.76,82.25 120.76,81.35 120.85,81.26 v1(121,81.26)
  BOTTOM w0.102: CPU1.BW5 120.85,81.26 v1(121,81.26)
USB4_USB30_TX_C_N: length 2.8
  TOP w0.102: U7301.7 23.48,69.65 23.4,69.56 23.1,69.56 22.86,69.32 22.86,68.89 23.24,68.51 23.24,68 C7304.2
USB4_USB30_TX_C_P: length 2.5
  TOP w0.102: U7301.8 23.49,69.24 23.4,69.33 23.2,69.33 23.09,69.23 23.09,68.98 23.46,68.61 23.46,68.1 23.72,67.85 C7303.2
USB4_USB30_TX_N: length 136.9
  TOP w0.102: 22.63,64.93 22.63,65.31 22.98,65.66 23.16,65.66 23.39,65.89 23.39,66.3 23.29,66.4 23.29,66.73 C7304.1 ; 22.63,64.93 v1(22.63,64.18) ; 22.63,64.93 v2(22.45,64.93)
  L6 w0.089: v1(111.36,91.42) 111.26,91.32 110.82,91.32 110.05,90.54 108.48,90.54 106.09,92.93 104.89,92.93 104.37,93.45 99.98,93.45 99.54,93.89 96.23,93.89 95.75,93.41 75.03,93.41 74.42,94.02 67.55,94.02 66.57,95 63.93,95 63.65,94.72 54.14,94.72 53.02,93.6 47.35,93.6 46.09,92.34 42.93,92.34 41.82,91.23 33.53,91.23 30.3,87.99 30.3,87.67 26.34,83.71 26.34,82.82 26.08,82.56 25.1,82.56 24.43,81.89 24.43,81.21 22.44,79.22 22.44,74.73 21.04,73.34 21.04,65.99 22.25,64.77 22.54,64.77 22.63,64.68 v1(22.63,64.18)
  BOTTOM w0.102: v1(111.36,91.42) 113.06,91.42 113.21,91.26 118.03,91.26 118.03,91.27 120.89,91.27 120.89,91.26 120.92,91.26 121.29,90.89 121.29,87.21 121.09,87.01 121.09,84.28 120.47,83.67 CPU1.BW2
USB4_USB30_TX_P: length 136.9
  TOP w0.102: v1(23.31,64.26) 23.16,64.26 22.85,64.57 22.85,65.21 23.07,65.43 23.25,65.43 23.62,65.8 23.62,66.39 23.51,66.49 23.51,66.75 23.69,66.93 C7303.1
  L6 w0.089: v1(23.31,64.26) 23.31,64.65 23.21,64.75 22.83,64.75 22.62,64.96 22.33,64.96 21.23,66.07 21.23,73.26 22.63,74.65 22.63,79.14 24.62,81.14 24.62,81.81 25.17,82.37 26.16,82.37 26.53,82.74 26.53,83.63 30.49,87.59 30.49,87.91 33.61,91.04 41.89,91.04 43.01,92.15 46.17,92.15 47.43,93.41 53.1,93.41 54.22,94.53 63.73,94.53 64,94.81 66.49,94.81 67.47,93.83 74.34,93.83 74.95,93.22 95.83,93.22 96.31,93.7 99.46,93.7 99.91,93.26 104.29,93.26 104.81,92.74 106.01,92.74 108.4,90.35 110.13,90.35 110.9,91.13 111.03,91.13 111.36,90.8 v1(111.36,90.63)
  BOTTOM w0.102: CPU1.BW1 120.75,84.27 120.86,84.38 120.86,87.1 121.06,87.31 121.06,87.76 ; 121.06,87.76 121.06,90.8 120.82,91.04 118.13,91.04 118.12,91.04 113.12,91.04 112.96,91.19 112.01,91.19 111.86,91.04 111.86,90.76 111.73,90.63 v1(111.36,90.63) ; 121.06,87.76 v2(120.9,87.76)
USB_ADT: length 224.9
  TOP w0.508: v1(137.1,17.12) 137.3,16.93 PD4409.A ; v1(12.01,54.26) 13.99,54.26 14.57,53.67 16.2,53.67 16.43,53.44 16.43,53.43 17.57,52.29 17.57,51.26 18.33,50.5 19.07,50.5 19.7,49.86 19.7,48.03 19.5,47.83 19.5,45.09 18.97,44.55 18.97,42.88 19.7,42.14 19.7,39.86 v1(18.76,38.92) 18.21,38.92 v2(17.48,39.64)
  L4 w0.508: v1(12.01,54.26) 11.78,54.26 11.22,54.82 11.22,59.21 11.8,59.79 11.8,78.11 16.39,82.71 19.76,82.71 20.36,83.31 20.36,84.23 20.14,84.46 v3(20.14,86.08) ; v1(18.76,38.92) 23.01,38.92 25.5,36.43 25.5,35.38 26.81,34.06 27.33,34.06 27.91,34.64 27.91,35.33 29.41,36.83 30.44,36.83 32.63,39.03 32.63,39.74 34.28,41.38 36.11,41.38 37.69,42.95 41.55,42.95 41.57,42.93 42.79,42.93 45.1,40.62 47.06,40.62 47.18,40.74 49.17,40.74 49.75,40.16 49.75,39 49.07,38.32 49.07,36.5 50.87,34.7 50.87,33.86 51.2,33.53 51.2,32.77 50.87,32.44 50.87,30.66 50.84,30.64 50.84,30.53 50.39,30.08 50.39,28.32 51.81,26.9 51.81,19.64 56.03,15.42 56.03,14.67 56.71,13.99 57.89,13.99 58.72,13.16 65.93,13.16 67.3,11.79 69.69,11.79 70.83,10.65 73.83,10.65 74.39,10.09 74.39,9.58 74.9,9.07 86.96,9.07 87.32,8.71 92.35,8.71 93.99,10.35 95.61,10.35 96.84,11.59 99.82,11.59 100.15,11.92 105.89,11.92 v1(107.33,13.36) 108.48,13.36 111.75,16.64 136.21,16.64 136.7,17.12 v1(137.1,17.12)
  BOTTOM w0.508: PD4401.2 103.4,15.37 107.18,15.37 PD4408.2 107.33,15.22 v2(107.33,14) v1(107.33,13.36)
  vias: v2(22.06,87.16) v3(20.14,86.97) v3(20.97,86.88) v3(20.97,86.05)
USB_EN#: length 4.5
  TOP w0.102: R2479.1 48.61,42.78 v2(48.56,42.73) 48.25,42.73 47.64,42.11 U2401.13
USB_OC0#: length 94.7
  TOP w0.102: RN1601.5 144.88,79.63 144.6,79.35 v1(144.39,79.35) ; v2(98.27,93.02) 98.52,93.27 v1(98.77,93.27) ; v1(78.48,98.32) 78.68,98.12 78.68,97.59 U7204.B2
  L3 w0.102: v1(98.77,93.27) 97.2,94.85 92.5,94.85 89.99,97.36 88.44,97.36 88.18,97.11 88.18,95.99 87.5,95.3 84.37,95.3 83.36,96.32 81.05,96.32 79.04,98.32 v1(78.48,98.32)
  L4 w0.102: v1(126.53,81.17) 125.11,79.75 125.11,79.21 124.82,78.91 124.63,78.91 122.57,76.86 121.97,76.86 121.49,76.38 119.46,76.38 119.04,76.8 113.38,76.8 112.56,77.62 109.5,77.62 107.55,79.56 107.55,82.41 105.28,84.69 105.28,87.02 105.66,87.4 105.66,90.95 104.79,91.82 100.22,91.82 v1(98.77,93.27)
  L6 w0.102: v1(144.39,79.35) 143.96,78.92 143.58,78.92 143.17,78.52 143.17,77.32 142.95,77.09 136.6,77.09 134.39,79.3 132.12,79.3 131.59,79.83 131.59,81.41 131.39,81.61 129.13,81.61 128.19,82.55 127.45,82.55 127.02,82.12 127.02,81.61 126.58,81.17 v1(126.53,81.17)
  BOTTOM w0.102: CPU1.CK6 126.76,81.17 v1(126.53,81.17)
USB_OC1#: length 205.1
  TOP w0.102: v1(143.71,79.35) 144.16,78.9 144.67,78.9 144.82,79.04 RN1601.6
  L3 w0.102: v1(22.9,32.97) 23.59,33.66 23.59,42.19 22.52,43.26 22.52,44.1 20.82,45.8 20.82,49.98 22,51.16 22,54.97 23.57,56.54 23.57,58.25 24.94,59.62 24.94,61.27 25.47,61.8 25.47,64.34 23.46,66.35 23.46,67.74 v1(22.42,68.79)
  L4 w0.102: v1(22.42,68.79) 22.85,68.79 27.04,72.98 27.04,76.4 27.05,76.41 27.63,76.99 27.63,79.78 29.94,82.1 29.94,85.45 31.03,86.54 31.03,88.5 36.67,94.14 42.21,94.14 42.57,94.49 53.2,94.49 53.57,94.86 64.27,94.86 64.41,94.72 68.47,94.72 68.7,94.49 80.74,94.49 81.2,94.03 98.72,94.03 100.73,92.03 104.87,92.03 106.05,90.85 106.05,85.89 106.14,85.8 106.14,84.31 107.77,82.68 107.77,79.63 109.46,77.94 112.51,77.94 113.36,77.09 117.19,77.09 117.29,77.19 120.49,77.19 120.52,77.22 122.42,77.22 122.68,77.47 122.68,77.47 124.24,79.04 124.24,81.01 125.51,82.28 126.08,82.28 v1(126.56,81.8)
  L6 w0.102: v1(143.71,79.35) 142.97,78.62 142.97,77.73 142.54,77.29 136.7,77.29 134.49,79.5 132.2,79.5 131.79,79.91 131.79,81.49 131.46,81.82 129.19,81.82 128.25,82.76 127.37,82.76 126.56,81.95 v1(126.56,81.8)
  BOTTOM w0.102: v2(22.98,68.96) 22.6,68.96 v1(22.42,68.79) ; v1(126.56,81.8) 126.79,81.57 CPU1.CK5 ; U3601.13 22.76,33.11 v1(22.9,32.97)
USB_OC2#: length 177.7
  TOP w0.102: v1(143.76,78.49) 144.29,77.96 RN1601.8
  L3 w0.102: v1(23.87,64.7) 24.02,64.85 24.63,64.85 25.27,64.21 25.27,62.16 24.73,61.62 24.73,59.72 23.16,58.14 23.16,57.68 22.6,57.13 22.6,56.67 22.02,56.09 v1(21.94,56.09)
  L4 w0.102: v1(23.87,64.7) 23.87,69.47 27.25,72.85 27.25,76.17 27.93,76.86 27.93,78.69 29.36,80.11 29.43,80.11 30.14,80.82 30.14,85.35 31.24,86.44 31.24,88.41 36.74,93.92 42.3,93.92 42.67,94.29 53.3,94.29 53.67,94.66 63.96,94.66 64.76,93.86 66.24,93.86 66.62,94.24 80.51,94.24 80.97,93.78 97.63,93.78 99.79,91.62 104.7,91.62 105.45,90.87 105.45,87.48 105.04,87.06 105.04,84.57 106.63,82.98 106.63,79.78 107.03,79.38 107.45,79.38 109.41,77.42 112.48,77.42 113.3,76.61 118.96,76.61 119.38,76.19 121.6,76.19 122.04,76.62 122.62,76.62 124.66,78.67 125.34,78.67 v1(126.56,79.89)
  L6 w0.102: v1(143.76,78.49) 143.53,78.26 143.53,77.37 143.05,76.89 136.51,76.89 134.3,79.1 131.34,79.1 131.13,79.3 131.13,80.37 130.91,80.6 130.14,80.6 128.39,78.84 127.24,78.84 126.95,79.13 126.95,79.5 v1(126.56,79.89)
  BOTTOM w0.102: v1(21.94,56.09) 21.58,55.73 R3512.2 ; CPU1.CK8 126.72,79.9 126.58,79.9 v1(126.56,79.89) ; v1(23.87,64.7) 23.95,64.77 v2(23.95,65.38)
USB_OC2#_R: length 7.4
  BOTTOM w0.102: U3502.3 19.89,52.62 18.54,51.26 18.39,51.26 v2(18.37,51.28) 18.23,51.42 18.23,54 19.58,55.35 19.65,55.35 R3512.1
USB_OC3#: length 174.3
  TOP w0.102: v1(144.42,78.46) 144.47,78.46 144.55,78.54 RN1601.7 ; v1(215.37,35.55) v2(214.9,35.08) 214.5,34.68 214.5,32.67 216.4,30.76 216.4,29.97 216.48,29.9 216.48,26.22 216.12,25.86 216.12,24.73 215.79,24.4 215.79,23.19 213.71,21.11 213.71,18.9 215.82,16.79 215.82,10.86 214.78,9.82 214.78,9.81 212.19,7.22 206.57,7.22 204.64,9.15 204.64,12.68 204.62,12.7 204.62,12.73 201.95,15.4 201.95,16.26 201.67,16.54 R3432.2
  L6 w0.102: 144.42,78.41 v1(144.42,78.46) ; 144.42,78.41 143.78,77.78 143.78,77.32 143.15,76.69 136.42,76.69 134.21,78.9 131.24,78.9 130.93,79.2 130.93,80.3 130.83,80.4 130.23,80.4 128.47,78.64 127.09,78.64 v1(126.54,79.19) ; 144.42,78.41 144.42,76.7 148.29,72.83 149.82,72.83 150.06,72.6 151.34,72.6 155.75,68.19 155.75,59.16 162.38,52.53 166.26,52.53 166.69,52.96 172.43,52.96 181.91,43.49 184.42,43.49 185.44,42.47 198.31,42.47 200.3,40.48 200.3,39.37 201.17,38.5 207.35,38.5 208.94,36.91 212.6,36.91 213.95,35.55 v1(215.37,35.55)
  BOTTOM w0.102: CPU1.CK9 126.95,78.97 126.73,79.19 126.55,79.19 v1(126.54,79.19)
USB_OC3#_R: length 6
  TOP w0.102: v1(191.78,15.03) 191.81,14.99 v2(192.48,14.99) 193.82,14.99 195.37,16.54 R3432.1
  BOTTOM w0.102: U3403.3 190.76,15.03 v1(191.78,15.03)
USB_POWERSHARE_VBUS_EN: length 31.9
  TOP w0.102: v1(29.87,46.99) 29.95,47.07 30.83,47.07 31.07,47.31 U2401.71
  L4 w0.102: v1(18.1,36.78) 18.23,36.91 18.23,39.5 20.14,41.4 20.14,44.22 20.57,44.66 22.8,44.66 23.02,44.88 26.71,44.88 28.99,47.16 29.7,47.16 v1(29.87,46.99)
  BOTTOM w0.102: v1(18.1,36.78) 17.98,36.78 17.27,36.07 17.27,35.69 v2(16.94,35.37) 15.07,33.49 15.07,32.4 16.73,30.74 18.13,30.74 18.65,31.26 U3601.5
USB_PWR_EN#: length 216.9
  TOP w0.102: v1(189.15,14.3) v2(189.15,14.86) ; R2434.2 52.11,42.07 R2479.2 52.77,42.78 v1(52.85,42.7)
  L4 w0.102: v1(15.51,50.83) 16.53,49.81 19.55,49.81 22.45,52.71 28.33,52.71 30.84,50.2 32.92,50.2 33.41,50.69 35.21,50.69 36.85,49.04 39.5,49.04 39.8,48.75 41.14,48.75 42.29,47.6 43.53,47.6 44.32,46.81 44.49,46.81 44.83,46.48 46.45,46.48 46.91,46.94 49.2,46.94 52.01,44.12 52.01,43.53 v1(52.85,42.7) 53.51,42.04 53.51,40.08 55.59,38 55.59,37.59 55.54,37.54 55.54,35.51 56.66,34.39 56.66,33.43 55.85,32.62 55.85,32.21 55.62,31.98 55.57,31.98 55.11,31.52 55.11,22.99 56.43,21.67 56.43,20.83 57.6,19.66 63.52,19.66 64.1,19.08 69.82,19.08 71,17.9 72.93,17.9 74.01,16.82 76.22,16.82 76.91,16.13 77.54,16.13 80.11,18.7 97.73,18.7 98.37,18.06 99.71,18.06 101.67,20.02 103,20.02 103.97,20.98 149.55,20.98 150.36,21.8 152.09,21.8 152.9,20.98 171.09,20.98 175.3,16.77 180.21,16.77 182.9,14.07 184.37,14.07 184.84,13.61 188.46,13.61 v1(189.15,14.3)
  BOTTOM w0.102: v1(15.51,50.83) 15.51,52.01 16.12,52.62 U3502.4 ; v1(189.15,14.3) 189.15,14.43 188.63,14.95 U3403.4
USB_PWR_SHR_EN_L#: length 41.2
  TOP w0.102: v1(40.21,30.43) 41.6,31.82 41.6,34.29 41.88,34.57 41.88,34.98 41.58,35.28 U2401.118 ; R2475.2 24.86,35.33 v1(24.71,35.49)
  L4 w0.102: v1(18.82,36.76) 19.45,36.12 23.72,36.12 24.35,35.49 v1(24.71,35.49) 24.71,33.4 27.58,30.53 28.85,30.53 29.33,31.02 35.12,31.02 35.35,30.79 35.76,30.79 35.99,31.02 38.7,31.02 39.29,30.43 v1(40.21,30.43)
  BOTTOM w0.102: R3601.1 15.77,32.01 15.28,32.49 15.28,33.21 17.47,35.39 17.47,35.98 17.79,36.3 18.36,36.3 v1(18.82,36.76) ; v2(24.71,34.93) v1(24.71,35.49)
USBCOMP: length 9.1
  TOP w0.508: R1603.1 129.08,81.23 v2(129.13,81.28) 129.13,82.19 128.77,82.55 123.6,82.55 122.85,81.8 v1(122.85,81.78)
  BOTTOM w0.203: CPU1.CC5 123.07,81.57 v1(122.85,81.78)
V_SM_VREF_CNTA: length 73.9
  TOP w0.254: v1(61.6,51.84) 61.6,52.29 61.77,52.45 61.77,52.5 64,54.74 64.05,54.74 64.13,54.82 69.72,54.82 70.45,55.55 73.2,55.55 v1(73.48,55.27) ; R1206.2 70.66,19.33 C1222.1 69.31,19.13 68.93,18.75 v1(68.93,18.37)
  L3 w0.254: v1(68.93,18.37) 68.52,18.78 68.52,27.71 69.01,28.2 69.01,35.89 68.46,36.44 68.08,36.44 64.99,39.53 64.79,39.53 63.39,40.92 63.39,46.74 60.45,49.69 60.45,51.84 60.72,52.11 61.33,52.11 v1(61.6,51.84)
  BOTTOM w0.203: CPU1.F36 88.15,62.04 87.78,61.67 87.78,61.34 87.32,60.89 87.14,60.89
  BOTTOM w0.254: 87.14,60.89 81.53,55.27 v1(73.48,55.27)
V_SM_VREF_CNTB: length 149.2
  TOP w0.254: v1(86.53,17.01) 87.08,16.46 89.07,16.46 89.58,16.97 94.84,16.97 95.88,15.93 101.26,15.93 102.33,17 105.48,17 107.61,19.13 132.99,19.13 133.65,19.79 139.62,19.79 140.96,18.44 145,18.44 146.3,17.15 147.92,17.15 148.48,17.71 149.73,17.71 R1305.2 149.98,17.96 C1323.1 ; v1(72.84,55.04) 72.81,55.07 70.61,55.07 69.89,54.36 64.18,54.36 62.15,52.33 v1(62.15,51.51)
  L3 w0.254: v1(86.53,17.01) 83.7,19.84 75.03,19.84 73.5,21.36 73.5,24.89 71.88,26.52 71.88,36.36 69.53,38.71 69.1,38.71 67.79,40.03 67.79,42.78 67.23,43.34 66.26,43.34 65.73,43.87 65.73,47.55 62.43,50.85 62.43,51.23 v1(62.15,51.51)
  BOTTOM w0.254: v1(72.84,55.04) 72.84,55.37 73.27,55.8 81.54,55.8 86.98,61.24 87.18,61.24 87.45,61.51 87.45,61.86 CPU1.E36
VCI_IN1#: length 6.9
  TOP w0.102: U2401.126 44.78,35.28 45.03,35.03 47.19,35.03 47.7,34.52 47.82,34.52 48.1,34.24 48.1,33.62 48.55,33.18 v2(48.55,32.8) 48.61,32.73 R2452.2
VCREF0: length 8.5
  TOP w0.102: U2401.25 47.64,46.91 48.87,48.14 v2(50.12,48.14) 50.12,48.15 50.7,48.72 51.61,48.72 R2448.1 51.99,49.1 C2409.1 53.13,49.1 53.92,48.31 R2424.1
VD_IN1_C: length 134.5
  TOP w0.089: R2611.1 C2612.2 C2613.2 59.68,46.48 v1(58.85,47.32)
  L3 w0.127: v1(32.53,88.74) 31.77,87.98 31.77,84.76 32.91,83.62 32.91,83.52 32.96,83.47 32.96,83.27 32.96,83.26 32.96,82.63 32.63,82.3 32.61,82.3 32.56,82.25 32.07,82.25 30.63,80.81 30.63,78.77 31.03,78.36 31.03,77.55 30.5,77.02 29.35,77.02 28.93,76.6 28.61,76.6 28.21,76.2 28.21,76.18 27.49,75.45 27.49,73.98 27.07,73.56 27.07,72.57 25.53,71.03 25.53,68.12 26.11,67.55 26.11,66.55 27.32,65.33 27.32,64.37 27.06,64.1 27.06,59.63 25.01,57.58 25.01,54.77 24,53.75 24,50.55 v1(23.9,50.45)
  L4 w0.127: v1(23.9,50.45) 23.95,50.4 24.51,50.4 26.58,48.33 28.15,48.33 28.25,48.43 30.21,48.43 v1(30.27,48.36)
  BOTTOM w0.089: v1(58.85,47.32) 58.57,47.6 55.8,47.6 54.53,48.87 51.94,48.87 51.71,49.1 50.87,49.1 50.34,48.57 48.07,48.57 46.95,47.45 42.18,47.45 40.79,48.84 39.67,48.84 39.32,49.19 36.46,49.19 34.63,47.37 31.27,47.37 v1(30.27,48.36) ; v1(32.53,88.74) 32.53,90.27 35.4,93.14 35.4,93.53 35.86,93.98 35.86,95.05 37.03,96.22 57.11,96.22 60.78,92.56 60.78,89.88 v2(62.21,88.45) 62.46,88.19 64.21,88.19 64.79,88.78 66.39,88.78 66.72,89.11 67.76,89.11 R2610.2
VGA_CORE: length 60.9
  TOP w0.356: R8642.1 103.35,106.33 102.99,105.97 v1(102.99,105.95)
  L3 w0.254: v1(116.66,97.82) 116.78,97.95 116.78,98.78 118.21,100.21 118.21,103.15 117.22,104.14 115.74,104.14 115.59,104.3 115.56,104.3 115.28,104.57 115.28,104.6 115.21,104.68 115.21,105.31 115.39,105.49 v1(115.83,105.49) 118.94,105.49 119.87,106.42 127.36,106.42 128.77,107.83 147.24,107.83 147.63,107.43 v3(147.63,106.44)
  L4 w0.305: v1(115.83,105.49) 110.97,105.49 110.71,105.75 103.21,105.75 103.02,105.95 v1(102.99,105.95)
  BOTTOM w0.254: PR8518.1 v1(116.66,97.82)
  BOTTOM w0.508: C8039.1 167.44,79.56 v1(167.84,79.96)
  vias: v1(164.84,86.72) v1(165.4,86.32) v1(174.94,76.96) v1(175.36,79.84) v1(175.38,77.52) v1(175.53,76.43) v1(175.92,80.43) v1(175.94,78.11) v1(176.02,75.95) v1(176.5,78.68) v1(177.06,79.21) v1(177.06,81.59) v1(177.49,83.82) v1(177.61,79.81) v1(177.7,77.52) v1(177.77,82.12) v1(177.87,83.31) v1(178.25,82.78) v1(178.2,80.34) v1(178.2,78.06) v1(178.48,82.17) v1(178.79,80.95) v1(178.85,76.33) v1(179.34,79.25) v1(179.41,76.86) v1(179.46,74.6) v1(180.01,75.17) v1(180.44,86.03) v1(180.57,75.7) v1(181.11,76.3) v1(181.38,85.12) v1(181.71,76.84) v1(181.89,84.53) v1(181.89,83.14) v1(182.01,85.93) v1(182.31,77.45) v1(183.41,87.33) v1(183.41,85.93) v1(183.41,84.53) v1(183.38,83.14) v1(184.04,82.37) v1(186.25,83.04) v1(186.28,81.66) v1(189.02,84.48) v1(189.02,83.04) v1(189.12,85.93) v1(190.34,84.46) v2(142.13,95.2) v2(149.55,98.38) v2(170.53,78.39) v2(183.43,85.22) v3(141.17,106.25) v3(141.24,101.5) v3(141.24,100.64) v3(141.24,99.72) v3(142.13,106.2) v3(142.11,101.53) v3(142.11,100.66) v3(142.11,99.75) v3(142.97,101.53) v3(142.97,100.66) v3(142.97,99.75) v3(143.15,106.2) v3(144.14,105.97) v3(144.39,101.53) v3(144.47,97.34) v3(144.55,95.94) v3(145.05,105.84) v3(145.31,97.36) v3(145.38,95.94) v3(145.49,101.5) v3(146.12,105.84) v3(146.15,97.36) v3(146.25,95.91) v3(146.65,101.5) v3(146.63,100.36) v3(146.63,98.99) v3(146.76,106.5) v3(146.83,104.93) v3(146.98,97.36) v3(147.09,95.91) v3(147.29,105.65) v3(147.72,104.93) v3(147.72,101.5) v3(147.7,100.36) v3(147.7,98.99) v3(147.82,97.36) v3(147.92,95.91) v3(148.25,105.67) v3(148.66,97.31) v3(148.79,104.93) v3(148.79,101.5) v3(148.76,100.36) v3(148.76,98.99) v3(148.76,95.91) v3(171.97,79.83) v3(172.56,79.23) v3(172.87,80.09) v3(173.17,78.62) v3(173.78,78.02) v3(174.37,77.42) v3(174.54,78.54) v3(176.22,76.91) v3(176.68,75.59)
VGA_CORE_DISCHG: length 2.1
  TOP w0.102: v2(102.51,105.13) 102.23,105.42 Q8605.D 102.23,106.78 R8642.2
VGA_CORE_PSI: length 108.6
  TOP w0.127: v1(118.51,107.14) 118.21,106.84 117.34,106.84 117.19,106.68 117.19,106.67 116.99,106.47 PR8516.1 ; R7967.2 R7966.2 186.47,64.16 v2(186.55,64.08) 187.2,64.08 v1(188,63.27)
  L3 w0.127: v1(152.47,107.37) 154.91,104.93 154.91,92.93 158.1,89.74 159.39,89.74 159.56,89.56 159.58,89.56 160.78,88.37 160.78,88.33 160.82,88.29 160.82,88.14 160.84,88.12 160.84,86.98 163.57,84.25 163.57,83.54 174.92,72.19 174.92,71.53 175,71.45 175,69.14 175.08,69.07 175.08,68.07 177.48,65.67 179.26,65.67 180.36,64.57 186.74,64.57 188,63.3 v1(188,63.27)
  L4 w0.127: v1(152.47,107.37) 152.11,107.72 146.02,107.72 145.79,107.95 129.2,107.95 127.43,106.17 127.4,106.17 127.3,106.07 123.62,106.07 121.3,103.76 119.86,103.76 119.32,104.3 119.32,104.7 118.51,105.51 v1(118.51,107.14)
VGA_CORE_VID: length 101.2
  TOP w0.089: R7961.2 181.65,67.39 R7960.2 182.09,67.06 v1(182.52,67.49)
  L3 w0.114: v1(153.55,107.38) 155.29,105.64 155.29,93.08 158.25,90.12 159.53,90.12 159.54,90.12 159.72,89.94 159.74,89.94 161.15,88.53 161.15,88.5 161.16,88.5 161.16,88.48 161.2,88.44 161.2,88.3 161.22,88.28 161.22,87.18 164.74,83.66 164.74,82.91 166.77,80.88 167.54,80.88 168.41,80.01 168.41,79.47 175.38,72.49 175.38,69.29 175.46,69.22 175.46,68.23 177.62,66.07 179.39,66.07 180.34,65.12 182.52,65.12 182.78,65.38 182.78,66.27 182.52,66.53 v1(182.52,67.49)
  L4 w0.114: v1(120.19,104.35) 121.35,104.35 123.46,106.45 127.15,106.45 127.25,106.56 127.27,106.56 129.05,108.33 145.94,108.33 146.17,108.11 152.83,108.11 v1(153.55,107.38)
  BOTTOM w0.089: PR8507.1 v2(117.47,104.02) 119.86,104.02 v1(120.19,104.35)
VGA_CT_1: length 3.3
  BOTTOM w0.127: U8601.12 174.95,99.63 174.99,99.58 175.47,99.58 v2(175.91,100.03)
  BOTTOM w0.254: C8608.1 176.7,100.03 v2(175.91,100.03)
VGACORE_GND_SENSE_1: length 85
  TOP w0.254: v1(114.42,99.08) 114.56,99.08 114.65,99.16 PR8520.2
  L4 w0.254: v1(114.42,99.08) 114.61,99.08 118.1,95.58 119.88,95.58 120.14,95.33 120.14,94.44 120.52,94.06 123.16,94.06 123.36,94.26 125.5,94.26 127.65,92.1 127.65,91.49 128.75,90.4 133.32,90.4 134.67,91.75 145.31,91.75 145.79,91.26 150.8,91.26 161.56,80.5 161.56,78.63 167.47,72.72 168.81,72.72 169.31,72.22 v1(169.31,71.32)
  BOTTOM w0.254: v1(169.31,71.32) 169.31,71.91 169.56,72.16 171.06,72.16 v2(171.29,71.94) 171.77,71.94 172,71.71 176.42,71.71 176.65,71.48 176.65,71.45 177.65,70.45 177.76,70.45 177.76,70.45 178.11,70.45 179.32,71.66 179.33,71.66 179.45,71.78 180.82,71.78 181.19,72.16 GPU1.F1
VGACORE_VDD_SENSE_1: length 81.9
  L4 w0.254: v1(170,71.66) 170,72.08 168.97,73.1 167.63,73.1 162,78.74 162,80.61 161.97,80.64 161.97,80.65 150.97,91.65 145.97,91.65 145.46,92.15 134.51,92.15 133.14,90.78 128.92,90.78 128.04,91.67 128.04,92.28 125.62,94.69 123.18,94.69 122.93,94.44 120.8,94.44 120.54,94.69 120.54,95.63 120.21,95.96 118.83,95.96 117.8,97 117.8,97.65 v1(117.97,97.82)
  BOTTOM w0.254: GPU1.F2 181.76,72.2 180.83,71.28 179.5,71.28 178.89,70.67 178.87,70.67 178.24,70.03 177.51,70.03 177.21,70.34 177.18,70.34 176.24,71.28 v2(172.41,71.28) 171.8,71.28 171.57,71.5 171.09,71.5 170.94,71.66 v1(170,71.66)
  BOTTOM w0.305: PR8519.2 117.95,97.84 v1(117.97,97.82)
VID_PLLVDD: length 18.5
  TOP w0.508: R7954.2 182.89,93.33 v2(182.21,94.01) 182.19,94.03 182.19,94.06 v1(181.77,94.48)
  L6 w0.508: v1(181.77,94.48) 181.71,94.41 181.71,91.16 182.34,90.53 182.34,89.69 179.75,87.1 179.75,82.83 179.88,82.71 179.88,79.84 v1(179.97,79.74)
  BOTTOM w0.356: GPU1.N6 v1(179.97,79.74)
VID_PLLVDD_L: length 35.1
  TOP w0.508: v1(182.85,92.1) 183,92.26 183.81,92.26 R7954.1 184.38,92.83 C7938.1 184.38,94.4 184.45,94.47 184.45,95.18 v2(184.12,95.51) 183.76,95.51 183.69,95.58 182.92,95.58 181.76,96.75 180.98,96.75 C7939.1 179.79,95.57 C7934.1 179.06,95.58 179.06,96.98 179.67,97.59 179.67,98.63 v1(182.09,101.04) ; C7937.1 180.76,81.37 v1(181.02,81.1) C7936.1
  L6 w0.508: v1(180.54,79.2) 181.02,79.68 v1(181.02,81.1) 180.54,81.59 180.54,85.19 181.3,85.95 181.3,87.04 181.65,87.4 181.65,88.14 182.95,89.44 182.95,90.78 182.62,91.11 182.62,91.87 v1(182.85,92.1)
  BOTTOM w0.305: GPU1.M6 v1(180.54,79.2)
  BOTTOM w0.508: v1(182.09,101.04) 182.09,101.43 L7902.2
VIDEO_CLK_XTAL_SS: length 12.3
  TOP w0.089: R7901.1 196.49,68.18 196.49,69.42 193.72,72.19 191.76,72.19 189.94,74.02 v1(189.38,74.02) 189.05,74.02 v2(188.74,73.71)
  BOTTOM w0.089: v1(189.38,74.02) 189.31,74.09 GPU1.A10
VR_CAP: length 2.3
  TOP w0.203: U2401.18 48.06,44.11
  TOP w0.254: C2418.1 49.21,44.11 v2(48.46,44.11) 48.06,44.11
VR_EN: length 4.6
  TOP w0.102: v2(39.49,64.14) 39.49,64.11 39.29,63.91 39.29,63.32 R4002.2 38.73,63.25 38.25,62.77 v1(37.38,62.77)
  BOTTOM w0.102: PU4601.40 38.1,63.46 37.41,62.77 v1(37.38,62.77)
VR_RDY: length 4.7
  BOTTOM w0.102: PU4601.39 38.5,63.37 37.81,62.68 37.81,62.59 37.56,62.33 37.28,62.33 PR4609.2 35.76,60.81 TP4601.1
VRALERT#: length 5.4
  BOTTOM w0.076: TP1708.1 123.74,58.61 123.74,60.18 123.41,60.5 123.41,61.28 123.62,61.49 123.62,61.76 123.57,61.83 123.51,61.89 123.36,62.16 CPU1.CC36
VRAM_ID2: length 17.4
  TOP w0.102: v1(131.37,69.64) 132.31,69.64 133.22,68.74 135.63,68.74 137.2,67.16 140.23,67.16 140.43,66.96 140.43,66.45 v1(140.51,66.37)
  BOTTOM w0.083: CPU1.CN23 129.3,70.08 130.07,70.08
  BOTTOM w0.102: 130.07,70.08 130.31,69.83 131.18,69.83 v1(131.37,69.64) ; R2037.1 141.89,69.33 R2038.2 141.89,67.27 v2(141.48,66.86) 140.99,66.37 v1(140.51,66.37)
WHITE_LED_BAT: length 5.1
  TOP w0.254: R6406.1 EC6404.1 12.67,95.46 v1(13.38,95.46)
  BOTTOM w0.254: v1(13.38,95.46) 13.94,95.46 v2(14.09,95.3) 14.09,94.01 14.55,93.55 Q6404.C
WIFI_RF_EN: length 185.1
  TOP w0.102: v2(160.29,45.54) 160.29,46.05 v1(160.19,46.15) ; v1(200.2,56.97) 199.41,57.76 D6102.K 198.24,57.76 R6114.2 ; R2107.2 135.22,52.02 135.66,52.45 135.66,54.82 v1(133.73,56.75)
  L4 w0.102: v1(160.19,46.15) 160.24,46.21 162.71,46.21 164.28,44.63 164.33,44.63 164.34,44.63 165.02,44.63 165.98,43.67 167.68,43.67 168.4,42.95 169.41,42.95 170.71,41.66 171.52,41.66 178.58,34.6 179.52,34.6 180.94,33.18 185.85,33.18 186.43,32.59 186.46,32.59 186.78,32.28 196.08,32.28 v1(196.67,32.87) ; v1(215.64,32.72) 214.22,34.14 214.22,40.08 215.87,41.73 215.87,47.45 217.82,49.41 219.17,49.41 221.46,51.69 221.46,57.05 221.3,57.2 221.3,60.04 218.66,62.68 213.93,62.68 212.36,61.12 205.02,61.12 203.47,59.57 203.47,58.93 201.52,56.97 v1(200.2,56.97)
  L6 w0.102: v1(126.11,68.43) 125.7,68.84 124.18,68.84 123.95,68.6 123.95,68.26 123.97,68.24 123.97,64.28 127.51,60.73 127.51,57.61 129.01,56.11 133.09,56.11 v1(133.73,56.75) ; v1(196.67,32.87) 197.6,33.81 200.07,33.81 200.55,33.33 200.58,33.33 201.06,32.84 204.9,32.84 205.33,33.28 206.39,33.28 207.61,32.06 208.35,32.06 209.54,33.25 211.7,33.25 212.24,32.72 v1(215.64,32.72)
  BOTTOM w0.089: v1(126.11,68.43) 126,68.43 125.42,69.01 CPU1.CG25
  BOTTOM w0.102: v1(133.73,56.75) 134.64,55.83 143.74,55.83 147.98,51.59 156.07,51.59 156.8,50.85 158.31,50.85 160.4,48.77 160.4,46.36 v1(160.19,46.15)
WIFI_RF_EN_R: length 9.2
  TOP w0.102: D6102.A 198.88,56.75 R6114.1 198.09,55.22 AFTP6106.1 198.29,53.7 R6142.2 199.59,53.62 199.82,53.85 199.82,54.88 v1(199.43,55.26)
  BOTTOM w0.102: WLAN1.56 199.96,54.72 199.43,55.25 v1(199.43,55.26)
WLAN_CLK_CPU_N: length 119
  L4 w0.102: v1(201.56,63.5) 201.79,63.5 201.94,63.36 201.94,62.96 201.82,62.84 201.82,62.36 198.49,59.03 189.77,59.03 188.73,57.99 180.11,57.99 179.62,58.47 177.24,58.47 174.44,61.28 174.44,63.38 152.73,85.09 150.86,85.09 150.65,84.88 144.5,84.88 144.25,85.13 142.04,85.13 139.72,82.81 135.81,82.81 132.4,86.21 129.08,86.21 128.14,85.27 119.91,85.27 119.32,85.86 119.32,86.24 116.61,88.95 114.5,88.95 112.54,86.99 112.54,86.31 111.74,85.5 110.36,85.5 v1(109.96,85.94)
  BOTTOM w0.102: WLAN1.49 201.71,62.2 201.85,62.33 201.85,62.87 201.99,63.01 201.99,63.23 201.72,63.5 v1(201.56,63.5) ; CPU1.BC1 110.66,84.31 110.66,85.24 v1(109.96,85.94)
WLAN_CLK_CPU_P: length 119
  L4 w0.102: v1(202.35,63.5) 202.14,63.29 202.14,62.87 202.02,62.75 202.02,62.28 198.57,58.83 189.86,58.83 188.82,57.79 180.02,57.79 179.54,58.27 177.16,58.27 174.24,61.19 174.24,63.3 152.65,84.89 150.94,84.89 150.73,84.68 144.41,84.68 144.16,84.93 142.13,84.93 139.8,82.6 135.72,82.6 132.32,86.01 129.16,86.01 128.22,85.07 119.83,85.07 119.12,85.78 119.12,86.15 116.52,88.75 114.59,88.75 112.74,86.91 112.74,86.23 111.82,85.3 v1(109.94,85.3)
  BOTTOM w0.102: v1(202.35,63.5) 202.22,63.36 202.22,62.92 202.07,62.78 202.07,62.33 202.21,62.2 WLAN1.47 ; v1(109.94,85.3) 110.27,85.3 110.43,85.14 110.43,83.89 CPU1.BC2
WLAN_CLKREQ_CPU_N: length 148.5
  TOP w0.102: v1(124.48,64.34) 124.48,63.78 124.63,63.63 124.63,62.56 126,61.19 126,58.52 126.84,57.69 126.84,56.44 127.27,56.01 127.27,54.98 v1(127.12,54.82) 127.12,54.81 126.08,53.77 RN1813.8 ; v1(197.38,55.98) 197.66,56.26 197.66,58.35 AFTP6105.1 197.23,59.03 200.73,59.03 v1(200.78,58.98)
  L6 w0.102: v1(127.12,54.82) 127.77,54.82 129.58,53.01 129.74,53.01 135.5,53.01 138.17,50.35 138.17,42.34 140.35,40.16 148.64,40.16 149.93,41.46 155.77,41.46 157.65,39.58 167.41,39.58 168.13,40.29 169.46,40.29 169.92,40.74 176.07,40.74 180.44,36.38 180.64,36.38 180.66,36.35 184.35,36.35 184.96,36.96 191.13,36.96 192.83,35.26 192.83,34.43 195.58,31.68 198.78,31.68 v1(199.18,32.08)
  BOTTOM w0.102: v1(197.38,55.98) 196.31,55.98 194.48,54.16 194.48,51.77 196.51,49.74 198.29,49.74 198.93,49.1 198.93,47.32 199.36,46.89 199.36,45.32 193.94,39.89 193.94,34.39 197,31.32 198.79,31.32 199.18,31.71 v1(199.18,32.08) ; v1(124.48,64.34) 124.19,64.63 CPU1.CE32 ; WLAN1.53 200.71,59.08 200.78,59.01 v1(200.78,58.98)
WLAN_EN#: length 265.9
  TOP w0.102: v2(171.29,32.9) 171.83,32.9 v1(171.88,32.84) ; v1(28.98,56.72) 28.42,57.28 27.78,57.28 27.38,56.87 Q6102.D 26.56,56.9 R6137.2 ; v1(218.79,56.59) 219.22,57.03 R6138.1
  L3 w0.102: v1(27.53,39.73) 27.53,40.11 28.04,40.62 28.04,44.43 27.88,44.58 27.88,47.09 28.19,47.4 28.19,49.66 28.7,50.17 28.7,54.41 28.98,54.68 v1(28.98,56.72)
  L6 w0.102: v1(171.88,32.84) 172.31,33.28 172.31,33.42 173.57,34.67 175.99,34.67 177.13,33.53 178.43,33.53 179.45,32.51 183.03,32.51 184.99,30.56 188.62,30.56 188.87,30.3 192.93,30.3 194.35,28.88 199.71,28.88 202.97,25.63 205.73,25.63 208.22,28.12 215.22,28.12 216,27.34 216,25.75 217.17,24.57 217.88,24.57 v1(218.05,24.74)
  BOTTOM w0.102: v1(218.05,24.74) 220.91,24.74 222.78,26.61 222.78,51.9 218.79,55.89 v1(218.79,56.59) ; v1(171.88,32.84) 171.24,32.2 154.81,32.2 154.05,31.45 118.13,31.45 61.56,31.45 57.63,35.38 51.62,35.38 51.55,35.46 51.53,35.46 50.39,36.6 49.04,36.6 48.86,36.78 45.11,36.78 44.47,37.42 43.28,37.42 43,37.13 43,36.83 42.72,36.55 39.92,36.55 38.08,38.39 35.8,38.39 35.48,38.71 31.28,38.71 30.19,39.8 29.56,39.8 28.87,39.12 28.26,39.12 27.65,39.73 v1(27.53,39.73)
WLAN_EN_R#: length 4
  TOP w0.102: R6138.2 220.21,57.58 v2(221,57.58) 221,57.97 C6104.2 220.49,59.11 220.64,59.26 v1(220.8,59.26)
  BOTTOM w0.102: Q6101.G 220.21,59.85 v1(220.8,59.26)
WLAN_PCIE_RX_N: length 118.4
  L4 w0.102: v1(203.04,63) 203.04,62.11 202.83,61.9 202.36,61.9 198.85,58.4 191.94,58.4 190.93,57.38 179.85,57.38 179.42,57.81 177.01,57.81 173.83,61 173.83,63.12 153.09,83.86 153.09,83.87 153,83.95 152.88,83.95 152.85,83.92 144.29,83.92 143.69,84.52 142.33,84.52 140.01,82.2 135.16,82.2 133.02,84.33 120.3,84.33 118.49,86.14 118.49,86.22 116.21,88.5 114.62,88.5 114.07,87.94 114.07,85.12 114.32,84.86 114.32,83.59 115.87,82.04 115.87,81.83 v1(116.45,81.24)
  BOTTOM w0.102: CPU1.BN6 116.78,80.92 116.46,81.24 v1(116.45,81.24) ; WLAN1.43 203.21,62.25 203.27,62.31 203.27,62.77 v1(203.04,63)
WLAN_PCIE_RX_P: length 118.3
  L4 w0.102: v1(116.45,81.88) 116.31,81.88 114.52,83.67 114.52,84.95 114.27,85.2 114.27,87.85 114.71,88.29 116.13,88.29 118.28,86.14 118.28,86.06 120.21,84.13 132.94,84.13 135.07,81.99 140.09,81.99 142.41,84.32 143.61,84.32 144.2,83.72 152.94,83.72 173.63,63.04 173.63,60.91 176.93,57.61 179.34,57.61 179.77,57.18 191.01,57.18 192.03,58.19 198.94,58.19 202.44,61.7 202.91,61.7 203.24,62.03 203.24,62.56 203.34,62.66 203.7,62.66 203.83,62.79 v1(203.83,63)
  BOTTOM w0.102: v1(116.45,81.88) 116.76,81.57 CPU1.BN5 ; WLAN1.41 203.71,62.2 203.5,62.41 203.5,62.82 203.68,63 v1(203.83,63)
WLAN_PCIE_TX_CON_N: length 1.4
  BOTTOM w0.102: C6107.1 204.71,62.37 WLAN1.37
WLAN_PCIE_TX_CON_P: length 1.4
  BOTTOM w0.102: WLAN1.35 205.21,62.29 C6108.1
WLAN_PCIE_TX_N: length 113.9
  L4 w0.102: v1(204.72,63.91) 204.72,63.53 204.82,63.43 205.05,63.43 205.15,63.32 205.15,62.56 202.13,59.54 202.13,58.68 201.24,57.79 192.4,57.79 191.38,56.77 179.6,56.77 179.17,57.2 176.75,57.2 173.2,60.76 173.2,62.32 164.81,70.7 164.81,71.28 152.78,83.31 144.03,83.31 142.05,81.33 137.23,81.33 137,81.56 134.85,81.56 132.49,83.92 118.01,83.92 116.96,84.97 116.96,85.8 117.08,85.91 117.25,85.91 v1(117.38,85.78)
  BOTTOM w0.076: v1(117.38,85.78) 117.38,85.86 117.45,85.94 117.59,85.94 117.77,85.75 117.77,84.71 117.63,84.57 117.61,84.5 117.6,84.46 117.6,84.16 117.6,84.15 117.63,84.01 117.63,83.87 117.6,83.71 117.6,83.53 117.6,83.48 117.62,83.42 117.65,83.36 117.65,83.35 117.78,82.92 117.78,82.42 117.84,82.33 117.99,82.29 CPU1.BR4
  BOTTOM w0.102: v1(204.72,63.91) 204.85,63.91 204.92,63.83 204.92,63.48 204.82,63.38 C6107.2
WLAN_PCIE_TX_P: length 113.8
  L4 w0.102: v1(205.35,63.91) 205.35,62.48 202.33,59.46 202.33,58.59 201.32,57.58 192.48,57.58 191.47,56.57 179.51,56.57 179.08,57 176.67,57 172.99,60.68 172.99,62.23 164.61,70.61 164.61,71.19 152.69,83.11 144.11,83.11 142.13,81.13 137.15,81.13 136.92,81.36 134.77,81.36 132.4,83.72 117.93,83.72 116.76,84.89 116.76,85.88 v1(117.29,86.41)
  BOTTOM w0.076: v1(117.29,86.41) 117.37,86.41 117.95,85.83 117.95,84.64 117.79,84.48 117.78,84.44 117.78,84.18 117.8,84.09 117.8,83.86 117.78,83.7 117.77,83.53 117.77,83.52 117.78,83.49 117.81,83.43 118.03,83.21 CPU1.BR3
  BOTTOM w0.102: C6108.2 205.38,63.88 v1(205.35,63.91)
XCLK_BIASREF: length 5.4
  BOTTOM w0.254: CPU1.CJ1 126.48,84.44 126.8,84.76 127.02,84.76 127.67,85.42 127.8,85.42 128.9,86.51 v2(128.9,87.25)
  BOTTOM w0.508: v2(128.9,87.25) 128.9,88.34 R1803.1
XDP_CLK_CPU_N: length 3.2
  BOTTOM w0.102: CPU1.AU1 106.95,86.24 TP1808.1
XDP_CLK_CPU_P: length 4.7
  BOTTOM w0.102: TP1807.1 105.48,87.1 106.6,85.98 106.6,84.13 106.95,83.77 CPU1.AU2
XDP_DBRESET#: length 13.7
  BOTTOM w0.076: 133.04,79.1 129.95,79.1 129.79,79.06 129.72,79.03 129.62,79.01 129.13,78.88 CPU1.CN10
  BOTTOM w0.102: R1701.2 139.77,75.69 EC6801.1 EC1706.1 138.07,75.72 TP9955.1 137.46,75.87 136.42,76.91 135.68,76.91 135.43,77.17 135.06,77.17 TP1706.1 134.28,77.95 134.28,78.39 133.98,78.69 133.45,78.69 133.04,79.1
XDP_PRDY#: length 4.8
  BOTTOM w0.102: CPU1.W1 96.11,84.31 96.11,85.14 95.24,86.01 95.24,87.33 TP306.1
XDP_PREQ#: length 4
  BOTTOM w0.102: CPU1.W2 96.13,83.62 96.36,83.85 96.36,85.32 95.6,86.08 TP305.1
XDP_TCK_JTAGX: length 12.5
  BOTTOM w0.089: CPU1.P6 92.26,81.48 92.26,81.59 92.19,81.67 92.19,81.69 92.02,81.85 92.01,81.85 91.47,82.39 91.47,82.43 91.44,82.46 91.44,84.08 91.46,84.1 91.46,84.41 91.28,84.58 91.21,84.58 90.95,84.84 90.95,85.04 90.7,85.3 90.49,85.3 88.61,87.18 v2(88.61,87.25) 88.6,87.25 88.51,87.34 88.51,87.4 88.56,87.45 88.56,88.42 89.53,89.39 R315.1 89,90.15 R9996.2
XDP_TCLK: length 15.3
  TOP w0.089: v1(93.29,81.14) 92.73,81.14 R317.1
  L4 w0.127: v1(89.34,82.1) 92.33,82.1 v1(93.29,81.14)
  BOTTOM w0.089: CPU1.T6 93.64,80.97 93.58,81 v1(93.29,81.14) ; R9996.1 88.77,89.13 v2(87.88,88.24) 87.88,87.4 90.04,85.25 90.04,84.81 90.15,84.7 90.15,82.43 90.15,82.12 90.06,82.03 89.99,82.03 89.4,82.03 v1(89.34,82.1)
XDP_TDI: length 19.4
  L4 w0.127: v1(84.56,83.58) 85.81,83.58 86.5,82.88 89.53,82.88 89.58,82.93 89.61,82.93 89.87,83.2 93.24,83.2 93.75,82.69 93.75,81.6 v1(94.21,81.14)
  BOTTOM w0.089: v1(84.56,83.58) 84.55,83.58 83.14,84.99 v2(83.14,87.56) R9995.1 83.14,90.22 R311.1 ; v1(94.21,81.14) CPU1.U6
XDP_TDO_CPU: length 18
  L4 w0.127: v1(96.06,81.79) 96.06,82.1 95.38,82.78 94.95,82.78 93.6,84.13 92.64,84.13 92.33,84.43 85.88,84.43 v1(85.53,84.79)
  BOTTOM w0.089: v1(85.53,84.79) 85.53,88.51 v2(85.62,88.6) 85.62,88.62 85.68,88.69 R9994.1 85.68,90.25 R310.1 ; v1(96.06,81.79) CPU1.Y5
XDP_TMS: length 12.2
  BOTTOM w0.089: CPU1.T5 93.34,81.98 93.34,82.2 93.34,83.44 93.16,83.62 92.87,83.62 92.56,83.93 92.56,84.09 92.58,84.1 92.58,84.43 92.42,84.58 92.02,84.58 89.45,87.15 89.45,87.79 90.14,88.47 v2(90.7,88.47) 90.88,88.65 R9992.1 91.22,89.7 R309.1
XDP_TRST#: length 3
  TOP w0.089: v2(96.56,81.44) 96.36,81.44 v1(96.06,81.14) 95.78,80.85 95.78,80.34
  BOTTOM w0.089: CPU1.AB6 CPU1.Y6 96.28,80.92 v1(96.06,81.14)
XTAL_KBC_2: length 2.2
  TOP w0.089: R2458.2 46.55,33.1 C2424.2 46.58,31.97 X2401.2
XTL_24M_X1_CPU: length 15.2
  L6 w0.089: v1(130.4,84.97) 130.4,84.46 130.6,84.25 132.76,84.25 135.91,81.1 135.91,80.62 v1(135.76,80.47)
  BOTTOM w0.089: R1839.1 135.78,78.62 135.2,79.2 135.2,80.14 v2(135.25,80.19) 135.53,80.47 v1(135.76,80.47) ; CPU1.CK3 127.71,83.11 127.71,83.43 127.95,83.68 127.95,84.03 127.88,84.11 127.88,84.38 128.08,84.58 129.99,84.58 130.37,84.97 v1(130.4,84.97)
XTL_24M_X1_R: length 5.2
  BOTTOM w0.089: R1839.2 137.48,78.62 C1807.2 138.32,78.74 R1841.1 138.47,78.67 139.26,77.88 140.8,77.88 X1801.1
XTL_24M_X2_CPU: length 14.3
  L6 w0.089: v1(136.39,80.44) 136.39,81.05 133.01,84.43 131.52,84.43 131.49,84.46 131.12,84.46 130.83,84.75 130.83,85.12 130.58,85.37 130.07,85.37 129.76,85.07 v1(129.76,84.99)
  BOTTOM w0.089: R1840.1 135.88,79.83 136.39,80.34 v1(136.39,80.44) ; v1(129.76,84.99) 129.76,84.95 129.6,84.79 127.96,84.79 127.5,84.33 127.5,84.13 127.16,83.79 CPU1.CK2
XTL_24M_X2_R: length 3.3
  BOTTOM w0.089: X1801.3 139.81,79.35 138.58,79.35 R1841.2 138.17,79.3 C1808.2 137.54,79.38 R1840.2
XTL_32K_X1_CPU: length 19
  TOP w0.089: v1(117.16,65.61) 117.14,65.59 117.14,65.56 116.8,65.22 116.8,65.12 116.79,65.12 116.79,64.78 117.07,64.51 117.07,62.95 116.4,62.28 115.77,62.28 115.41,61.93 115.41,59.64 115.03,59.26 114.24,59.26 113.66,58.68 113.66,55.55 v2(111.68,53.57) 111.68,53.24 111.75,53.16 R1815.1 C1804.1 111.07,52.43 111.01,52.37 X1802.1
  BOTTOM w0.089: v1(117.16,65.61) 117.05,65.61 CPU1.BN31
XTL_32K_X2_CPU: length 17.8
  TOP w0.089: X1802.2 113.47,52.52 C1803.1 R1815.2 112.62,53.29 v2(112.9,53.57) 112.9,54.18 113.91,55.2 113.91,58.55 114.29,58.93 115.08,58.93 115.7,59.55 115.7,61.79 115.95,62.03 116.63,62.03 117.27,62.66 117.27,64.57 117.19,64.65 v1(117.19,64.95)
  BOTTOM w0.089: v1(117.19,64.95) 116.87,64.63 CPU1.BN32
N198396033: length 11.4
  TOP w0.102: v1(207.18,24.08) 207.18,24.31 v2(207.69,24.82) 208.3,24.82 208.77,24.34 211.24,24.34 R2505.1
  BOTTOM w0.102: v1(207.18,24.08) 206.55,24.08 206.27,24.36 201.14,24.36 Q2510.D
N203186882: length 14.3
  BOTTOM w0.102: R4020.2 161.18,73.71 R4018.2 161.87,73.39 161.87,74.1 162.52,74.74 163.17,74.74 163.37,74.54 U4007.2 163.37,73.59 162.3,72.52 162.3,71.96 161.92,71.58 v2(161.92,71.22) 161.94,71.2 162.81,71.2 163.24,71.63 163.24,72.19 163.57,72.52 165.78,72.52 R4034.2 R4008.2
N203399166:
  vias: v2(163.14,66.17)
N210032824: length 3.5
  TOP w0.508: v1(207.13,10.37) 207.02,10.25 206.92,10.25 206.88,10.21 v2(206.25,10.21) 205.86,10.59 R2506.2
  BOTTOM w0.508: v1(207.13,10.37) 206.57,10.37 206.06,10.87 RTC1.1

## Copper pours and planes (outline as drawn)
1.8V_RUN_FB on BOTTOM: 84.73,12.73 84.47,12.98 84.47,14.07 84.53,14.13 85.8,14.13 86.02,13.9 87.6,13.9 87.62,13.87 87.62,13.29 87.57,13.24 86.25,13.24 85.74,12.73 ; 3 cut-outs
1V_1D8V_VGA_S0 on TOP: 178.3,83.52 177.97,83.85 177.97,84.15 178.23,84.41 178.23,84.91 177.97,85.17 177.97,85.3 178.23,85.55 178.23,85.93 177.95,86.21 177.95,86.21 177.33,86.83 177.33,87.09 178.56,88.32 178.56,88.67 177.97,89.26 177.97,89.44 178.48,89.94 178.48,90.6 180.82,92.95 180.82,92.97 180.82,92.97 180.82,93.63 181.2,94.01 181.3,94.01 182.09,93.22 182.09,92.97 181.53,92.41 181.53,91.9 181.91,91.52 182.29,91.52 182.54,91.77 182.67,91.77 183.97,90.48 183.97,90.17 183.48,89.69 183.28,89.69 182.54,90.43 182.19,90.43 178.72,86.96 178.72,84.9 179.19,84.43 179.19,84.13 178.58,83.52 ; 6 cut-outs
1V_1D8V_VGA_S0 on BOTTOM: 177.59,85.78 177.36,86.01 177.36,86.54 179.1,88.28 179.1,88.84 179.22,88.95 179.52,88.95 179.67,88.8 179.67,88.43 179.83,88.28 180.07,88.28 180.87,89.08 180.87,90.4 181.17,90.71 181.43,90.71 181.87,91.15 181.87,91.46 182.35,91.94 182.76,91.94 183.19,92.37 183.19,92.52 183.21,92.53 183.21,92.71 182.85,93.07 182.85,93.58 183.7,94.43 182.29,95.84 182.29,96.47 183.69,97.87 183.69,98.96 183.61,99.04 183.61,101.09 181.91,102.8 180.54,102.8 180.36,102.97 180.36,103.71 180.49,103.84 181.58,103.84 181.83,104.09 182.82,104.09 183.08,104.35 183.64,104.35 184.53,103.46 184.53,99.85 184.89,99.48 184.89,98.97 184.88,98.96 184.88,98.83 184.82,98.77 184.82,98.64 184.37,98.2 184.37,93.07 184.75,92.69 184.75,92.2 184.37,91.82 184.37,91.32 179.25,86.2 179.03,86.2 178.61,85.78 ; 3 cut-outs
1V_1D8V_VGA_S0 on L3: 182.34,104.07 182.8,103.61 182.8,102.72 182.79,102.71 182.79,102.12 181.32,100.66 181.32,98.96 180.11,97.74 180.11,97.08 181.3,95.89 181.3,93.02 182.67,91.65 183.05,91.65 183.31,91.9 183.56,91.9 183.81,91.65 183.81,90.88 182.42,89.49 182.42,89.44 179.29,86.31 177.72,86.31 177.46,86.57 177.46,88.09 177.72,88.34 177.77,88.34 178.66,89.23 178.66,96.62 178,97.28 178,99.57 178.47,100.04 178.47,102.68 179.85,104.07
1V_1D8V_VGA_S0 on L4: 183.81,91.52 183.56,91.26 183.31,91.26 182.8,91.77 182.8,97.74 180.89,99.65 180.89,103.46 181.53,104.09 182.42,104.09 183.24,103.27 183.24,99.58 183.81,99.01
1V_CPU_CORE on TOP: outline of 93 points within 62.45,67.31 112.69,92.87 ; 68 cut-outs
1V_CPU_CORE on BOTTOM: 104.34,77.85 104.18,78.01 104.18,79.23 104.39,79.43 105.1,79.43 105.28,79.61 105.28,81.82 105.51,82.04 111.27,82.04 111.53,81.79 111.53,79.73 111.86,79.4 112.8,79.4 112.9,79.3 112.9,78.69 112.44,78.23 112.44,78.08 112.21,77.85
1V_CPU_CORE on BOTTOM: 63.06,70.89 62.87,71.08 62.87,75.68 63.49,76.3 64.66,76.3 64.94,76.58 64.94,78.13 64.64,78.44 63.47,78.44 62.78,79.12 62.78,84.58 63.84,85.64 64.47,85.64 65.04,86.21 65.04,86.46 65.09,86.52 65.96,86.52 66.11,86.36 66.11,83.29 66.49,82.91 71.42,82.91 72.26,82.07 72.26,73.99 71.67,73.41 66.82,73.41 66.21,72.8 66.21,71.33 65.78,70.89 ; 1 cut-out
1V_CPU_CORE on BOTTOM: 104.29,67.36 104.16,67.49 104.16,67.74 104.3,67.88 104.3,70.17 104.44,70.31 112.44,70.31 112.82,69.93 112.82,68.56 113.2,68.18 113.2,67.72 112.85,67.36
1V_CPU_CORE on L3: 92.12,82.65 93.01,81.77 93.01,80.32 93.75,79.58 97.38,79.58 97.78,79.17 101.04,79.17 101.44,79.58 103.75,79.58 107,76.33 108.71,76.33 108.96,76.08 110.74,76.08 111.02,75.8 111.02,71.2 111.7,70.51 111.7,69.7 111.5,69.5 104.41,69.5 104.21,69.7 104.21,69.95 103.4,70.77 101.54,70.77 101.24,70.46 101.24,69.42 100.68,68.86 93.54,68.86 89.99,72.42 83.53,72.42 82.52,73.43 74.19,73.43 72.94,72.19 64.87,72.19 63.19,73.87 63.19,82.02 65.68,84.51 71.04,84.51 74.06,81.49 79.27,81.49 80.44,82.65
1V_CPU_CORE on L4: 65.12,83.95 70.4,83.95 74.01,80.34 81.63,80.34 83.61,82.32 90.04,82.32 92.91,79.45 104.16,79.45 107.28,76.33 110.48,76.33 111.02,75.8 111.02,71.15 111.58,70.59 111.58,69.55 111.45,69.42 104.06,69.42 103.04,70.44 101.9,70.44 101.89,70.42 100.62,70.42 99.89,71.15 99.89,74.98 98.95,75.92 91.99,75.92 89.73,73.66 84.58,73.66 83.94,73.03 74.62,73.03 72.51,70.92 63.8,70.92 63.19,71.53 63.19,82.02
