# Allegro board 17859-1.0710WZS1337.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R2448  10KR2F-2-GP  [R402H16]  51.96 48.64 0 top
R2449  100KR2J-1-GP  [R402H16]  28.83 48.27 270 top
R2450  100KR2J-1-GP  [R402H16]  28.83 47.47 90 top
R2451  100KR2J-1-GP  [R402H16]  51.38 31.98 90 top
R2452  100KR2J-1-GP  [R402H16]  49.04 31.88 270 top
R2453  1KR2J-1-GP  [R402H16]  42.02 30.33 180 top
R2455  100KR2J-1-GP  [R402H16]  41.25 30.33 0 top
R2458  0R0402-PAD-2-GP  [0R0402-PAD-1]  45.49 33.1 90 top
R2462  0R0402-PAD-2-GP  [0R0402-PAD-1]  39.44 54.84 0 top
R2467  0R2J-L-GP  [R402H15]  28.19 48.87 0 bottom
R2468  0R2J-L-GP  [R402H15]  24.86 49.91 180 bottom
R2469  0R0402-PAD-2-GP  [0R0402-PAD-1]  48.61 34.93 0 top
R2470  0R0402-PAD-2-GP  [0R0402-PAD-1]  50.59 45.85 90 top
R2472  0R0402-PAD-2-GP  [0R0402-PAD-1]  50.16 29.7 180 top
R2473  0R2J-L-GP  [R402H15]  49.35 29.72 180 top
R2474  0R0402-PAD-2-GP  [0R0402-PAD-1]  37.66 33.18 0 top
R2475  10KR2J-3-GP  [R402H16]  24.43 34.78 90 top
R2476  0R2J-2-GP  [R402H16]  56.56 38.81 270 top
R2477  0R2J-L-GP  [R402H15]  56.33 48.03 270 top
R2478  100KR2J-1-GP  [R402H16]  28.62 44.02 90 top
R2479  0R0402-PAD-2-GP  [0R0402-PAD-1]  51.68 42.78 90 top
R2480  0R0402-PAD-2-GP  [0R0402-PAD-1]  57.19 47.27 90 top
R2483  330R2J-3-GP  [R402H16]  31.29 34.27 0 top
R2489  100KR2J-1-GP  [R402H16]  27.93 37.21 90 top
R2490  10KR2F-2-GP  [R402H16]  52.34 45.93 270 top
R2491  0R0402-PAD-2-GP  [0R0402-PAD-1]  50.16 36.6 270 top
R2497  100KR2J-1-GP  [R402H16]  41.85 55.83 0 top
R2501  4K7R2J-2-GP  [R402H16]  189.02 37.42 0 top
R2502  0R2J-L-GP  [R402H15]  213.1 21.82 270 top
R2503  47KR2F-GP  [R402H16]  213.1 22.58 270 top
R2504  10MR2J-L-GP  [R402H16]  206.29 11.92 270 top
R2505  4K7R2J-2-GP  [R402H16]  211.91 24.11 90 top
R2506  1KR2J-1-GP  [R402H16]  206.29 11.1 270 top
R2507  33R2J-2-GP  [R402H16]  190.47 32.59 270 top
R2511  0R5J-5-GP  [R805H24]  210.69 30.38 90 top
R2512  0R2J-2-GP  [R402H16]  211.42 21.82 270 top
R2513  0R2J-2-GP  [R402H16]  208.96 25.48 180 top
R2514  10KR2J-3-GP  [R402H16]  208.96 27.26 0 top
R2515  0R0402-PAD-2-GP  [0R0402-PAD-1]  189.53 38.69 90 top
R2516  0R0805-PAD-2-GP-U  [0R0805-PAD-1-U]  212.24 28.55 90 top
R2517  0R2J-2-GP  [R402H16]  184.47 38.53 90 top
R2518  100KR2J-1-GP  [R402H16]  208.76 19.99 180 top
R2520  100KR2J-1-GP  [R402H16]  214.29 25.48 0 top
R2567  1MR2J-1-GP  [R402H16]  209.65 19.99 180 top
R2568  33R2J-2-GP  [R402H16]  190.47 34.17 90 top
R2569  33R2J-2-GP  [R402H16]  190.47 33.38 90 top
R2570  33R2J-2-GP  [R402H16]  186.73 35.16 0 top
R2571  33R2J-2-GP  [R402H16]  185.97 35.16 0 top
R2601  0R2J-2-GP  [R402H16]  169.23 104.47 90 top
R2602  0R0402-PAD-2-GP  [0R0402-PAD-1]  24.81 39.07 180 top
R2603  7K5R2F-1-GP  [R402H16]  164.89 105.87 270 top
R2604  7K5R2F-1-GP  [R402H16]  167.56 104.47 90 top
R2607  10KR2J-3-GP  [R402H16]  25.57 39.07 180 top
R2608  27KR2F-L-GP  [R402H16]  57.98 44.17 180 top
R2609  10R2F-L-GP  [R402H14]  58.74 44.17 180 top
R2610  NTC-100K-8-GP  [NTC-603H38]  67.84 88.37 270 bottom
R2611  0R0402-PAD-2-GP  [0R0402-PAD-1]  60.12 44.63 90 top
R2612  0R0402-PAD-2-GP  [0R0402-PAD-1]  219.37 65.05 270 top
R2615  0R2J-2-GP  [R402H16]  25.44 40.85 0 top
R2616  0R2J-L-GP  [R402H15]  21.43 44.81 0 top
R2617  0R0402-PAD-2-GP  [0R0402-PAD-1]  22.22 44.81 0 top
R2701  0R0805-PAD-2-GP-U  [0R0805-PAD-1-U]  28.87 10.95 90 bottom
R2702  100KR2J-1-GP  [R402H16]  19.65 21.11 0 bottom
R2703  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  16.68 22.68 180 top
R2704  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  14.95 9.91 90 top
R2705  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  14.95 8.64 90 top
R2706  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  22.22 12.42 180 bottom
R2707  0R0805-PAD-2-GP-U  [0R0805-PAD-1-U]  28.87 9.15 90 bottom
R2708  0R0402-PAD-2-GP  [0R0402-PAD-1]  21.79 23.29 180 bottom
R2709  0R0402-PAD-2-GP  [0R0402-PAD-1]  20.16 15.19 0 bottom
R2710  100KR2J-1-GP  [R402H16]  23.29 21.82 180 bottom
R2711  200KR2F-L-GP  [R402H16]  22.5 21.16 180 bottom
R2712  0R0402-PAD-2-GP  [0R0402-PAD-1]  30.55 14.96 180 bottom
R2713  0R0805-PAD-2-GP-U  [0R0805-PAD-1-U]  25.85 9.63 90 bottom
R2714  0R0805-PAD-2-GP-U  [0R0805-PAD-1-U]  29.1 13.36 0 bottom
R2715  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  28.9 20.02 0 top
R2716  100KR2J-1-GP  [R402H16]  27.81 20.04 0 top
R2717  100KR2J-1-GP  [R402H16]  28.75 15.45 270 bottom
R2719  0R0402-PAD-2-GP  [0R0402-PAD-1]  19.83 13.49 180 bottom
R2722  0R0402-PAD-2-GP  [0R0402-PAD-1]  32.02 12.63 270 top
R2723  22R2J-2-GP  [R402H16]  32.02 13.39 270 top
R2724  22R2J-2-GP  [R402H16]  31.92 15.5 270 top
R2734  0R0402-PAD-2-GP  [0R0402-PAD-1]  26.79 25.1 180 bottom
R2735  1KR2J-1-GP  [R402H16]  26.13 21.16 90 top
R2736  10KR2J-L-GP  [R402H15]  59.51 50.27 270 top
R2737  0R2J-2-GP  [R402H16]  58.13 53.52 270 top
R2738  4K7R2J-2-GP  [R402H16]  59.51 49.51 90 top
R2740  0R0402-PAD-2-GP  [0R0402-PAD-1]  53.72 55.15 90 top
R2741  0R0402-PAD-2-GP  [0R0402-PAD-1]  24.53 23.22 270 bottom
R2901  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  24 6.61 180 top
R2902  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  22.4 6.66 180 top
R2903  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  25.39 6.61 180 top
R2904  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  26.92 6.61 180 top
R2906  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  14.32 4.07 270 top
R2907  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  14.57 8.89 180 bottom
R2908  10R2F-L1-GP  [R402H16]  17.7 18.19 270 top
R2909  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  13.58 6.45 0 top
R2910  10R2F-L1-GP  [R402H16]  16.1 16.94 270 top
R2911  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  14.22 11.89 90 bottom
R2912  4K7R2J-2-GP  [R402H16]  16.1 16.16 90 top
R2913  4K7R2J-2-GP  [R402H16]  17.7 17.33 90 top
R2914  0R0402-PAD-2-GP  [0R0402-PAD-1]  14.04 12.14 270 top
R2919  10KR2J-L-GP  [R402H15]  13.33 10.34 0 bottom
R2920  10KR2J-L-GP  [R402H15]  13.96 5.95 270 bottom
R2921  1KR2J-1-GP  [R402H16]  20.52 23.09 270 top
R2922  1KR2J-1-GP  [R402H16]  18.71 23.02 270 top
R2923  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  16.07 12.83 90 top
R3432  0R0402-PAD-2-GP  [0R0402-PAD-1]  196.44 16.54 90 top
R3501  0R0402-PAD-2-GP  [0R0402-PAD-1]  19.73 27.59 270 top
R3502  0R0402-PAD-2-GP  [0R0402-PAD-1]  19.73 26.83 270 top
R3503  0R0402-PAD-2-GP  [0R0402-PAD-1]  19.76 25.86 270 top
R3504  0R0402-PAD-2-GP  [0R0402-PAD-1]  19.76 25.1 270 top
R3509  0R5J-5-GP  [R805H24]  21.33 48.88 270 bottom
R3510  0R5J-5-GP  [R805H24]  21.33 50.75 270 bottom
R3512  0R0402-PAD-2-GP  [0R0402-PAD-1]  20.47 55.73 270 bottom
R3521  0R0402-PAD-2-GP  [0R0402-PAD-1]  19.07 43.89 90 bottom
R3522  0R0402-PAD-2-GP  [0R0402-PAD-1]  19.07 43.13 90 bottom
R3524  0R0402-PAD-2-GP  [0R0402-PAD-1]  19.07 45.42 90 bottom
R3533  0R0402-PAD-2-GP  [0R0402-PAD-1]  19.07 44.66 90 bottom
R3601  0R2J-2-GP  [R402H16]  17.22 32.01 270 bottom
R3602  0R2J-2-GP  [R402H16]  18.38 35.77 270 bottom
R3603  20KR2F-L-GP  [R402H16]  21.76 33.35 90 top
R3604  22K1R2F-L-GP  [R402H16]  21.76 32.59 90 top
R3605  0R2J-2-GP  [R402H16]  17.44 30.13 270 bottom
R3606  0R2J-2-GP  [R402H16]  16.83 33.2 180 bottom
R3607  0R2J-2-GP  [R402H16]  18.64 32.74 0 top
R3608  0R2J-2-GP  [R402H16]  19.4 32.74 0 top
R4002  0R0402-PAD-2-GP  [0R0402-PAD-1]  39.64 63.25 270 top
R4003  10KR2J-3-GP  [R402H16]  165.93 71.12 180 bottom
R4004  100KR2J-1-GP  [R402H16]  215.44 45.8 90 top
R4005  1KR2J-1-GP  [R402H16]  43.72 58.77 90 top
R4006  20KR2J-L2-GP  [R402H16]  205.89 55.65 180 top
R4007  0R2J-L-GP  [R402H15]  204.69 53.95 0 top
R4008  20KR2J-L2-GP  [R402H16]  166.69 71.96 0 bottom
R4009  10KR2J-3-GP  [R402H16]  205.86 53.85 90 top
R4010  0R2J-2-GP  [R402H16]  211.45 45.42 270 top
R4011  0R0402-PAD-2-GP  [0R0402-PAD-1]  43.72 57.98 90 top
R4017  0R2J-L-GP  [R402H15]  160.95 69.93 180 bottom
R4018  0R2J-L-GP  [R402H15]  161.26 73.21 270 bottom
R4019  10KR2J-3-GP  [R402H16]  214.17 41.86 0 top
R4020  0R2J-L-GP  [R402H15]  159.56 73.71 270 bottom
R4024  0R2J-L-GP  [R402H15]  108.55 100.92 270 bottom
R4029  0R0402-PAD-2-GP  [0R0402-PAD-1]  204.38 44.93 180 top
R4030  0R0402-PAD-2-GP  [0R0402-PAD-1]  203.59 44.93 180 top
R4031  100KR2J-1-GP  [R402H16]  202.81 44.94 180 top
R4032  100KR2J-1-GP  [R402H16]  205.17 44.93 180 top
R4033  0R2J-2-GP  [R402H16]  201.97 45.93 180 top
R4034  20KR2J-L2-GP  [R402H16]  165.91 72.82 180 bottom
R4036  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  107.94 103.15 180 bottom
R4037  0R2J-L-GP  [R402H15]  164.79 70.23 180 bottom
R4038  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  162.25 57.81 270 bottom
R4039  0R2J-L-GP  [R402H15]  164.79 68.66 180 bottom
R4040  0R2J-L-GP  [R402H15]  164.15 67.19 90 bottom
R4043  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  162.66 67.97 0 bottom
R4046  D01R6F-3-GP  [R1206H26]  159 59.16 180 bottom
R4048  10KR2J-3-GP  [R402H16]  213.94 46.15 180 top
R4301  0R0402-PAD-2-GP  [0R0402-PAD-1]  109.49 13.08 225 top
R4302  15KR2F-GP  [R402H16]  23.51 98.15 180 top
R4303  10KR2J-3-GP  [R402H16]  17.42 98.86 90 bottom
R4304  2K2R2J-2-GP  [R402H16]  49.68 51.69 0 top
R4305  33R2J-2-GP  [R402H16]  49.63 49.99 180 top
R4306  33R2J-2-GP  [R402H16]  23.41 96.45 180 top
R4307  240KR3-GP  [R603H22]  28.29 89 0 top
R4308  47KR2F-GP  [R402H16]  29.97 85.47 270 bottom
R4309  100KR2J-1-GP  [R402H16]  24.17 96.45 180 top
R4310  100R2J-L-GP  [R402H15]  113.91 12.01 180 top
R4311  100KR2F-L1-GP  [R402H16]  39.06 83.24 0 top
R4315  18K7R2F-GP  [R402H16]  41.27 83.62 0 top
R4316  20KR2J-L2-GP  [R402H16]  38.37 86.46 180 top
R4317  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  27.71 97.95 180 top
R4318  100KR2J-1-GP  [R402H16]  41.37 77.9 180 top
R4333  10KR2F-2-GP  [R402H16]  41.07 79.89 90 top
R4368  0R0402-PAD-2-GP  [0R0402-PAD-1]  41.07 80.65 270 top
R4369  100KR2F-L1-GP  [R402H16]  32.53 77.37 90 bottom
R4370  100KR2F-L1-GP  [R402H16]  40.58 77.9 180 top
R4376  470KR2F-GP  [R402H16]  36.89 83.24 180 bottom
R4377  84K5R2F-GP  [R402H16]  36.09 82.55 180 bottom
R4378  100KR2J-1-GP  [R402H16]  37.69 80.37 270 bottom
R4379  1KR2F-3-GP  [R402H16]  26.79 79.33 90 bottom
R5502  33R2F-3-GP  [R402H16]  50.47 89.38 0 bottom
R5503  33R2F-3-GP  [R402H16]  49.66 89.38 0 bottom
R5506  100KR2J-1-GP  [R402H16]  40.79 78.18 0 bottom
R5518  100R2J-2-GP  [R402H14]  40.43 85.78 0 bottom
R5523  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  39.03 86.36 180 bottom
R5524  0R2J-2-GP  [R402H16]  45.38 84.69 180 bottom
R5528  100KR2J-1-GP  [R402H16]  41.24 89.84 90 bottom
R5529  100KR2J-1-GP  [R402H16]  42.95 89.84 270 bottom
R5530  0R0402-PAD-2-GP  [0R0402-PAD-1]  44.57 84.69 0 bottom
R5531  0R0402-PAD-2-GP  [0R0402-PAD-1]  51.91 89.94 0 top
R5537  0R2J-2-GP  [R402H16]  54.86 85.07 0 bottom
R5538  0R2J-2-GP  [R402H16]  52.55 87.43 0 bottom
R5547  10KR2F-2-GP  [R402H16]  60.57 87.68 270 top
R5548  31K6R2F-GP  [R402H16]  61 88.98 0 top
R5551  10KR2J-3-GP  [R402H16]  57.83 86.67 270 bottom
R5553  10KR2J-3-GP  [R402H16]  58.31 87.43 270 bottom
R5554  10KR2J-3-GP  [R402H16]  55.65 86.16 0 bottom
R5555  10KR2J-3-GP  [R402H16]  56.43 86.16 0 bottom
R5556  33R2F-3-GP  [R402H16]  49.6 89.41 90 top
R5557  33R2F-3-GP  [R402H16]  49.6 88.65 90 top
R5558  0R3J-L1-GP  [R603H22]  63.04 93.8 0 bottom
R5559  0R0805-PAD-2-GP-U  [0R0805-PAD-1-U]  63.88 95.89 90 bottom
R5560  0R0805-PAD-2-GP-U  [0R0805-PAD-1-U]  59.71 90.1 180 top
R5707  0R2J-2-GP  [R402H16]  22.55 54.87 0 top
R5709  100KR2J-1-GP  [R402H16]  18.84 69.04 0 top
R5710  150KR2F-L-GP  [R402H16]  14.52 72.21 270 top
R5711  200KR2F-L-GP  [R402H16]  14.52 72.98 90 top
R5712  0R0402-PAD-2-GP  [0R0402-PAD-1]  18.08 69.04 180 top
R5713  0R0402-PAD-2-GP  [0R0402-PAD-1]  17.88 62.46 90 bottom
R5714  0R0402-PAD-2-GP  [0R0402-PAD-1]  17.88 61.7 90 bottom
R5715  0R0402-PAD-2-GP  [0R0402-PAD-1]  17.88 59.06 90 bottom
R5716  0R0402-PAD-2-GP  [0R0402-PAD-1]  17.88 58.3 90 bottom
R5717  0R0402-PAD-2-GP  [0R0402-PAD-1]  17.88 57.23 90 bottom
R5720  0R0402-PAD-2-GP  [0R0402-PAD-1]  17.88 56.47 90 bottom
R5721  0R0402-PAD-2-GP  [0R0402-PAD-1]  17.88 60.73 90 bottom
R5722  0R0402-PAD-2-GP  [0R0402-PAD-1]  17.88 59.97 90 bottom
R6001  0R0805-PAD-2-GP-U  [0R0805-PAD-1-U]  186.51 12.12 90 top
R6002  0R0402-PAD-2-GP  [0R0402-PAD-1]  190.7 12.07 0 top
R6016  0R0402-PAD-2-GP  [0R0402-PAD-1]  189.33 11.64 270 top
R6102  10KR2J-3-GP  [R402H16]  203.24 56.85 0 top
R6105  0R0402-PAD-2-GP  [0R0402-PAD-1]  195.68 58.07 0 top
R6109  22R2J-2-GP  [R402H16]  206.19 50.29 180 top
R6110  0R0402-PAD-2-GP  [0R0402-PAD-1]  208.32 60.43 270 top
R6111  0R0402-PAD-2-GP  [0R0402-PAD-1]  208.32 59.64 270 top
R6113  0R2J-L-GP  [R402H15]  202.41 57.08 180 top
R6114  0R2J-L-GP  [R402H15]  198.09 57.18 180 top
R6115  20KR2J-L2-GP  [R402H16]  204.67 52.71 90 top
R6118  22R2J-2-GP  [R402H16]  208.05 52.81 180 top
R6119  0R0402-PAD-2-GP  [0R0402-PAD-1]  211.98 63.05 0 bottom
R6120  0R0402-PAD-2-GP  [0R0402-PAD-1]  211.2 63.05 0 bottom
R6121  0R0402-PAD-2-GP  [0R0402-PAD-1]  210.43 63.05 0 bottom
R6122  0R0402-PAD-2-GP  [0R0402-PAD-1]  209.67 63.05 0 bottom
R6123  0R0402-PAD-2-GP  [0R0402-PAD-1]  208.88 63.05 0 bottom
R6124  0R0402-PAD-2-GP  [0R0402-PAD-1]  208.12 63.05 0 bottom
R6125  0R0402-PAD-2-GP  [0R0402-PAD-1]  199.43 63.02 0 bottom
R6126  0R0402-PAD-2-GP  [0R0402-PAD-1]  198.67 63.02 0 bottom
R6127  0R0402-PAD-2-GP  [0R0402-PAD-1]  197.91 63.02 0 bottom
R6128  0R0402-PAD-2-GP  [0R0402-PAD-1]  197.15 63.02 0 bottom
R6129  0R0402-PAD-2-GP  [0R0402-PAD-1]  196.39 63.02 0 bottom
R6130  0R0402-PAD-2-GP  [0R0402-PAD-1]  195.62 63.02 0 bottom
R6133  71K5R2F-1-GP  [R402H16]  210.99 52.25 90 top
R6134  75KR2F-GP  [R402H16]  145.59 63.55 180 top
R6135  33R2J-2-GP  [R402H16]  201.85 50.57 180 top
R6136  0R2J-L-GP  [R402H15]  29.61 55.68 180 top
R6137  10KR2J-3-GP  [R402H16]  26.13 59.11 90 top
R6138  20KR2J-L2-GP  [R402H16]  219.65 57.71 90 top
R6140  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  213.96 49.84 270 top
R6142  10KR2J-3-GP  [R402H16]  198.37 53.19 180 top
R6143  0R3J-0-U-GP  [R603H22]  213.96 51.11 270 top
R6301  0R0402-PAD-2-GP  [0R0402-PAD-1]  219.68 7.24 180 top
R6302  0R0805-PAD-2-GP-U  [0R0805-PAD-1-U]  221.46 20.5 270 top
R6303  10KR2J-3-GP  [R402H16]  218.76 5.44 180 top
R6304  10KR2J-3-GP  [R402H16]  220.03 5.95 90 top
R6308  0R0402-PAD-2-GP  [0R0402-PAD-1]  218.18 8.66 180 top
R6311  0R2J-L-GP  [R402H15]  201.57 18.43 0 bottom
R6312  0R2J-L-GP  [R402H15]  202.33 18.43 0 bottom
R6313  0R2J-L-GP  [R402H15]  200.25 19.22 0 bottom
R6314  0R2J-L-GP  [R402H15]  197.83 19.22 0 bottom
R6315  0R2J-L-GP  [R402H15]  203.09 17.5 180 bottom
R6316  0R2J-L-GP  [R402H15]  200.81 17.48 180 bottom
R6317  0R2J-L-GP  [R402H15]  199.45 19.21 0 bottom
R6318  0R2J-L-GP  [R402H15]  198.6 19.22 0 bottom
R6339  100KR2F-L1-GP  [R402H16]  209.72 5.67 270 top
R6401  10KR2J-3-GP  [R402H16]  20.57 96.37 270 bottom
R6402  10KR2J-3-GP  [R402H16]  20.57 87.84 90 bottom
R6404  0R0402-PAD-2-GP  [0R0402-PAD-1]  23.31 99.39 90 top
R6405  0R0402-PAD-2-GP  [0R0402-PAD-1]  20.24 97.13 270 top
R6406  549R2F-GP  [R402H16]  11.68 94.82 0 top
R6407  499R2F-2-GP  [R402H16]  9.95 92.41 270 top
R6408  0R2J-2-GP  [R402H16]  18.31 91.57 0 bottom
R6419  0R2J-L-GP  [R402H15]  32.46 59.79 90 top
R6502  10KR2J-3-GP  [R402H16]  173.73 11.43 270 top
R6503  51KR2J-1-GP  [R402H16]  101.11 14.07 90 bottom
R6504  0R3J-0-U-GP  [R603H22]  97.55 14.48 180 bottom
R6505  100KR2J-1-GP  [R402H16]  104.34 13.85 270 bottom
R6506  1KR2J-1-GP  [R402H16]  95.04 13.44 270 bottom
R6507  100KR2J-1-GP  [R402H16]  101.44 14.53 180 top
R6508  0R0402-PAD-2-GP  [0R0402-PAD-1]  97.48 16.72 180 bottom
R6509  100KR2J-1-GP  [R402H16]  179.06 9.6 0 top
R6511  0R2J-2-GP  [R402H16]  177.44 8.33 180 top
R6512  0R0402-PAD-2-GP  [0R0402-PAD-1]  181.43 16.51 270 top
R6513  4K7R2J-2-GP  [R402H16]  180.61 7.47 180 top
R6515  0R2J-2-GP  [R402H16]  175.33 9.88 90 top
R6516  1KR2J-1-GP  [R402H16]  174.47 15.34 270 top
R6517  0R3J-0-U-GP  [R603H22]  175.41 6.58 90 top
R6518  0R2J-2-GP  [R402H16]  175.33 10.65 90 top
R6519  0R2J-2-GP  [R402H16]  176.83 12.25 270 top
R6521  0R2J-2-GP  [R402H16]  172.74 13.95 180 top
R6522  100R3J-4-GP  [R603H22]  178.81 7.27 0 top
R6601  0R2J-L-GP  [R402H15]  217.65 42.88 270 top
R6602  0R2J-L-GP  [R402H15]  217.65 42.12 270 top
R6801  0R2J-2-GP  [R402H16]  32.56 53.29 180 top
R6802  0R2J-2-GP  [R402H16]  31.79 53.29 180 top
R6803  0R2J-2-GP  [R402H16]  31.03 53.29 180 top
R7002  0R2J-2-GP  [R402H16]  217.77 59.24 90 top
R7003  0R2J-2-GP  [R402H16]  217.77 58.35 90 top
R7004  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  167.56 57.23 270 top
R7005  10KR2J-3-GP  [R402H16]  167.66 49.89 180 top
R7006  10KR2J-3-GP  [R402H16]  166.9 49.89 0 top
R7007  0R0402-PAD-2-GP  [0R0402-PAD-1]  168.57 49.61 180 top
R7008  0R2J-2-GP  [R402H16]  216.3 59.08 0 top
R7009  0R2J-2-GP  [R402H16]  164.74 52.05 90 top
R7010  0R2J-2-GP  [R402H16]  164.74 53.83 90 top
R7011  0R2J-2-GP  [R402H16]  164.74 52.94 90 top
R7012  0R2J-2-GP  [R402H16]  164.74 54.61 90 top
R7013  0R2J-2-GP  [R402H16]  164.74 51.16 90 top
R7014  0R2J-2-GP  [R402H16]  170.25 50.9 270 top
R7018  100KR2J-1-GP  [R402H16]  214.27 60.99 180 top
R7218  0R2J-2-GP  [R402H16]  76.45 97.13 90 bottom
R7219  0R2J-2-GP  [R402H16]  74.82 96.47 90 bottom
R7220  1MR2J-1-GP  [R402H16]  78.2 105.39 180 top
R7221  100KR2J-1-GP  [R402H16]  78.28 95.49 180 bottom
R7222  1MR2J-1-GP  [R402H16]  70.99 101.48 270 top
R7223  1MR2J-1-GP  [R402H16]  70.99 99.47 270 top
R7224  0R2J-2-GP  [R402H16]  71.16 103.94 270 top
R7225  0R2J-2-GP  [R402H16]  73.81 104.85 270 top
R7226  1MR2J-1-GP  [R402H16]  78.99 105.39 180 top
R7229  0R2J-2-GP  [R402H16]  69.74 100.46 0 top
R7230  0R2J-L-GP  [R402H15]  75.81 93.22 0 top
R7231  0R2J-L-GP  [R402H15]  75.05 93.5 0 top
R7232  0R2J-2-GP  [R402H16]  83.74 98.88 90 bottom
R7233  0R2J-2-GP  [R402H16]  73.17 97.18 0 bottom
R7234  0R2J-L-GP  [R402H15]  74.29 93.5 180 top
R7235  0R2J-L-GP  [R402H15]  73.53 93.5 180 top
R7236  0R2J-2-GP  [R402H16]  72.36 93.45 270 top
R7237  15KR2F-GP  [R402H16]  83.74 99.7 270 bottom
R7238  0R2J-2-GP  [R402H16]  77.08 93.73 180 top
R7239  100KR2J-1-GP  [R402H16]  84.47 92.99 0 top
R7240  0R2J-2-GP  [R402H16]  82.7 95.25 270 top
R7241  100KR2J-1-GP  [R402H16]  82.21 94.49 90 top
R7242  1MR2J-1-GP  [R402H16]  77.64 106.63 90 top
R7243  1MR2J-1-GP  [R402H16]  84.35 95.28 90 top
R7244  10KR2F-2-GP  [R402H16]  70.1 106.58 180 top
R7245  43KR2J-GP  [R402H16]  69.34 105.72 0 top
R7246  10KR2F-2-GP  [R402H16]  83.86 102.87 270 top
R7247  10KR2J-L-GP  [R402H15]  70.99 97.95 90 top
R7248  1MR2J-1-GP  [R402H16]  70.99 98.71 270 top
R7249  1MR2J-1-GP  [R402H16]  70.99 100.26 270 top
R7250  0R3J-0-U-GP  [R603H22]  81.83 92.94 270 top
R7252  3K3R2J-3-GP  [R402H16]  82.59 93.42 180 bottom
R7253  3K3R2J-3-GP  [R402H16]  81.83 93.42 180 bottom
R7254  3K3R2J-3-GP  [R402H16]  81.07 93.42 180 bottom
R7255  3K3R2J-3-GP  [R402H16]  80.31 93.42 180 bottom
R7301  100KR2J-1-GP  [R402H16]  31.82 73.08 270 top
R7302  100KR2J-1-GP  [R402H16]  31.87 70.61 270 top
R7303  0R2J-L-GP  [R402H15]  18.46 70.31 270 bottom
R7304  0R2J-2-GP  [R402H16]  33.25 68.19 90 top
R7305  0R2J-2-GP  [R402H16]  33.25 68.98 90 top
R7306  10KR2J-3-GP  [R402H16]  28.67 72.14 0 bottom
R7307  4K7R2J-2-GP  [R402H16]  27.88 72.14 0 bottom
R7308  2MR2F-GP  [R402H16]  12.95 90.17 90 top
R7309  2MR2F-GP  [R402H16]  32.94 74.25 90 top
R7310  0R2J-2-GP  [R402H16]  15.64 84.99 270 top
R7311  0R2J-2-GP  [R402H16]  15.64 84.23 270 top
R7312  0R2J-2-GP  [R402H16]  15.64 86.54 270 top
R7313  0R2J-2-GP  [R402H16]  15.64 85.78 270 top
R7314  0R2J-2-GP  [R402H16]  16.1 80.22 270 top
R7315  0R2J-2-GP  [R402H16]  16.1 80.98 270 top
R7316  0R2J-2-GP  [R402H16]  16.1 81.79 270 top
R7317  0R2J-2-GP  [R402H16]  16.1 82.55 270 top
R7318  1KR2J-1-GP  [R402H16]  26.05 74.55 180 bottom
R7319  1KR2J-1-GP  [R402H16]  26.03 72.29 180 bottom
R7320  1KR2J-1-GP  [R402H16]  25.29 74.55 180 bottom
R7321  1KR2J-1-GP  [R402H16]  25.24 72.29 180 bottom
R7322  1KR2J-1-GP  [R402H16]  20.77 68.68 270 top
R7323  1KR2J-1-GP  [R402H16]  24.56 68.28 270 bottom
R7324  1KR2J-1-GP  [R402H16]  26.33 62.84 90 top
R7325  1KR2J-1-GP  [R402H16]  20.77 70.21 90 top
R7326  0R2J-2-GP  [R402H16]  33.24 69.8 90 top
R7327  1KR2J-1-GP  [R402H16]  20.77 69.45 90 top
R7340  1KR2J-1-GP  [R402H16]  20.77 70.97 270 top
R7341  1KR2J-1-GP  [R402H16]  25.8 68 0 bottom
R7342  1KR2J-1-GP  [R402H16]  26.26 69.22 270 bottom
R7343  1KR2J-1-GP  [R402H16]  28.49 69.09 0 bottom
R7344  1KR2J-1-GP  [R402H16]  27.12 67.97 0 bottom
R7401  1MR2F-GP  [R402H16]  20.62 88.04 270 top
R7402  200KR2F-L-GP  [R402H16]  34.13 81.51 90 top
R7403  0R2F-1-GP  [R402H16]  35.83 81.51 90 top
R7404  100KR2J-1-GP  [R402H16]  24.58 85.02 270 bottom
R7405  100KR2F-L1-GP  [R402H16]  32.99 79.76 180 top
R7406  100KR2F-L1-GP  [R402H16]  33.85 79.76 180 top
R7407  200KR2F-L-GP  [R402H16]  20.28 84.38 270 top
R7408  200KR2F-L-GP  [R402H16]  22.27 82.58 180 bottom
R7409  200KR2F-L-GP  [R402H16]  21.46 81.72 0 bottom
R7422  1MR2F-GP  [R402H16]  21.08 82.91 90 bottom
R7423  100KR2F-L1-GP  [R402H16]  20.52 81.54 0 bottom
R7424  100KR2F-L1-GP  [R402H16]  23.34 85.75 0 bottom
R7425  100KR2F-L1-GP  [R402H16]  20.29 85.14 90 top
R7426  100KR2F-L1-GP  [R402H16]  23.51 80.42 270 bottom
R7427  100KR2F-L1-GP  [R402H16]  23.51 84.05 90 bottom
R7428  100KR2F-L1-GP  [R402H16]  31.08 81.26 270 bottom
R7430  1MR2F-GP  [R402H16]  18.84 88.67 0 top
R7601  2K49R2F-GP  [R402H16]  180.72 101.5 45 bottom
R7602  10KR2F-2-GP  [R402H16]  173.65 90.38 45 top
R7603  10KR2J-3-GP  [R402H16]  174.77 94.11 180 bottom
R7604  0R2J-2-GP  [R402H16]  163.11 82.37 180 bottom
R7605  200R2J-L1-GP  [R402H16]  184.83 96.93 135 top
R7606  100KR2F-L1-GP  [R402H16]  163.11 80.6 180 bottom
R7613  0R2J-2-GP  [R402H16]  165.14 81.61 270 bottom
R7614  10KR2J-3-GP  [R402H16]  163.87 78.64 270 bottom
R7615  0R2J-2-GP  [R402H16]  163.34 77.75 90 bottom
R7616  0R3J-0-U-GP  [R603H22]  175.94 95.89 90 bottom
R7618  0R2J-2-GP  [R402H16]  173.81 92.51 315 bottom
R7801  60D4R2F-GP  [R402H16]  198.9 69.57 0 top
R7803  60D4R2F-GP  [R402H16]  198.12 69.57 0 top
R7805  40D2R2F-GP  [R402H16]  198.24 77.57 45 top
R7806  60D4R2F-GP  [R402H16]  197.5 82.88 0 top
R7807  40D2R2F-GP  [R402H16]  197.23 81.31 0 top
R7816  10KR2F-2-GP  [R402H16]  211.63 81.82 0 bottom
R7818  10KR2J-3-GP  [R402H16]  180.36 69.47 315 top
R7820  10KR2F-2-GP  [R402H16]  209.34 81.82 180 bottom
R7821  10KR2F-2-GP  [R402H16]  212.06 86.62 0 bottom
R7824  10KR2F-2-GP  [R402H16]  210.54 86.62 180 bottom
R7901  10KR2J-3-GP  [R402H16]  197 67.24 0 top
R7902  10KR2J-3-GP  [R402H16]  197.91 67.24 0 top
R7903  1MR2J-1-GP  [R402H16]  185.46 64.7 0 bottom
R7904  1K3R2J-GP  [R402H16]  184.7 64.7 0 bottom
R7905  100KR2J-1-GP  [R402H16]  176.68 67.11 45 top
R7907  40K2R2F-GP  [R402H16]  179.24 70.84 225 top
R7908  49K9R2F-L-GP  [R402H16]  177.41 68.23 135 bottom
R7909  49K9R2F-L-GP  [R402H16]  179.34 68.2 45 bottom
R7910  100KR2J-1-GP  [R402H16]  204.11 104.9 270 top
R7911  100KR2F-L1-GP  [R402H16]  179.9 68.76 225 bottom
R7912  0R2J-2-GP  [R402H16]  199.28 71.05 135 bottom
R7913  0R2J-2-GP  [R402H16]  195.55 70.61 225 bottom
R7914  49K9R2F-L-GP  [R402H16]  180.23 67.8 45 top
R7915  100KR2F-L1-GP  [R402H16]  178.86 65.84 315 top
R7917  10KR2J-3-GP  [R402H16]  198.67 67.24 180 top
R7918  100KR2F-L1-GP  [R402H16]  196.11 71.15 45 bottom
R7919  49K9R2F-L-GP  [R402H16]  178.74 67.62 45 bottom
R7920  100KR2F-L1-GP  [R402H16]  196.49 69.67 135 bottom
R7921  4K99R2F-L-GP  [R402H16]  198.98 68.46 225 bottom
R7924  10KR2F-2-GP  [R402H16]  199.53 69.02 225 bottom
R7925  49K9R2F-L-GP  [R402H16]  178.74 67.62 225 top
R7926  100KR2F-L1-GP  [R402H16]  177.41 68.23 315 top
R7927  10KR2J-3-GP  [R402H16]  180.16 64.93 90 bottom
R7928  49K9R2F-L-GP  [R402H16]  180.56 65.15 135 top
R7929  100KR2F-L1-GP  [R402H16]  180 65.71 315 top
R7931  10KR2J-3-GP  [R402H16]  162.2 78.95 270 bottom
R7932  4K99R2F-L-GP  [R402H16]  196.64 71.71 225 bottom
R7933  10KR2J-3-GP  [R402H16]  145.89 90.17 0 bottom
R7934  10KR2J-3-GP  [R402H16]  164.89 74.73 90 bottom
R7935  100KR2F-L1-GP  [R402H16]  198.06 69.85 135 bottom
R7938  100KR2F-L1-GP  [R402H16]  178.81 66.45 225 bottom
R7939  100KR2F-L1-GP  [R402H16]  176.98 66.83 45 bottom
R7940  0R2J-2-GP  [R402H16]  181.73 64.93 270 bottom
R7943  10KR2J-3-GP  [R402H16]  160.52 78.18 270 bottom
R7944  10KR2J-3-GP  [R402H16]  200.15 71.35 270 top
R7948  10KR2J-3-GP  [R402H16]  199.97 68.99 0 top
R7949  10KR2J-3-GP  [R402H16]  199.33 72.9 270 top
R7952  10KR2J-3-GP  [R402H16]  182.7 58.12 270 bottom
R7953  10KR2J-3-GP  [R402H16]  179.88 61.27 90 bottom
R7954  0R3J-0-U-GP  [R603H22]  183.48 92.87 225 top
R7957  0R0402-PAD-2-GP  [0R0402-PAD-1]  179.78 59.92 90 bottom
R7958  0R2J-2-GP  [R402H16]  181.4 66.78 135 bottom
R7959  0R2J-2-GP  [R402H16]  181.96 66.22 135 bottom
R7960  0R2J-2-GP  [R402H16]  182.29 66.75 225 top
R7961  0R2J-2-GP  [R402H16]  181.96 68.18 315 top
R7962  0R2J-2-GP  [R402H16]  183.38 66.17 315 top
R7963  0R2J-2-GP  [R402H16]  183.26 65.59 45 bottom
R7964  0R2J-2-GP  [R402H16]  199.33 72.11 90 top
R7965  0R2J-2-GP  [R402H16]  185.59 65.03 45 top
R7966  0R2J-2-GP  [R402H16]  185.03 64.47 45 top
R7967  0R2J-2-GP  [R402H16]  184.47 63.91 45 top
R7973  0R2J-2-GP  [R402H16]  163.37 76.94 90 bottom
R7974  0R2J-2-GP  [R402H16]  160.5 79.17 270 bottom
R7975  10KR2J-3-GP  [R402H16]  165.14 82.37 90 bottom
R7976  0R2J-2-GP  [R402H16]  180 67.01 315 bottom
R7977  0R2J-2-GP  [R402H16]  188.29 58.39 270 bottom
R7978  0R2J-2-GP  [R402H16]  188.3 57.62 90 bottom
R8101  549R2F-GP  [R402H16]  208.61 106.02 0 top
R8102  931R2F-1-GP  [R402H16]  209.39 105.06 180 top
R8103  1K33R2F-GP  [R402H16]  207.31 107.09 270 top
R8104  549R2F-GP  [R402H16]  212.26 101.02 270 top
R8105  931R2F-1-GP  [R402H16]  210.99 101.6 0 top
R8106  1K33R2F-GP  [R402H16]  210.86 99.92 0 top
R8107  121R2F-GP  [R402H16]  210.94 66.04 90 top
R8108  121R2F-GP  [R402H16]  208.3 101.27 180 top
R8109  1KR2J-1-GP  [R402H16]  209.42 72.24 90 top
R8110  1KR2J-1-GP  [R402H16]  209.06 95.74 90 top
R8111  1KR2J-1-GP  [R402H16]  211.2 87.84 90 top
R8112  1KR2J-1-GP  [R402H16]  210.31 81.64 0 top
R8113  40D2R2F-GP  [R402H16]  209.6 65.26 0 top
R8114  40D2R2F-GP  [R402H16]  208.83 65.26 0 top
R8115  40D2R2F-GP  [R402H16]  210.08 103.08 180 top
R8116  40D2R2F-GP  [R402H16]  209.32 103.08 180 top
R8529  10KR2J-3-GP  [R402H16]  107.13 106.4 90 top
R8530  0R2J-L-GP  [R402H15]  111.5 101.09 90 bottom
R8531  0R2J-L-GP  [R402H15]  109.16 98.43 0 bottom
R8532  0R2J-L-GP  [R402H15]  111.2 99.57 270 top
R8533  0R2J-L-GP  [R402H15]  111.2 100.33 90 top
R8534  100KR2F-L1-GP  [R402H16]  113.25 101.37 0 bottom
R8541  10KR2J-3-GP  [R402H16]  104.85 105.31 270 bottom
R8542  0R2J-L-GP  [R402H15]  109.67 101.22 90 top
R8543  0R2J-L-GP  [R402H15]  111.35 101.22 270 top
R8545  0R2J-L-GP  [R402H15]  108.07 102.21 0 top
R8546  0R2J-L-GP  [R402H15]  105.18 106.48 90 top
R8601  0R3J-0-U-GP  [R603H22]  171.16 102.59 270 bottom
R8602  0R3J-0-U-GP  [R603H22]  171.29 97.69 0 bottom
R8603  0R2J-2-GP  [R402H16]  169.87 99.27 270 bottom
R8604  1MR2J-1-GP  [R402H16]  180.36 58.37 90 top
R8605  0R2J-L-GP  [R402H15]  157.27 73.84 180 bottom
R8607  0R3J-0-U-GP  [R603H22]  183.05 104.35 225 bottom
R8608  0R3J-0-U-GP  [R603H22]  180.13 103.36 270 bottom
R8609  0R3J-0-U-GP  [R603H22]  174.31 102.47 90 bottom
R8610  0R3J-0-U-GP  [R603H22]  173.88 97.08 180 bottom
R8611  0R2J-2-GP  [R402H16]  170.51 101.55 270 bottom
R8626  10KR2J-L-GP  [R402H15]  154.32 77.93 270 bottom
R8629  0R2J-L-GP  [R402H15]  168.8 98.35 270 bottom
R8634  10KR2J-3-GP  [R402H16]  168.88 93.09 270 bottom
R8635  10KR2J-3-GP  [R402H16]  153.56 91.19 180 bottom
R8637  10KR2J-3-GP  [R402H16]  168.8 97.59 90 bottom
R8638  0R2J-L-GP  [R402H15]  171.4 93.02 270 bottom
R8640  100KR2J-1-GP  [R402H16]  158.87 99.32 0 bottom
R8641  10R3J-3-GP  [R603H22]  155.87 96.22 0 bottom
R8642  100R2J-2-GP  [R402H14]  102.91 107.04 270 top
R8643  100KR2J-1-GP  [R402H16]  160.73 100.69 90 bottom
R8644  100R2J-2-GP  [R402H14]  165.14 99.39 0 bottom
R8645  100KR2J-1-GP  [R402H16]  174.95 65.71 270 bottom
R8646  100R2J-2-GP  [R402H14]  175.58 61.8 90 bottom
R8647  100R2J-2-GP  [R402H14]  163.6 102.92 180 bottom
R8648  0R2J-L-GP  [R402H15]  154.81 91.9 270 bottom
R8649  0R2J-L-GP  [R402H15]  157.14 94.03 180 bottom
R8650  0R2J-L-GP  [R402H15]  155.16 87.71 90 bottom
R8651  0R2J-L-GP  [R402H15]  153.56 88.88 180 bottom
R8652  0R2J-L-GP  [R402H15]  149.45 88.67 180 bottom
R9110  0R2J-2-GP  [R402H16]  200.22 38.86 90 top
R9120  10KR2J-3-GP  [R402H16]  209.82 35.89 90 top
R9121  0R2J-2-GP  [R402H16]  208.43 31.12 0 top
R9122  0R2J-2-GP  [R402H16]  204.72 39.88 180 top
R9130  0R2J-2-GP  [R402H16]  197.99 35.44 90 top
R9132  33R2J-2-GP  [R402H16]  198.06 31.5 90 top
R9133  33R2J-2-GP  [R402H16]  196.21 33.91 90 top
R9137  0R2J-2-GP  [R402H16]  209.82 35.13 270 top
R9138  33R2J-2-GP  [R402H16]  196.97 37.01 90 top
R9139  0R2J-2-GP  [R402H16]  203.93 39.88 180 top
R9140  10KR2J-3-GP  [R402H16]  198.52 34.67 90 top
R9142  0R2J-2-GP  [R402H16]  205.48 39.83 180 top
R9143  0R2J-2-GP  [R402H16]  211.07 34.37 270 top
R9144  0R2J-2-GP  [R402H16]  202.2 39.7 90 top
R9148  10KR2J-3-GP  [R402H16]  197.99 36.22 90 top
R9149  0R2J-2-GP  [R402H16]  202.2 40.46 270 top
R9150  0R2J-2-GP  [R402H16]  202.2 41.23 270 top
R9152  0R2J-2-GP  [R402H16]  197.5 39.14 180 top
R9153  10KR2J-3-GP  [R402H16]  198.27 39.14 0 top
R9154  0R2J-L-GP  [R402H15]  197.81 37.92 270 top
R9806  0R0402-PAD-2-GP  [0R0402-PAD-1]  84.47 103.74 270 top
R9992  0R2J-2-GP  [R402H16]  90.44 89.36 90 bottom
R9994  0R2J-2-GP  [R402H16]  85.25 89.49 90 bottom
R9995  0R2J-2-GP  [R402H16]  83.57 89.49 270 bottom
R9996  0R2J-2-GP  [R402H16]  88.77 89.94 0 bottom
RN401  SRN2K2J-1-GP  [ARES2H16]  131.24 88.88 0 bottom
RN403  SRN2K2J-1-GP  [ARES2H16]  127.76 89.39 0 bottom
RN1201  SRN1KJ-7-GP  [SMD-ARES4H18]  73.48 20.22 180 top
RN1301  SRN1KJ-7-GP  [SMD-ARES4H18]  150.59 19.89 270 top
RN1601  SRN10KJ-6-GP  [ARES8-CN24-MUH20]  145.69 78.79 90 top
RN1602  SRN0J-6-GP  [SMD-ARES4H20]  132.76 88.88 180 bottom
RN1703  SRN10KJ-5-GP  [ARES2H18]  116.17 52.66 0 top
RN1704  SRN10KJ-5-GP  [ARES2H18]  119.86 49.63 0 top
RN1801  SRN20KJ-1-GP  [SMD-ARES4H20]  116.78 47.65 0 top
RN1806  SRN15J-GP  [ARES8-CN24-MUH20]  125.57 48.72 180 top
RN1807  SRN2K2J-4-GP  [ARES8-CN24-UH20]  134.69 72.72 270 bottom
RN1810  SRN10KJ-5-GP  [ARES2H18]  174.64 8.31 0 top
RN1811  SRN2K2J-1-GP  [ARES2H16]  145.18 72.85 0 top
RN1813  SRN10KJ-6-GP  [ARES8-CN24-MUH20]  126.92 52.2 0 top
RN2007  SRN1KJ-7-GP  [SMD-ARES4H18]  152.65 76.74 0 top
RN2008  SRN1KJ-7-GP  [SMD-ARES4H18]  151.12 76.74 0 top
RN2009  SRN10KJ-5-GP  [ARES2H18]  137.23 72.37 270 bottom
RN2402  SRN4K7J-8-GP  [SMD-ARES4H18]  50.03 39.83 90 top
RN2403  SRN10KJ-6-GP  [ARES8-CN24-MUH20]  26.61 30.61 270 top
RN2404  SRN10KJ-6-GP  [ARES8-CN24-MUH20]  26.66 33.02 270 top
RN2405  SRN100KJ-5-GP  [ARES8-CN24H20]  52.75 35.13 270 top
RN2412  SRN100KJ-5-GP  [ARES8-CN24H20]  29.13 52.15 270 top
RN2413  SRN2K2J-1-GP  [ARES2H16]  26.21 52.6 0 top
RN2414  SRN100KJ-5-GP  [ARES8-CN24H20]  28.11 45.8 270 top
RN2415  SRN100KJ-5-GP  [ARES8-CN24H20]  55.82 44.48 90 top
RN2416  SRN100KJ-5-GP  [ARES8-CN24H20]  46.58 54.03 180 top
RN2501  SRN4K7J-8-GP  [SMD-ARES4H18]  186.99 37.65 0 top
RN2602  SRN2K2J-1-GP  [ARES2H16]  60.93 42.73 180 top
RN2603  SRN10KJ-5-GP  [ARES2H18]  221.51 63.83 270 top
RN2901  SRN2K2J-1-GP  [ARES2H16]  17.44 19.33 270 bottom
RN4302  SRN100J-3-GP  [SMD-ARES4H18]  115.06 11.89 0 top
RN5502  SRN100KJ-5-GP  [ARES8-CN24H20]  44.06 82.5 270 bottom
RN5503  SRN100J-3-GP  [SMD-ARES4H18]  47.88 88.59 180 bottom
RN5504  SRN100J-3-GP  [SMD-ARES4H18]  41.9 82.63 180 bottom
RN5701  SRN499F-GP  [ARES8-CN24H20]  17.55 62.39 270 top
RN5702  SRN2K2J-1-GP  [ARES2H16]  17.98 64.93 270 top
RN5703  SRN499F-GP  [ARES8-CN24H20]  20.87 54.79 0 top
RN6401  SRN100J-3-GP  [SMD-ARES4H18]  215.64 37.95 0 top
RN6502  SRN2K2J-1-GP  [ARES2H16]  176.17 8.31 0 top
RN6503  SRN33J-5-GP-U  [SMD-ARES4H18]  180.33 11.41 0 top
RN6504  SRN10KJ-5-GP  [ARES2H18]  180.23 9.55 0 top
RN7203  SRN100KJ-5-GP  [ARES8-CN24H20]  81.43 105.74 180 top
RN7204  SRN10KJ-L-GP  [SMD-ARES4H16]  79.5 95.13 0 bottom
RN7206  SRN2K2J-5-GP  [SMD-ARES4H18]  82.82 96.45 90 top
RN7701  SRN2K2J-5-GP  [SMD-ARES4H18]  198.16 67.64 45 bottom
RN7901  SRN4K7J-8-GP  [SMD-ARES4H18]  179.8 62.84 90 top
RN7904  SRN2K2J-5-GP  [SMD-ARES4H18]  190.75 60.63 180 bottom
RN7905  SRN2K2J-5-GP  [SMD-ARES4H18]  189.22 60.63 180 bottom
RN7910  SRN10KJ-5-GP  [ARES2H18]  188.34 60.68 180 top
RTC1  ETY-CON2-22-GP-U  [3703K-Q02N-11L-U]  205.56 7.3 180 bottom
SBD1  ACES-CON10-48-GP  [50208-01001-001]  80.88 102.33 40 bottom
SKT251  SKT-G6179HT0321-001-GP  [G6179HT0321-001]  186.83 34.32 270 bottom
SPK1  ACES-CON4-29-GP  [50224-0040N-001]  18.71 6.5 180 bottom
SPR1  SPRING-12-GP-U1  [SPR8035H256]  166.01 57 180 bottom
SPR2  SPRING-12-GP-U1  [SPR8035H256]  25.71 58.5 90 bottom
SSD1  SKT-MINI67P-1-GP-U  [APCI0079-P002A]  214.51 13.2 90 bottom
TC3502  SC100U6D3V6MX-DL-GP  [C1206H75]  25.09 26.19 180 bottom
THM261  NCT7718W-GP  [MSOP8-1H44]  166.85 106.2 270 bottom
TP301  TPAD14-OP-GP  [TPAD14-OP]  95.6 88.39 180 bottom
TP302  TPAD14-OP-GP  [TPAD14-OP]  93.24 87.58 180 bottom
TP303  TPAD14-OP-GP  [TPAD14-OP]  92.02 87.07 180 bottom
TP304  TPAD14-OP-GP  [TPAD14-OP]  124.48 78.36 0 top
TP305  TPAD14-OP-GP  [TPAD14-OP]  95.6 87.1 180 bottom
TP306  TPAD14-OP-GP  [TPAD14-OP]  94.38 88.37 180 bottom
TP307  TPAD14-OP-GP  [TPAD14-OP]  93.24 88.83 180 bottom
TP308  TPAD14-OP-GP  [TPAD14-OP]  92.12 88.29 180 bottom
TP402  TPAD14-OP-GP  [TPAD14-OP]  131.36 79.91 0 top
TP618  TPAD14-OP-GP  [TPAD14-OP]  94.38 87.1 180 bottom
TP619  TPAD14-OP-GP  [TPAD14-OP]  86.59 87.84 180 bottom
TP620  TPAD14-OP-GP  [TPAD14-OP]  132.58 58.24 180 bottom
TP621  TPAD14-OP-GP  [TPAD14-OP]  91.98 89.51 180 bottom
TP1705  TPAD14-OP-GP  [TPAD14-OP]  104.31 88.19 0 bottom
TP1706  TPAD14-OP-GP  [TPAD14-OP]  134.6 77.63 180 bottom
TP1707  TPAD14-OP-GP  [TPAD14-OP]  117.37 56.04 180 bottom
TP1708  TPAD14-OP-GP  [TPAD14-OP]  124.75 57.59 180 bottom
TP1709  TPAD14-OP-GP  [TPAD14-OP]  112.54 54.99 180 bottom
TP1710  TPAD14-OP-GP  [TPAD14-OP]  118.68 58.32 180 bottom
TP1711  TPAD14-OP-GP  [TPAD14-OP]  215.94 47.88 0 top
TP1712  TPAD14-OP-GP  [TPAD14-OP]  112.41 69.3 0 top
TP1713  TPAD14-OP-GP  [TPAD14-OP]  118.73 55.34 180 bottom
TP1714  TPAD14-OP-GP  [TPAD14-OP]  61.61 35.18 0 top
TP1804  TPAD14-OP-GP  [TPAD14-OP]  126.84 68.94 0 top
TP1806  TPAD14-OP-GP  [TPAD14-OP]  124.38 71.68 270 top
TP1807  TPAD14-OP-GP  [TPAD14-OP]  104.87 87.1 180 bottom
TP1808  TPAD14-OP-GP  [TPAD14-OP]  106.12 87.07 180 bottom
TP1903  TPAD14-OP-GP  [TPAD14-OP]  116.12 65.08 0 top
TP2001  TPAD14-OP-GP  [TPAD14-OP]  124.96 76.63 0 top
TP2002  TPAD14-OP-GP  [TPAD14-OP]  125.32 75.31 0 top
TP2201  TPAD14-OP-GP  [TPAD14-OP]  123.53 57.54 180 bottom
TP2202  TPAD14-OP-GP  [TPAD14-OP]  124.24 56.47 180 bottom
TP2402  TPAD14-OP-GP  [TPAD14-OP]  48.43 48.47 0 top
TP4401  TPAD28-2-GP  [TPAD28]  164.36 10.7 90 top
TP4411  TPAD14-OP-GP  [TPAD14-OP]  156.15 7.39 0 top
TP4601  TPAD14-OP-GP  [TPAD14-OP]  35.76 60.56 180 bottom
TP7201  TPAD14-OP-GP  [TPAD14-OP]  74.9 105.84 180 top
TP7202  TPAD14-OP-GP  [TPAD14-OP]  74.21 106.91 180 top
TP7205  TPAD14-OP-GP  [TPAD14-OP]  72.54 99.8 180 top
TP7206  TPAD14-OP-GP  [TPAD14-OP]  77.21 105.07 0 top
TP7207  TPAD14-OP-GP  [TPAD14-OP]  77.64 103.91 0 top
TP7801  TPAD14-OP-GP  [TPAD14-OP]  197.33 77.04 0 top
TP7901  TPAD14-OP-GP  [TPAD14-OP]  166.95 87.4 270 bottom
TP7902  TPAD14-OP-GP  [TPAD14-OP]  166.67 79.96 90 top
TP7903  TPAD14-OP-GP  [TPAD14-OP]  188.39 75.9 270 top
TP7904  TPAD14-OP-GP  [TPAD14-OP]  188.21 79.23 270 top
TP7905  TPAD14-OP-GP  [TPAD14-OP]  166.06 86.52 180 bottom
TP7906  TPAD14-OP-GP  [TPAD14-OP]  165.07 83.49 180 bottom
TP9101  TPAD14-OP-GP  [TPAD14-OP]  207 36.22 270 top
TP9102  TPAD14-OP-GP  [TPAD14-OP]  206.67 32.72 0 top
TP9104  TPAD14-OP-GP  [TPAD14-OP]  208.07 37.24 270 top
TP9949  TPAD14-OP-GP  [TPAD14-OP]  117.62 65.94 0 top
TP9950  TPAD14-OP-GP  [TPAD14-OP]  120.35 67.28 0 top
TP9951  TPAD14-OP-GP  [TPAD14-OP]  119.64 56.16 180 bottom
TP9952  TPAD14-OP-GP  [TPAD14-OP]  118.41 57.03 180 bottom
TP9953  TPAD14-OP-GP  [TPAD14-OP]  127.65 43.67 0 top
TP9954  TPAD14-OP-GP  [TPAD14-OP]  215.64 36.45 0 top
TP9955  TPAD14-OP-GP  [TPAD14-OP]  137.92 75.87 180 bottom
TP9956  TPAD14-OP-GP  [TPAD14-OP]  115.19 57.69 180 bottom
TPAD1  PTWO-CON8-16-GP  [196574-08021-3]  176.71 12.1 180 bottom
U2401  MEC1416-NU-D0-GP  [TQFP128-2H48]  39.38 43.51 270 top
U2501  W25Q128JVSIQ-GP  [SOIC8-1H86]  186.83 34.32 90 bottom
U2502  SY6288C20AAC-GP  [SOT-23-5H56]  169.04 62.14 90 bottom
U2701  ALC3204-CG-GP-U  [QFN40J5-G3D75H36]  23.97 16 270 top
U3403  SY6288DAAC-GP  [SOT-23-5H56]  189.45 15.9 270 bottom
U3502  SY6288DAAC-GP  [SOT-23-5H56]  18.69 53.57 270 bottom
U3601  TPS2544RTER-GP  [QFN16-G1D8-UH32]  20.14 32.36 0 bottom
U4001  TPS22976DPUR-GP  [SON14J3020-G2610H34]  211.6 47.7 180 top
U4002  G5027RD1D-GP-U  [DFN8F3-G2517H32]  159.96 63.05 180 bottom
U4003  TPS22976DPUR-GP  [SON14J3020-G2610H34]  211.75 41.35 0 top
U4004  G5027RD1D-GP-U  [DFN8F3-G2517H32]  163.77 62.72 90 bottom
U4006  G5027RD1D-GP-U  [DFN8F3-G2517H32]  110.51 104.02 90 bottom
U4007  74LVC1G08GW-1-GP  [SC70-5H44]  163.37 72.85 180 bottom
U4302  S-1004NA23I-M5T1U-GP  [SOT-23-5H52]  33.98 82.45 180 bottom
U5501  RT9724GB-GP  [SOT-23-5H51]  42.97 78.56 90 bottom
U5502  APL5324BI-TRG-GP  [SOT-23-5H58]  64.1 90.63 0 bottom
U6402  74LVC1G08GW-1-GP  [SC70-5H44]  30.42 58.7 0 top
U7001  LNG2DMTR-GP  [LGA12G2H40]  167.38 52.43 180 top
U7204  SN1703018ZQZR-GP  [BGA96G60-1H40]  77.01 99.27 180 top
U7205  W25Q80DVZPIG-GP  [DFN8A5060-G435345H32]  74.47 93.04 90 bottom
U7301  TUSB546-DCIRNQR-1-GP  [QFN40J4060-G2848H32]  26.72 70.65 90 top
U7418  AON7403-GP-U  [PPAK-8P-3232H36]  22.68 85.8 90 top
U7419  NX20P5090UK-GP  [CSP15G154256H24]  20.82 84.86 90 bottom
U7601  74LVC1G08GW-1-GP  [SC70-5H44]  160.83 81.97 180 bottom
U8502  74LVC1G08GW-1-GP  [SC70-5H44]  111.27 99.39 270 bottom
U8601  G2898KD1U-GP  [DFN14J32-G255D95H32]  173.53 100.03 270 bottom
U8604  74LVC1G08GW-1-GP  [SC70-5H44]  151.78 90.15 0 bottom
U8605  74LVC1G08GW-1-GP  [SC70-5H44]  155.52 90.17 90 bottom
U9101  NPCT750JAAYX-GP-COLAY  [QFN32G5-G3D6H32-COLAY]  203.12 35.13 270 top
USB1  SKT-USB34-21-GP-U1  [SKT-USB34-124103-U1]  1.25 89 90 bottom
USB3  SKT-USB13-428-GP  [SKT-USB13-160146-4]  4.45 25.15 90 bottom
USB4  SKT-USB13-428-GP  [SKT-USB13-160146-4]  4.45 45.15 90 bottom
VRAM1  H5GC4H24AJR-T2C-GP  [BGA170D1214H48]  210.46 74 270 bottom
VRAM4  H5GC4H24AJR-T2C-GP  [BGA170D1214H48]  210.46 95 90 bottom
WLAN1  SKT-MINI67P-2-GP-U  [APCI0019-P002A01-U]  204.46 56 0 bottom
X1801  XTAL-24MHZ-135-GP  [S-OSC3-2016H28]  140.58 78.9 180 bottom
X1802  XTAL-32D768KHZ-98-GP  [SMD49-12H34]  112.24 51.29 90 top
X2401  XTAL-32D768KHZ-98-GP  [SMD49-12H34]  45.05 31.66 90 top
X7901  XTAL-27MHZ-192-GP  [SMD-OSC38H32]  184.7 61.55 180 bottom

## Library data of the parts
AFTP2501 AFTP2502 AFTP2601-AFTP2604 AFTP2901-AFTP2904 AFTP3501 AFTP3504-AFTP3506 AFTP4301-AFTP4316 AFTP6001 AFTP6101 AFTP6105-AFTP6110 AFTP6301 AFTP6303 AFTP6304 AFTP6502 AFTP6503 AFTP6505-AFTP6508 AFTP6510-AFTP6513 AFTP6515-AFTP6540 AFTP6565 AFTP6605-AFTP6608 = AFTE14P-75: tolerance: ZZ.AFT14.101
AUD1 = 2SJ3166-007111F-U: tolerance: 022.10002.0Q31
BATT1 = 3806K-F10N-03L: tolerance: 020.F0667.0010
BS2 = STF237R113H62: tolerance: 34.4SE26.001
C801 C803 C804 C806 C1102-C1104 C1106-C1108 C1111 C1116 C1119 C1121 C1207 C1213-C1221 C1226 C1233 C1313-C1322 C1326 C1327 C1805 C1806 C2202-C2205 C2210-C2213 C2215-C2217 C2219 C2222-C2224 C3402 C3422 C3507 C3510 C3517 C3601 C5536 PC4607 PC4708 PC4766 PC4809 PC4812 PC4866 PC4877 PC5130 PC5305 PC8506 = C402H22: tolerance: 78.10523.5FLDL
C802 C1105 C1109 C1110 C1114 C1117 C2209 C2214 C4301 C7219 C7329 C7807 C7825-C7831 = C603H36: tolerance: 78.10522.5BLDL
C805 C1139-C1142 C1228 C1328 C1711 C2201 C2206 C2207 C2221 C2502 C2602 C2605 C2608-C2610 C2612 C3401 C3508 C3516 C3602 C3603 C5501 C5538 C5702 C6001 C6007 C6101 C6103 C6104 C6307 C6401 C7244 C7315-C7318 C8037 C8630 C9108 C9112 C9113 EC1707 EC1712 EC1804 EC2201 EC3513 PC4438 PC4446 PC8514 = C402H22: tolerance: 78.10421.2FLDL
C1112 C1113 C1115 C1118 C1122 C1128-C1135 C2208 C2220 C3403 C3404 C3506 C3509 C3518 C3519 C3604 C3605 C4035 C4036 C6321 C6322 C7222 C7227 C7231 C7232 C7626 C7628 C7818 C7820 C7832 C7833 C7935 C7938 C7939 C8010 C8017 C8047 C8143-C8146 PC1001-PC1032 PC1034 PC1036-PC1084 PC4509-PC4512 PC4514-PC4517 PC4525 PC4527 PC4529 PC5201 PC5203 PC5205 PC5206 PC8611 PC8613 PC8620 PC8621 PC8628 PC8631 = C603H40: tolerance: 78.22610.5BLDL
C1120 C1123 C1136-C1138 C1202-C1206 C1208-C1210 C1303-C1310 C1324 C1325 C2601 C4005 C4006 C4009 C6002 C6008 C7319 C8038-C8046 C9106 C9109 PC5125 PC5128 PC5303 PC5306 = C603H36: tolerance: 78.10610.5BLDL
C1211 C1212 C1224 C1230 C1232 C1312 C1330 = C402H22: tolerance: 078.47510.05FD
C1222 C1323 C2517 PC4420 PC4608 PC4625 PC4626 PC4652 = C402H22: tolerance: 78.22321.2FLDL
C1223 C1329 C2426 PC5001 = C603H36: tolerance: 78.22523.5BLDL
C1225 C1227 C1231 C1311 C2218 C2604 C2723 C2907 C2908 C5505 C5539 C5599 C7610 C7611 C7613 C7615 C7620 C7621 C7624 C7634 C7813 C7814 C8001-C8004 C8008 C8009 C8019-C8026 C8030-C8032 PC4421 PC4422 PC4507 PC4520 = C603H36: tolerance: 78.47520.5BLDL
C1229 C1301 C2406-C2408 C2410-C2414 C2416 C2420-C2423 C2428 C2429 C4007 C4011 C4014 C4033 C4047 C6109 C6110 C7003 C7325-C7328 EC1202 EC6402 EC6404 FC8916-FC8930 PC4406 PC4425 PC4513 PC4602 PC4603 PC4630 PC4631 PC4633 PC4634 PC5004 PC5129 PC5214 PC8501 PC8507 PC8509 PC8516 PC8517 PC8522 PC8526 = C402H22: tolerance: 78.10422.5FLDL
C1331 C8015 C8016 C8048 = C603H36: tolerance: 78.47520.5BL
C1605 = C402H22: tolerance: 78.22423.5FL; signal model: wistron_C1605
C1606 = C402H22: tolerance: 78.22423.5FL; signal model: wistron_C1606
C1607 = C402H22: tolerance: 78.22423.5FL; signal model: wistron_C1607
C1608 = C402H22: tolerance: 78.22423.5FL; signal model: wistron_C1608
C1609 = C402H22: tolerance: 78.22423.5FL; signal model: wistron_C1609
C1610 = C402H22: tolerance: 78.22423.5FL; signal model: wistron_C1610
C1611 = C402H22: tolerance: 78.22423.5FL; signal model: wistron_C1611
C1612 = C402H22: tolerance: 78.22423.5FL; signal model: wistron_C1612
C1613 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C1613
C1614 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C1614
C1701 = C402H22: tolerance: 78.22124.2FLDL
C1710 C2503 PC4436 = C603H36: tolerance: 78.47422.5BLDL
C1803 C1804 C1807 C1808 = C402H22: tolerance: 78.15034.1FLDL
C2405 = C402H22: tolerance: 78.10134.1FL
C2409 C4303-C4305 C8141 C8142 = C402H22: tolerance: 78.10324.2FLDL
C2418 C2525 C4031 C4032 C4034 C4041 C4043 C7612 C7614 C7622 C7630 C7631 C7633 C8011-C8014 C8018 C8028 C8036 C8601-C8604 EC8933-EC8939 EC8947-EC8953 PC5202 PC8618 PC8629 = C402H22: tolerance: 78.10523.5FL
C2424 C2425 C7907 C7908 = C402H22: tolerance: 78.18034.1FL
C2430 C2431 C2436 C2607 PC4443 = C402H22: tolerance: 78.22224.2FL
C2501 = C603H36: tolerance: 078.10613.05BD
C2603 PC4441 PC4601 PC4611 PC4612 PC4623 PC4632 PC4640 = C402H22: tolerance: 78.22224.2FLDL
C2606 = C603H36: tolerance: 78.47134.1BL
C2613 EC2905-EC2908 = C402H22: tolerance: 78.10134.1FLDL
C2702 C2703 C2705 C2708 C2709 C2740 C7224 C7226 C7230 = C603H36: tolerance: 78.22523.L1L
C2704 C2706 C2714 C2718 C2721 C2735-C2737 C2741 C6402 C6501-C6504 C7616 C7632 C7801 C7802 C7805 C7806 C7808 C7809 C7903 C7906 C7936 C7937 C8029 C8034 C8035 C8089 C8631 EC2401 EC6401 FC8901-FC8915 PC4518 PC8614 PC8616 = C402H22: tolerance: 78.10421.2FL
C2707 C2710 C2711 C2713 C2715 C2717 C2720 C2722 C2902 C4008 C4012 C4013 C4045 C5502 C7004 C7623 C7625 C7627 C7629 C7817 C7834 C7835 C7934 C8111-C8114 C8123-C8130 C8606 C8607 PC8627 PC8630 = C603H38: tolerance: 78.10610.5BL
C2738 C7223 C7909 = C402H22: tolerance: 78.22423.L2L
C2739 = C603H36: tolerance: 78.10134.1BL
C3511 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C3511
C3512 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C3512
C3514 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C3514
C3520 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C3520
C4001 C4010 C8608 PC4433 PC4618 = C402H22: tolerance: 78.47124.2FLDL
C4302 C5535 PC4415 = C603H35: tolerance: 78.10424.2BLDL
C4306 EC4301 PC4402 PC4405 PC4407-PC4411 PC4413 PC4414 PC4418 PC4427 PC4434 PC4437 PC4447 PC4502-PC4505 PC4523 PC4701-PC4704 PC4802-PC4805 PC4814-PC4817 PC5111 PC5115 PC8502-PC8505 PC8511-PC8513 PC8515 PC8610 PC8615 = C603H40: tolerance: 78.10612.5BL
C4343 C7401 C8605 PC5118 = C402H22: tolerance: 78.15224.2FL
C4344 C5515 EC1706 EC2002 EC2901-EC2904 EC4307 EC4312 EC6403 EC6801 EC8925 EC8929 EC8960 EC8963 PC4432 PC4435 PC4442 PC4445 PC4526 PC4533 PC4616 PC4617 PC4619 PC4642 PC4643 PC4651 PC4706 PC4810 PC4813 PC5215 PC8510 = C402H22: tolerance: 78.10224.2FLDL
C5503 C5542 C5550 = C805H54: tolerance: 78.10623.51L
C5508 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C5508
C5514 C5518 EC4534 = C603H40: tolerance: 078.22522.05BD
C5531 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C5531
C5532 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C5532
C5533 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C5533
C5534 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C5534
C5537 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C5537
C5540 C5541 EC1801 EC1901 FC6101 PC4430 = C402H22: tolerance: 78.10034.1FLDL
C5701 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C5701
C5703 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C5703
C5704 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C5704
C5705 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C5705
C5706 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C5706
C5707 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C5707
C5708 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C5708
C5709 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C5709
C6003 = C402H22: tolerance: 78.10324.2FLDL; signal model: wistron_C6003
C6004 = C402H22: tolerance: 78.10324.2FLDL; signal model: wistron_C6004
C6005 = C402H22: tolerance: 78.10324.2FLDL; signal model: wistron_C6005
C6006 = C402H22: tolerance: 78.10324.2FLDL; signal model: wistron_C6006
C6106 C7330 PC4401 PC4403 PC4404 PC4412 PC5002 PC5003 PC5209 PC5210 = C805H58: tolerance: 78.10622.51LDL
C6107 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C6107
C6108 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C6108
C6302 = C402H22: tolerance: 078.22423.05FD; signal model: wistron_C6302
C6303 = C402H22: tolerance: 078.22423.05FD; signal model: wistron_C6303
C6304 C6305 EC1903 EC5503 PC4610 PC4624 PC4639 PC8518 = C402H22: tolerance: 78.33034.1FLDL
C6306 C6308 PC4605 PC4653 = C402H22: tolerance: 078.47322.02FD
C6311 = C402H22: tolerance: 078.22423.05FD; signal model: wistron_C6311
C6312 = C402H22: tolerance: 078.22423.05FD; signal model: wistron_C6312
C6313 = C402H22: tolerance: 078.22423.05FD; signal model: wistron_C6313
C6314 = C402H22: tolerance: 078.22423.05FD; signal model: wistron_C6314
C6315 = C402H22: tolerance: 078.22423.05FD; signal model: wistron_C6315
C6316 = C402H22: tolerance: 078.22423.05FD; signal model: wistron_C6316
C7220 C7221 PC5212 = C402H22: tolerance: 78.22124.2FL
C7225 C8101-C8110 C8115-C8122 C8131 C8132 PC5108 PC5122 = C402H22: tolerance: 78.10523.L2L
C7228 C7229 PC5117 PC5124 = C603H38: tolerance: 78.10610.L0L
C7301 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7301
C7302 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7302
C7303 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7303
C7304 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7304
C7305 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7305
C7306 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7306
C7307 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7307
C7308 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7308
C7309 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7309
C7310 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7310
C7311 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7311
C7312 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7312
C7313 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7313
C7314 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7314
C7321 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7321
C7322 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7322
C7323 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7323
C7324 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7324
C7331 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7331
C7332 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7332
C7333 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7333
C7334 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7334
C7601 = C402H22: tolerance: 78.22423.5FL; signal model: wistron_C7601
C7602 = C402H22: tolerance: 78.22423.5FL; signal model: wistron_C7602
C7603 = C402H22: tolerance: 78.22423.5FL; signal model: wistron_C7603
C7604 = C402H22: tolerance: 78.22423.5FL; signal model: wistron_C7604
C7605 = C402H22: tolerance: 78.22423.5FL; signal model: wistron_C7605
C7606 = C402H22: tolerance: 78.22423.5FL; signal model: wistron_C7606
C7607 = C402H22: tolerance: 78.22423.5FL; signal model: wistron_C7607
C7608 = C402H22: tolerance: 78.22423.5FL; signal model: wistron_C7608
C8136 C8140 = C402H22: tolerance: 78.82124.2FLDL
C8501 EC2701-EC2705 EC4302 EC4311 EC4313 EC8901-EC8915 EC8917 EC8919 EC8928 EC8954 EC8957-EC8959 EC8961 EC8962 EC8965-EC8968 PC4501 PC4506 PC4508 PC4521 PC4522 PC4530-PC4532 PC5204 PC5208 PC8619 = C402H22: tolerance: 78.10422.5FL
CPU1 = BGA1528M2446-1H52: tolerance: ZZ.00CPU.271
D1701 D2405 D4002-D4004 D6101 D6102 PD4407 PD4411 = SOD523AKH26: tolerance: 83.R2003.A8M
D2401 D2501 D2703 D5502 D5503 D8601 PD4401 PD4408 = SOT-23-9H44: tolerance: 75.00054.A7D
D2402 D4001 D7902 PD4404 = SOD323AKH44: tolerance: 83.00355.G1F
