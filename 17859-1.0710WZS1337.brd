# Allegro board 17859-1.0710WZS1337.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_CLK#0: length 92.9
  L4 w0.089: v1(144.06,25.68) 144.45,25.68 144.52,25.61 144.52,25.34 144.62,25.24 145.22,25.24 145.31,25.32 145.31,26.35 144.44,27.22 144.15,27.22 143.67,26.74 143.39,26.74 143.09,27.04 143.09,27.36 143.63,27.9 143.63,28.03 143.48,28.18 143.35,28.18 142.81,27.64 142.49,27.64 137.11,33.02 111.51,33.02 110.86,33.67 108.47,33.67 100.1,42.04 100.1,54.46 99.33,55.22 99.33,60.9 100.06,61.63 100.06,62.18 99.97,62.27 99.08,62.27 98.88,62.47 98.88,62.81 99.08,63.01 99.82,63.01 99.91,63.1 99.91,63.27 99.82,63.36 99.38,63.36 99.17,63.58 99.17,68.24 99.38,68.46 100.07,68.46 100.27,68.25 100.27,67.44 v1(100.76,66.95)
  BOTTOM w0.102: v1(100.76,66.95) 100.76,67.03 100.56,67.23 CPU1.AF28 ; v1(144.06,25.68) 143.78,25.68 143.71,25.61 143.71,25.4 143.61,25.29 143.43,25.3 143.19,25.54 143.19,26.97 143.39,27.17 DM2.139
M_B_CLK#1: length 92.1
  L4 w0.089: v1(99.85,66.95) 100.35,66.46 100.35,66.16 101.59,64.92 101.59,64.01 101.05,63.47 101.05,61.49 100.11,60.54 100.11,55.54 100.87,54.78 100.87,42.36 108.79,34.44 111.18,34.44 111.83,33.79 137.43,33.79 141.53,29.69 141.66,29.69 142.14,30.18 142.43,30.18 142.76,29.84 142.76,29.56 142.33,29.13 142.33,29 142.47,28.87 142.63,28.87 143.02,29.26 143.34,29.26 145.93,26.68 145.93,24.75 145.7,24.52 144.78,24.52 144.66,24.41 144.66,24.24 144.78,24.13 145.82,24.13 146.02,23.93 146.02,22.35 145.73,22.06 v1(143.95,22.06)
  BOTTOM w0.102: v1(143.95,22.06) 143.75,22.25 143.55,22.25 143.44,22.15 143.44,21.73 143.49,21.69 143.49,20.89 143.63,20.75 DM2.140 ; CPU1.AE28 99.58,67.23 v1(99.85,66.95)
M_B_CS#0: length 88.6
  L4 w0.089: v1(102.37,58.08) 101.97,58.08 101.88,57.99 101.88,52.58 102.44,52.01
  L4 w0.142: v1(147.72,24.31) 148.14,24.31 148.28,24.45 148.28,28.05 138.94,37.39 126.98,37.39 126.84,37.25 126.84,36.79 126.7,36.65 126.29,36.65 126.12,36.82 126.12,37.29 125.95,37.46 125.72,37.46 125.55,37.29 125.55,36.82 125.39,36.65 125.15,36.65 124.98,36.82 124.98,37.29 124.82,37.46 124.58,37.46 124.41,37.29 124.41,36.82 124.25,36.65 124.01,36.65 123.85,36.82 123.85,37.29 123.68,37.46 123.44,37.46 123.28,37.29 123.28,36.82 123.11,36.65 122.87,36.65 122.71,36.82 122.71,37.29 122.54,37.46 122.31,37.46 122.14,37.29 122.14,36.82 121.97,36.65 121.74,36.65 121.57,36.82 121.57,37.29 121.4,37.46 121.17,37.46 121,37.29 121,36.82 120.83,36.65 120.6,36.65 120.43,36.82 120.43,37.29 120.27,37.46 120.03,37.46 119.86,37.29 119.86,36.82 119.7,36.65 115.68,36.65 115.09,36.06 113.14,36.06 112.55,36.65 109.71,36.65 103.09,43.26 103.09,51.36 102.44,52.01
  BOTTOM w0.076: v1(102.37,58.08) 102.67,58.08 102.76,58.17 102.76,58.92 103.33,59.49 103.33,60.35 103.09,60.59 103.09,61.5 CPU1.AL37
  BOTTOM w0.14: v1(147.72,24.31) 148.04,24.31 148.18,24.45 148.18,26.8 148.11,26.87 148.11,26.87 147.89,27.1 DM2.149
M_B_CS#1: length 89.8
  L4 w0.142: v1(102.35,58.76) 102.68,58.76 102.84,58.6 102.84,56.95 103.07,56.72 103.38,56.72 103.52,56.86 103.52,59.12 103.67,59.26 104.16,59.26 104.49,58.93 104.49,52.89 106.83,50.55 106.83,50.31 106.99,50.14 107.1,50.14 107.27,49.98 107.27,49.74 107.1,49.57 106.99,49.57 106.83,49.41 106.83,49.17 106.99,49.01 107.1,49.01 107.27,48.84 107.27,48.6 107.1,48.44 106.99,48.44 106.83,48.27 106.83,48.03 106.99,47.87 107.1,47.87 107.27,47.7 107.27,47.47 107.1,47.3 106.99,47.3 106.83,47.13 106.83,46.69 106.98,46.54 107.13,46.54 107.23,46.43 107.23,45.23 112,40.46 140.26,40.46 140.58,40.15 140.58,39.91 140.57,39.9 140.57,39.67 140.73,39.5 140.97,39.5 140.98,39.51 141.21,39.51 141.38,39.34 141.38,39.11 141.37,39.1 141.37,38.86 141.54,38.7 141.77,38.7 141.78,38.71 142.02,38.71 142.19,38.54 142.19,38.3 142.18,38.29 142.18,38.06 142.34,37.89 142.58,37.89 142.59,37.9 142.82,37.9 142.99,37.73 142.99,37.5 142.98,37.49 142.98,37.25 143.15,37.09 143.38,37.09 143.39,37.1 143.63,37.1 151.1,29.63 151.1,28.55 151.73,27.92 151.73,24.33 151.59,24.18 v1(151.16,24.18)
  BOTTOM w0.076: v1(102.35,58.76) 102.37,58.76 103.17,59.56 103.17,60.28 102.93,60.52 102.93,61.65 102.99,61.8 102.99,62.12 102.98,62.14 102.97,62.16 102.97,62.38 103,62.46 103.22,62.93 CPU1.AL35
  BOTTOM w0.14: DM2.157 149.89,26.89 150.01,26.77 150.01,25.03 150.86,24.18 v1(151.16,24.18)
M_B_DIMB_ODT0: length 90.5
  L4 w0.089: 102.28,55.43 102.08,55.63 102.08,56.43 v1(102.42,56.77)
  L4 w0.142: v1(151.16,23.5) 150.68,23.98 150.68,27.84 150.08,28.44 150.08,28.86 139.49,39.45 109.44,39.45 109.04,39.84 109.04,40.08 109.33,40.36 109.33,40.6 109.16,40.77 108.93,40.77 108.64,40.48 108.4,40.48 108.24,40.65 108.24,40.88 108.52,41.17 108.52,41.4 108.36,41.57 108.12,41.57 107.84,41.29 107.6,41.29 105.92,42.96 105.92,46.85 105.76,47.01 105.08,47.01 104.91,47.18 104.91,47.42 105.08,47.58 105.76,47.58 105.92,47.75 105.92,47.98 105.76,48.15 105.08,48.15 104.91,48.32 104.91,48.55 105.08,48.72 105.76,48.72 105.92,48.89 105.92,49.12 105.76,49.29 105.08,49.29 104.91,49.46 104.91,49.69 105.08,49.86 105.76,49.86 105.92,50.02 105.92,50.39 105.69,50.62 105.04,50.62 104.9,50.77 104.9,51.42 103.45,52.87 103.45,53.32 103.15,53.61 103.15,54.55 102.28,55.43
  BOTTOM w0.076: v1(102.42,56.77) 102.85,56.77 102.93,56.84 102.93,58.86 103.5,59.42 103.5,60.5 103.26,60.74 103.26,61.21 103.48,61.43 103.48,61.77 103.26,62.26 CPU1.AL36
  BOTTOM w0.14: v1(151.16,23.5) 149.65,25.01 149.65,26.6 149.39,26.86 DM2.155
M_B_DIMB_ODT1: length 90.7
  L4 w0.142: v1(102.5,56.02) 102.67,56.19 103.24,56.19 103.38,56.05 103.38,53.71 103.78,53.32 103.78,53.07 106.37,50.48 106.37,45.46 107.23,44.6 107.23,44.25 106.37,43.39 106.37,43.15 106.73,42.79 106.93,42.79 107.87,43.73 108.11,43.73 108.27,43.56 108.27,43.33 107.38,42.44 107.38,42.23 107.59,42.03 107.79,42.03 108.68,42.92 108.91,42.92 109.08,42.76 109.08,42.52 108.68,42.12 108.68,41.88 108.84,41.72 109.08,41.72 109.48,42.12 109.72,42.12 109.88,41.95 109.88,41.72 109.48,41.31 109.48,41.08 109.65,40.91 109.88,40.91 110.29,41.31 110.52,41.31 110.69,41.15 110.69,40.91 110.12,40.34 110.12,40.14 110.3,39.96 139.64,39.96 144,35.6 144.24,35.6 144.25,35.61 144.48,35.61 144.65,35.44 144.65,35.2 144.64,35.19 144.64,34.96 144.81,34.79 145.04,34.79 145.05,34.8 145.29,34.8 145.46,34.64 145.46,34.4 145.45,34.39 145.45,34.15 145.61,33.99 145.85,33.99 145.86,34 146.09,34 146.26,33.83 146.26,33.59 146.25,33.59 146.25,33.35 146.42,33.18 146.65,33.18 146.66,33.19 146.9,33.19 147.07,33.03 147.07,32.79 147.06,32.78 147.06,32.54 147.22,32.38 147.46,32.38 147.47,32.39 147.7,32.39 147.87,32.22 147.87,31.99 147.86,31.98 147.86,31.74 148.03,31.57 148.26,31.57 148.27,31.58 148.51,31.58 148.67,31.42 148.67,31.18 148.66,31.17 148.66,30.94 148.83,30.77 149.07,30.77 149.08,30.78 149.31,30.78 149.48,30.61 149.48,30.38 149.47,30.37 149.47,30.13 149.64,29.96 149.87,29.96 149.88,29.97 150.12,29.97 150.28,29.81 150.28,29.57 150.27,29.56 150.27,29.33 150.59,29.01 150.59,28.4 151.22,27.78 v1(151.22,25.7)
  BOTTOM w0.076: CPU1.AL34 103.47,63.05 103.48,63.01 103.59,61.93 103.65,61.8 103.65,61.36 103.42,61.14 103.42,60.81 103.66,60.57 103.66,59.36 103.09,58.79 103.09,56.11 103,56.02 v1(102.5,56.02)
  BOTTOM w0.14: DM2.161 150.89,26.03 v1(151.22,25.7)
M_B_DQ0: length 52.3
  L6 w0.089: v1(109.51,21.42) 110.78,22.68 110.78,23.84 110.33,24.29 110.33,28.48 108.71,30.1 108.56,30.1 107.81,29.35 107.68,29.35 107.59,29.44 107.59,29.63 108.31,30.35 108.31,30.5 108.21,30.6 108.06,30.6 107.32,29.86 107.19,29.86 107.07,29.99 107.07,30.11 107.81,30.85 107.81,31 105.33,33.48 105.33,36.93 103.45,38.81 103.45,45.52 103.45,45.52 103.45,52 103.85,52.4 v1(103.85,53.91)
  BOTTOM w0.076: CPU1.AN35 104.23,62.48 104.19,62.43 104.19,62.36 104.07,61.9 104.02,61.8 104.02,61.43 104.07,61.36 104.21,61.23 104.21,60.76 103.92,60.47 103.92,59.38 103.27,58.73 103.27,54.49 v1(103.85,53.91)
  BOTTOM w0.089: v1(109.51,21.42) 109.64,21.3 DM2.4
M_B_DQ1: length 50.4
  L6 w0.089: v1(109.51,22.77) 109.05,23.23 109.05,25.51 102.01,32.56 102.01,35.94 102.46,36.39 102.46,45.93 102.46,45.93 102.46,52.49 103.08,53.11 103.08,58.02 104.66,59.59 105.34,59.59 v1(105.39,59.54)
  BOTTOM w0.076: CPU1.AN34 105.16,63.59 105.37,63.38 105.37,62.57 105.34,62.48 105.32,62.43 105.32,62.18 105.35,62.03 105.35,61.88 105.32,61.78 105.25,61.7 105.25,60.48 105.56,60.18 105.56,59.71 v1(105.39,59.54)
  BOTTOM w0.089: DM2.8 110.64,20.63 110.36,20.91 110.36,21.9 110.04,22.22 110.04,22.23 v1(109.51,22.77)
M_B_DQ2: length 52.3
  L6 w0.089: v1(105.3,57.84) 105.28,57.84 104.9,57.46 104.9,55.72 104.69,55.51 104.69,52.26 104.68,52.26 104.68,52.08 104.44,51.84 104.44,40.68 106.44,38.68 106.44,35.23 107.13,34.54 107.13,34.34 106.67,33.88 106.67,33.66 106.89,33.44 107.04,33.44 107.46,33.86 107.59,33.86 107.71,33.74 107.71,33.61 107.29,33.19 107.29,33.04 107.4,32.94 107.54,32.94 107.97,33.36 108.09,33.36 108.22,33.23 108.22,33.11 107.8,32.68 107.8,32.54 111.07,29.26 111.9,29.26 112.57,28.6 112.57,24.21 v1(111.88,23.52)
  BOTTOM w0.076: v1(105.3,57.84) 105.8,58.33 105.8,60.17 105.42,60.55 105.42,61.61 105.47,61.67 105.49,61.77 105.51,61.86 105.51,62.11 105.49,62.21 105.49,62.41 105.65,62.84 CPU1.AR35
  BOTTOM w0.089: DM2.17 112.88,24.53 v1(111.88,23.52)
M_B_DQ3: length 53.1
  L6 w0.089: v1(113.94,26.27) 114.14,26.47 114.14,26.81 114.05,26.9 113.33,26.9 113.22,27.01 113.22,27.15 113.33,27.26 114.04,27.26 114.15,27.36 114.15,27.51 114.04,27.61 113.33,27.61 113.22,27.72 113.22,27.86 113.33,27.97 114.05,27.97 114.14,28.06 114.14,28.44 113.6,28.98 113.45,28.98 113.27,28.8 113.12,28.8 113.02,28.91 113.02,29.05 113.2,29.24 113.2,29.38 112.97,29.61 112.83,29.61 112.72,29.51 112.58,29.51 112.47,29.61 112.47,29.76 112.58,29.86 112.58,30.01 112.09,30.5 111.94,30.5 111.44,30 111.31,30 111.21,30.1 111.21,30.27 111.69,30.75 111.69,30.89 111.58,31 111.44,31 110.93,30.49 110.8,30.49 110.68,30.6 110.68,30.75 111.18,31.25 111.18,31.4 111.08,31.5 110.93,31.5 110.41,30.98 110.28,30.98 110.16,31.1 110.16,31.23 110.68,31.75 110.68,31.9 107.1,35.48 107.1,38.95 105.1,40.95 105.1,51.74 105.3,51.94 v1(105.3,54.56)
  BOTTOM w0.076: CPU1.AR34 106.06,62.94 106.06,61.98 106.17,61.81 106.17,61.41 105.96,61.21 105.96,60.74 106.31,60.39 106.31,55.06 105.81,54.56 v1(105.3,54.56)
  BOTTOM w0.089: DM2.21 113.88,26.33 v1(113.94,26.27)
M_B_DQ4: length 52
  L6 w0.089: v1(103.88,55.82) 103.26,55.2 103.26,52.83 102.79,52.36 102.79,45.8 102.79,45.79 102.79,38.04 104.48,36.34 104.48,35.12 104.38,35.01 102.92,35.01 102.81,34.91 102.81,34.76 102.92,34.66 104.38,34.66 104.48,34.55 104.48,34.4 104.38,34.3 102.92,34.3 102.81,34.2 102.81,34.05 102.92,33.94 104.38,33.94 104.48,33.84 104.48,33.69 104.38,33.59 102.92,33.59 102.81,33.48 102.81,33.34 102.92,33.23 104.38,33.23 104.79,32.82 104.79,30.22 v1(109.5,25.51)
  BOTTOM w0.076: CPU1.AN37 104.54,61.53 104.54,60.63 104.29,60.38 104.29,59.22 103.6,58.52 103.6,56.11 v1(103.88,55.82)
  BOTTOM w0.089: DM2.3 109.39,26.95 109.06,26.62 109.06,25.95 v1(109.5,25.51)
M_B_DQ5: length 51.9
  L6 w0.089: v1(109.51,24.12) 109.94,24.55 109.94,26.41 106.28,30.08 106.28,30.22 107.1,31.05 107.1,31.2 107,31.3 106.85,31.3 106.03,30.47 105.88,30.47 105.77,30.58 105.77,30.73 106.6,31.55 106.6,31.7 106.5,31.8 106.35,31.8 105.52,30.98 105.38,30.98 105.15,31.2 105.15,31.42 105.73,32.01 105.73,32.36 104.97,33.12 104.97,36.34 103.12,38.19 103.12,45.65 103.12,45.66 103.12,52.23 103.44,52.55 103.44,54.75 v1(103.87,55.19)
  BOTTOM w0.076: CPU1.AN36 104.43,62.27 104.19,61.75 104.19,61.49 104.2,61.47 104.38,61.29 104.38,60.69 104.08,60.4 104.08,59.24 103.43,58.59 103.43,55.63 v1(103.87,55.19)
  BOTTOM w0.089: DM2.7 110.39,24.99 v1(109.51,24.12)
M_B_DQ6: length 52.9
  L6 w0.089: v1(105.3,55.87) 104.89,55.46 104.89,52.03 104.78,51.93 104.78,40.81 106.77,38.82 106.77,35.35 108.96,33.16 108.96,33.01 108.44,32.49 108.44,32.35 108.54,32.24 108.69,32.24 109.21,32.76 109.36,32.76 109.46,32.66 109.46,32.51 108.94,31.99 108.94,31.84 109.04,31.74 109.19,31.74 109.71,32.26 109.86,32.26 109.96,32.15 109.96,32.01 109.44,31.49 109.44,31.34 111.2,29.58 112.04,29.58 113.01,28.61 113.01,24.29 113.11,24.19 113.34,24.19 113.43,24.1 113.43,23.92 113.34,23.83 113.11,23.83 113.01,23.73 113.01,22.31 112.82,22.12 v1(111.95,22.12)
  BOTTOM w0.076: CPU1.AR36 105.74,62.2 105.89,61.94 106,61.77 106,61.76 106,61.49 105.79,61.28 105.79,60.78
  BOTTOM w0.089: v1(105.3,55.87) 106.13,56.7 106.13,60.31 105.79,60.65 105.79,60.78 ; v1(111.95,22.12) 112.64,21.43 DM2.16
M_B_DQ7: length 52.5
  L6 w0.089: v1(105.3,56.54) 105.76,56.08 105.76,52.05 105.43,51.72 105.43,41.09 107.43,39.09 107.43,36.51 107.83,36.11 107.83,35.96 107.57,35.7 107.57,35.55 107.67,35.45 107.82,35.45 108.08,35.71 108.23,35.71 108.33,35.61 108.33,35.46 108.07,35.19 108.07,35.05 108.17,34.94 108.32,34.94 108.58,35.21 108.73,35.21 108.84,35.1 108.84,34.96 108.57,34.69 108.57,34.54 108.68,34.44 108.82,34.44 109.09,34.7 109.23,34.7 109.34,34.6 109.34,34.45 109.07,34.19 109.07,34.04 109.18,33.94 109.33,33.94 109.59,34.2 109.74,34.2 109.84,34.1 109.84,33.95 109.58,33.68 109.58,33.54 109.68,33.43 109.83,33.43 110.09,33.7 110.24,33.7 110.34,33.59 110.34,33.45 110.08,33.18 110.08,33.03 110.18,32.93 110.33,32.93 110.6,33.2 110.74,33.2 114.07,29.87 114.07,28.88 114.4,28.55 114.4,25.07 114.31,24.98 v1(113.96,24.98)
  BOTTOM w0.076: v1(105.3,56.54) 105.96,57.2 105.96,60.24 105.58,60.62 105.58,61.47 CPU1.AR37
  BOTTOM w0.089: v1(113.96,24.98) 113.96,24.46 113.64,24.13 DM2.20
M_B_DQ8: length 50.9
  L6 w0.089: v1(116.32,24.22) 115.47,24.22 115.28,24.41 115.28,24.78 115.39,24.88 115.64,24.88 115.74,24.98 115.74,25.13 115.64,25.24 115.39,25.24 115.28,25.34 115.28,30.01 111.19,34.11 111.19,34.25 111.57,34.63 111.57,34.78 111.47,34.89 111.32,34.89 110.94,34.51 110.79,34.51 110.69,34.61 110.69,34.76 111.07,35.14 111.07,35.29 108.38,37.97 108.38,39.49 106.42,41.45 106.42,56.44 106.41,56.45 106.41,56.58 v1(107.12,57.28)
  BOTTOM w0.076: v1(107.12,57.28) 106.56,57.84 106.56,60.69 106.75,60.88 106.75,61.21 106.54,61.41 106.54,61.84 106.58,61.88 106.58,61.9 106.6,61.92 106.61,61.92 106.61,62.46 106.65,62.62 CPU1.AU35
  BOTTOM w0.089: v1(116.32,24.22) 116.06,24.22 114.88,25.4 DM2.25
M_B_DQ9: length 50.3
  L6 w0.089: v1(118.27,25.61) 117.82,26.06 117.82,30.85 112.07,36.6 112.07,36.75 112.37,37.05 112.37,37.19 112.26,37.3 112.11,37.3 111.81,37 111.67,37 111.56,37.1 111.56,37.25 111.86,37.55 111.86,37.7 111.76,37.8 111.61,37.8 111.31,37.5 111.16,37.5 111.06,37.6 111.06,37.75 111.36,38.05 111.36,38.2 111.26,38.3 111.11,38.3 110.81,38 110.66,38 110.56,38.11 110.56,38.25 110.86,38.55 110.86,38.7 110.75,38.81 110.61,38.81 110.31,38.51 110.16,38.51 109.93,38.73 109.93,40.13 108.1,41.96 108.1,52.76 108.2,52.86 108.2,54.92 108.04,55.08 108.04,56.12 v1(108.44,56.52)
  BOTTOM w0.076: CPU1.AU34 107.68,63.59 107.89,63.38 107.89,62.64 107.84,62.44 107.84,62.14 107.86,62.06 107.86,61.86 107.81,61.73 107.81,60.56 108.05,60.33 108.05,59.72 107.9,59.58 107.9,57.05 v1(108.44,56.52)
  BOTTOM w0.089: DM2.37 117.88,26.81 117.82,26.75 117.82,26.06 v1(118.27,25.61)
M_B_DQ10: length 51.8
  L6 w0.089: v1(118.07,21.41) 117.65,21.41 117.52,21.54 117.52,23.91 117.31,24.12 117.31,24.47 117.5,24.66 117.5,29.54 115.82,31.22 115.82,31.37 116.26,31.81 116.26,31.95 116.15,32.06 116.01,32.06 115.57,31.62 115.42,31.62 115.32,31.72 115.32,31.87 115.76,32.31 115.76,32.46 115.65,32.56 115.5,32.56 115.06,32.12 114.92,32.12 114.71,32.33 114.71,32.45 115.11,32.85 115.11,33.01 109.62,38.5 109.62,40 107.77,41.84 107.77,52.83 107.99,53.06 107.99,54.87 107.86,55.01 107.86,56.19 107.9,56.23 107.9,57.25 v1(108.44,57.79)
  BOTTOM w0.076: CPU1.AW35 108.16,62.84 108.04,62.5 108.01,62.39 108.01,62.21 108.03,62.11 108.03,61.83 107.98,61.7 107.98,60.63 108.21,60.4 108.21,59.63 108.07,59.49 108.07,58.16 v1(108.44,57.79)
  BOTTOM w0.089: DM2.38 118.14,21.35 v1(118.07,21.41)
M_B_DQ11: length 50.9
  L6 w0.089: v1(107.07,54.08) 106.75,53.76 106.75,41.57 108.7,39.62 108.7,38.12 112.27,34.55 112.27,34.4 111.88,34.01 111.88,33.87 111.98,33.76 112.13,33.76 112.52,34.15 112.67,34.15 112.77,34.05 112.77,33.9 112.38,33.51 112.38,33.36 112.49,33.26 112.63,33.26 113.02,33.65 113.17,33.65 113.27,33.54 113.27,33.4 112.89,33.01 112.89,32.86 112.99,32.76 113.14,32.76 113.53,33.15 113.67,33.15 113.78,33.04 113.78,32.89 113.39,32.5 113.39,32.36 115.64,30.11 115.64,25.66 115.79,25.51 v1(116.32,25.51)
  BOTTOM w0.076: CPU1.AW34 108.55,62.98 108.55,62.04 108.68,61.81 108.68,61.41 108.47,61.21 108.47,60.88 108.78,60.57 108.78,58.92 109.02,58.68 109.02,55.27 107.83,54.08 v1(107.07,54.08)
  BOTTOM w0.089: DM2.29 115.88,25.94 v1(116.32,25.51)
M_B_DQ12: length 50.7
  L6 w0.089: v1(114.14,23.45) 114.54,23.45 114.63,23.54 114.63,29.77 109.02,35.37 109.02,35.52 109.39,35.88 109.39,36.03 109.28,36.14 109.14,36.14 108.77,35.77 108.62,35.77 108.52,35.88 108.52,36.02 108.88,36.39 108.88,36.53 108.78,36.64 108.63,36.64 108.27,36.27 108.12,36.27 107.75,36.65 107.75,39.22 105.76,41.21 105.76,51.8 105.94,51.98 105.94,56.15 105.76,56.33 105.76,57.83 v1(107.12,59.18)
  BOTTOM w0.076: v1(107.12,59.18) 106.92,59.39 106.92,60.58 107.08,60.74 107.08,61.52 CPU1.AU37
  BOTTOM w0.089: v1(114.14,23.45) 114.19,23.4 115.54,23.4 115.64,23.3 DM2.28
M_B_DQ13: length 49.6
  L6 w0.089: v1(107.12,58.55) 105.94,57.37 105.94,56.4 106.12,56.22 106.12,51.9 106.09,51.87 106.09,41.33 108.07,39.35 108.07,37.8 109.93,35.94 109.93,35.8 109.56,35.43 109.56,35.29 109.67,35.18 109.81,35.18 110.18,35.55 110.32,35.55 110.43,35.44 110.43,35.29 110.06,34.93 110.06,34.78 114.96,29.89 114.96,22.23 114.78,22.05 v1(114.12,22.05)
  BOTTOM w0.076: CPU1.AU36 106.9,62.22 106.81,62.04 106.76,61.87 106.75,61.83 106.73,61.81 106.73,61.79 106.71,61.77 106.71,61.49 106.91,61.28 106.91,60.81 106.72,60.62 106.72,58.94 v1(107.12,58.55)
  BOTTOM w0.089: DM2.24 114.64,21.53 v1(114.12,22.05)
M_B_DQ14: length 51.4
  L6 w0.089: v1(118.41,24.24) 118.71,24.54 118.71,30.4 114.71,34.41 114.71,34.55 115.01,34.85 115.01,35 114.9,35.11 114.76,35.11 114.46,34.8 114.31,34.8 114.2,34.91 114.2,35.06 114.51,35.36 114.51,35.5 114.4,35.61 114.25,35.61 113.95,35.31 113.81,35.31 113.7,35.41 113.7,35.56 114,35.86 114,36.01 113.9,36.11 113.75,36.11 113.45,35.81 113.3,35.81 113.2,35.91 113.2,36.06 113.5,36.36 113.5,36.51 113.4,36.61 113.25,36.61 112.95,36.31 112.8,36.31 112.7,36.42 112.7,36.56 113,36.87 113,37.01 110.25,39.76 110.25,40.26 108.43,42.08 108.43,49.88 108.53,49.98 108.53,55.16 v1(108.44,55.25)
  BOTTOM w0.076: CPU1.AW36 108.26,62.23 108.51,61.77 108.51,61.49 108.31,61.28 108.31,60.81 108.62,60.51 108.62,58.83 108.86,58.59 108.86,55.67 v1(108.44,55.25)
  BOTTOM w0.089: DM2.41 118.88,24.51 118.61,24.24 v1(118.41,24.24)
M_B_DQ15: length 50.7
  L6 w0.089: v1(118.07,22.71) 119.03,23.67 119.03,30.53 116.85,32.71 116.85,32.86 117.16,33.16 117.16,33.31 117.05,33.41 116.91,33.41 116.6,33.11 116.45,33.11 116.35,33.21 116.35,33.36 116.65,33.67 116.65,33.81 116.55,33.92 116.4,33.92 116.1,33.61 115.95,33.61 115.85,33.72 115.85,33.86 116.15,34.17 116.15,34.32 116.05,34.42 115.9,34.42 115.59,34.12 115.45,34.12 115.34,34.22 115.34,34.37 115.65,34.67 115.65,34.82 110.57,39.9 110.57,40.39 108.74,42.21 108.74,51.43 108.84,51.52 108.84,58.05 v1(108.46,58.42)
  BOTTOM w0.076: CPU1.AW37 108.16,61.54 108.16,61.37 108.14,61.35 108.14,60.74 108.43,60.46 108.43,58.46 v1(108.46,58.42)
  BOTTOM w0.089: DM2.42 119.14,20.61 118.93,20.81 118.93,21.85 v1(118.07,22.71)
M_B_DQ16: length 84.5
  L4 w0.089: v1(102.6,66.95) 102.09,66.44 102.09,66.06 102.07,66.04 102.07,65.45 101.84,65.22 101.84,63.99 101.92,63.9 101.92,62.14 105.72,58.34 105.72,52.52 108.35,49.89 108.35,47.83 111.89,44.3 113.98,44.3 115.25,43.02 118.04,43.02 119.07,41.98 127.02,41.98 127.1,42.06 139.89,42.06 152.22,29.74 152.22,28.4 152.34,28.27 152.34,22.17 v1(153.09,21.42)
  BOTTOM w0.089: DM2.170 153.14,21.37 v1(153.09,21.42) ; v1(102.6,66.95) 102.22,66.58 CPU1.AJ29
M_B_DQ17: length 84.2
  L4 w0.089: v1(153.07,22.84) 152.62,23.29 152.62,28.4 152.53,28.49 152.53,29.87 140.02,42.38 126.97,42.38 126.89,42.3 119.2,42.3 118.13,43.37 115.35,43.37 114.11,44.61 112.02,44.61 108.71,47.93 108.71,49.81 105.9,52.62 105.9,58.41 104.46,59.85 104.46,60.94 102.11,63.3 102.11,64 102.02,64.09 102.02,65.14 102.25,65.37 102.25,65.97 v1(102.6,66.32)
  BOTTOM w0.089: v1(153.07,22.84) 154.14,21.77 DM2.174 ; CPU1.AJ30 102.21,65.93 v1(102.6,66.32)
M_B_DQ18: length 85.2
  L4 w0.089: v1(104.46,64.34) 104.46,63.88 106.15,62.19 106.38,62.19 108.48,60.09 108.48,59.35 107.99,58.86 107.99,54.6 108.56,54.03 108.56,53.88 108.16,53.48 108.16,53.33 108.26,53.23 108.41,53.23 108.81,53.63 108.96,53.63 109.06,53.53 109.06,53.38 108.66,52.98 108.66,52.83 108.76,52.73 108.91,52.73 109.31,53.13 109.46,53.13 109.88,52.71 114.24,52.71 114.75,52.2 114.75,49.61 115.51,48.85 115.51,48.51 118.11,45.91 120.2,45.91 120.92,45.2 141.41,45.2 145.7,40.91 146.05,40.91 147.27,39.69 147.27,38.22 154.76,30.73 154.76,28.95 155.7,28.02 155.7,27.7 155.8,27.6 156.28,27.6 156.38,27.49 156.38,27.35 156.28,27.24 155.8,27.24 155.7,27.14 155.7,25.4 155.87,25.22 v1(156.67,25.22)
  BOTTOM w0.089: v1(104.46,64.34) 104.43,64.37 104.36,64.37 104.1,64.63 CPU1.AM32 ; v1(156.67,25.22) 157.47,26.03 157.47,26.86 157.39,26.95 DM2.187
M_B_DQ19: length 84.8
  L4 w0.089: v1(104.4,65.01) 104.4,64.86 104.06,64.52 104.06,64.5 104.01,64.44 104.01,64 106.16,61.85 106.44,61.85 106.45,61.85 106.46,61.85 107.14,61.17 107.14,61.15 107.14,61.15 107.14,60.06 107.77,59.43 107.77,53.39 108.76,52.4 114.3,52.4 114.55,52.15 114.55,49.57 115.08,49.04 115.08,48.5 118.02,45.56 120.11,45.56 120.79,44.88 141.28,44.88 145.57,40.59 145.92,40.59 146.95,39.56 146.95,38.09 154.45,30.6 154.45,28.91 155.47,27.89 155.47,24.62 156.65,23.43 v1(156.65,22.68)
  BOTTOM w0.089: v1(156.65,22.68) 157.14,22.19 DM2.186 ; v1(104.4,65.01) 104.38,65.07 CPU1.AM31
M_B_DQ20: length 85.8
  L4 w0.089: v1(104.42,65.68) 104.85,65.26 104.85,64.75 105.02,64.57 105.02,63.57 106.21,62.38 106.5,62.38 108.91,59.97 108.91,53.92 109.9,52.94 114.26,52.94 115.04,52.16 115.04,49.6 118.41,46.23 119.47,46.23 119.57,46.33 119.57,46.84 119.67,46.94 119.82,46.94 119.93,46.84 119.93,46.33 120.03,46.23 120.54,46.23 121.26,45.51 141.54,45.51 145.83,41.23 146.18,41.23 147.59,39.82 147.59,38.35 155.11,30.83 155.11,30.44 155.19,30.36 156.55,30.36 156.64,30.27 156.64,29.8 156.54,29.7 155.19,29.7 155.1,29.61 155.1,29.43 155.19,29.34 156.54,29.34 156.64,29.24 156.64,29.09 156.54,28.99 155.6,28.99 155.49,28.88 155.49,28.74 155.6,28.63 156.54,28.63 156.64,28.53 v1(156.64,26.52)
  BOTTOM w0.089: DM2.183 156.39,26.77 v1(156.64,26.52) ; v1(104.42,65.68) CPU1.AM30
M_B_DQ21: length 85.9
  L4 w0.089: v1(155.66,22.74) 155.21,23.19 155.21,23.62 155.22,23.63 155.22,27.61 154.13,28.7 154.13,30.46 146.63,37.96 146.63,39.42 145.78,40.27 145.43,40.27 141.15,44.56 120.61,44.56 120.05,45.11 117.92,45.11 117.6,45.43 117.45,45.43 117.26,45.24 117.11,45.24 117.01,45.35 117.01,45.49 117.2,45.69 117.2,45.83 115.57,47.46 115.35,47.46 113.81,49 111.39,49 110.28,50.1 110.27,50.1 109.75,50.63 109.75,50.96 110.06,51.28 110.06,51.4 109.94,51.53 109.81,51.53 109.5,51.21 109.35,51.21 107.56,53 107.56,59.39 106.96,59.99 106.96,61 106.29,61.67 106.08,61.67 103.83,63.93 103.83,64.52 103.88,64.57 103.88,64.59 103.96,64.67 103.96,65.86 v1(104.42,66.32)
  BOTTOM w0.089: DM2.182 156.14,22.26 v1(155.66,22.74) ; v1(104.42,66.32) CPU1.AM29
M_B_DQ22: length 82.7
  L4 w0.089: v1(102.65,65.62) 102.65,65.52 102.2,65.07 102.2,64.26 102.28,64.18 102.28,63.43 106.08,59.64 106.08,52.73 109.02,49.78 109.02,49.16 109.25,48.93 109.4,48.93 109.48,49.02 109.63,49.02 109.73,48.91 109.73,48.76 109.65,48.68 109.65,48.53 109.75,48.43 109.9,48.43 109.98,48.51 110.13,48.51 110.23,48.41 110.23,48.26 110.15,48.18 110.15,48.03 110.88,47.3 111.41,47.3 111.51,47.41 111.51,47.59 111.61,47.7 111.76,47.7 111.87,47.59 111.87,47.41 111.97,47.3 112.96,47.3 116.53,43.73 119.69,43.73 120.73,42.69 140.16,42.69 152.9,29.95 152.9,25.23 v1(153.59,24.54)
  BOTTOM w0.089: v1(102.65,65.62) 102.55,65.62 102.21,65.28 CPU1.AJ31 ; v1(153.59,24.54) 154.02,24.97 154.02,26.91 153.89,27.04 DM2.173
M_B_DQ23: length 82.7
  L4 w0.089: v1(102.62,64.93) 102.49,64.8 102.49,63.53 106.26,59.76 106.26,52.84 111.08,48.02 112.75,48.02 116.68,44.08 119.79,44.08 120.85,43.02 140.27,43.02 142.91,40.39 143.06,40.39 143.47,40.8 143.61,40.8 143.72,40.7 143.72,40.55 143.31,40.14 143.31,39.99 143.41,39.89 143.56,39.89 143.97,40.3 144.12,40.3 144.22,40.19 144.22,40.05 143.81,39.63 143.81,39.49 143.92,39.38 144.06,39.38 144.47,39.79 144.62,39.79 144.72,39.69 144.72,39.54 144.31,39.13 144.31,38.98 144.54,38.76 144.69,38.76 144.89,38.96 145.03,38.96 145.14,38.86 145.14,38.71 144.94,38.51 144.94,38.36 145.16,38.14 145.35,38.14 145.64,37.85 145.64,37.66 153.21,30.09 153.21,27.43 153.11,27.33 153.11,25.9 153.2,25.81 v1(153.59,25.81)
  BOTTOM w0.089: v1(102.62,64.93) 102.44,64.93 CPU1.AJ32 ; DM2.169 152.89,26.51 v1(153.59,25.81)
M_B_DQ24: length 84.6
  L4 w0.089: v1(158.1,24.69) 158.77,25.36 158.77,29.94 157.08,31.63 156.11,31.63 148.86,38.88 148.86,40.79 141.95,47.7 121.77,47.7 119.84,49.62 117.53,49.62 116.43,50.73 116.43,50.98 116.53,51.09 116.93,51.09 117.04,51.19 117.04,51.34 116.93,51.44 116.53,51.44 116.43,51.55 116.43,52.15 114.78,53.8 110.86,53.8 110.54,54.13 110.54,60.2 110.4,60.33 110.4,60.68 109.12,61.95 108.75,61.95 106.28,64.42 v1(106.28,64.95)
  BOTTOM w0.089: CPU1.AR31 106.25,65.04 v1(106.28,64.95) ; DM2.195 159.38,24.88 159.19,24.69 v1(158.1,24.69)
M_B_DQ25: length 83.8
  L4 w0.089: v1(105.87,64.08) 105.87,64.08 106.28,64.08 108.59,61.78 109.05,61.78 109.62,61.21 109.62,53.97 109.99,53.6 114.73,53.6 116.25,52.07 116.25,50.65 117.47,49.43 119.57,49.43 119.82,49.17 119.82,49.03 119.74,48.94 119.74,48.79 119.85,48.69 119.99,48.69 120.08,48.77 120.22,48.77 120.33,48.67 120.33,48.52 120.24,48.44 120.24,48.29 120.35,48.19 120.5,48.19 120.58,48.27 120.73,48.27 120.83,48.17 120.83,48.02 120.75,47.94 120.75,47.79 120.85,47.68 121,47.68 121.08,47.77 121.23,47.77 121.65,47.34 141.85,47.34 148.54,40.66 148.54,38.75 155.98,31.31 156.95,31.31 157.98,30.27 157.98,29.27 158.09,29.17 158.44,29.17 158.54,29.06 158.54,28.91 158.44,28.81 158.09,28.81 157.98,28.71 157.98,28.56 158.09,28.45 158.44,28.45 158.54,28.35 158.54,28.2 158.44,28.1 158.09,28.1 157.98,28 157.98,27.85 158.09,27.74 158.44,27.74 158.54,27.64 158.54,27.49 158.44,27.39 158.09,27.39 157.98,27.28 157.98,27.14 158.09,27.03 158.44,27.03 158.54,26.93 158.54,26.78 158.44,26.68 158.09,26.68 157.98,26.57 157.98,26.23 v1(158.1,26.12)
  BOTTOM w0.089: v1(158.1,26.12) 158.39,26.4 DM2.191 ; v1(105.87,64.08) 105.86,64.09 105.86,64.55 CPU1.AR32
M_B_DQ26: length 87.2
  L4 w0.089: v1(161.86,24.74) 162.67,24.74 162.76,24.83 162.76,26.22 161.79,27.18 161.79,29.7 150.72,40.76 150.72,41.56 142.61,49.68 141.56,49.68 141.47,49.77 141.47,50.27 141.38,50.36 141.04,50.36 140.94,50.25 140.94,49.78 140.84,49.68 140.69,49.68 140.58,49.78 140.58,50.25 140.48,50.36 140.33,50.36 140.23,50.25 140.23,49.78 140.12,49.68 139.98,49.68 139.87,49.78 139.87,50.25 139.77,50.36 139.62,50.36 139.52,50.25 139.52,49.78 139.41,49.68 139.27,49.68 139.16,49.78 139.16,50.25 139.06,50.36 138.91,50.36 138.81,50.25 138.81,49.78 138.7,49.68 138.56,49.68 138.45,49.78 138.45,50.25 138.35,50.36 138.2,50.36 138.1,50.25 138.1,49.78 137.99,49.68 137.84,49.68 137.74,49.78 137.74,50.25 137.64,50.36 137.49,50.36 137.38,50.25 137.38,49.78 137.28,49.68 137.13,49.68 137.03,49.78 137.03,50.25 136.92,50.36 125.78,50.36 123.1,53.04 120.49,53.04 119.7,53.83 118.71,53.83 117.87,54.67 117.87,55.49 113.56,59.8 113.56,60.03 111.57,62.02 110.96,62.02 110.09,62.89 110.09,63.26 108.53,64.83 108.53,65.22 v1(108.07,65.68)
  BOTTOM w0.089: DM2.207 162.38,25.27 v1(161.86,24.74) ; v1(108.07,65.68) CPU1.AV30
M_B_DQ27: length 87.9
  L4 w0.089: v1(108.07,66.32) 107.59,65.84 107.59,64.75 107.51,64.67 107.51,64.1 108.87,62.74 109.16,62.74 110.99,60.92 110.99,60.74 111.3,60.43 111.47,60.43 111.89,60.01 111.89,55.29 112.59,54.59 115.34,54.59 116.69,53.24 119.17,53.24 120.85,51.56 120.85,51.26 122.83,49.28 124.02,49.28 124.57,48.73 127.06,48.73 127.16,48.83 127.16,49.22 127.27,49.33 127.42,49.33 127.52,49.22 127.52,48.83 127.62,48.73 129.37,48.73 129.47,48.83 129.47,49.22 129.57,49.33 129.72,49.33 129.83,49.22 129.83,48.83 129.93,48.73 130.08,48.73 130.18,48.83 130.18,49.22 130.29,49.33 130.43,49.33 130.54,49.22 130.54,48.83 130.64,48.73 130.79,48.73 130.89,48.83 130.89,49.22 131,49.33 131.14,49.33 131.25,49.22 131.25,48.83 131.35,48.73 142.21,48.73 149.77,41.17 149.77,40.27 159.94,30.1 159.94,26.95 160.37,26.52 160.37,25.33 161.03,24.67 161.03,22.14 v1(161.64,21.54)
  BOTTOM w0.089: DM2.204 v1(161.64,21.54) ; v1(108.07,66.32) CPU1.AV29
M_B_DQ28: length 86.2
  L4 w0.089: v1(158.3,23.83) 157.65,24.48 157.65,30.16 156.82,30.99 155.85,30.99 148.22,38.62 148.22,40.53 141.76,46.99 121.1,46.99 118.83,49.25 117.39,49.25 116.05,50.6 116.05,52.03 114.76,53.32 110.02,53.32 109.32,54.02 109.32,61.24 108.99,61.57 108.49,61.57 107.32,62.74 106.35,62.74 105.42,63.68 105.42,64.25 105.86,64.69 105.86,65.32 v1(106.24,65.69)
  BOTTOM w0.089: DM2.194 159.14,23 v1(158.3,23.83) ; CPU1.AR30 106.23,65.69 v1(106.24,65.69)
M_B_DQ29: length 86
  L4 w0.089: v1(158.43,22.46) 157.3,23.59 157.3,30.06 156.68,30.67 155.72,30.67 147.9,38.48 147.9,39.95 146.3,41.56 145.96,41.56 140.89,46.62 121.11,46.62 121.07,46.67 120.97,46.67 118.95,48.69 118.95,48.82 118.71,49.05 117.34,49.05 115.87,50.52 115.87,51.95 114.68,53.14 109.95,53.14 109.09,54 109.09,60.04 106.57,62.56 106.28,62.56 105.24,63.6 105.24,64.32 105.68,64.77 105.68,65.39 105.77,65.48 105.77,65.88 106.24,66.35 v1(106.24,66.35)
  BOTTOM w0.089: v1(106.24,66.35) 106.19,66.35 CPU1.AR29 ; DM2.190 158.14,21.11 157.96,21.28 157.96,21.99 v1(158.43,22.46)
M_B_DQ30: length 85.7
  L4 w0.089: v1(107.98,64.28) 108.46,64.28 109.71,63.03 109.71,62.76 110.87,61.61 111.35,61.61 112.1,60.87 112.1,55.33 112.64,54.79 115.43,54.79 116.78,53.44 119.21,53.44 120.05,52.61 122.52,52.61 123.16,51.97 123.16,50.17 123.68,49.64 124.47,49.64 124.57,49.54 124.57,49.41 124.68,49.3 124.83,49.3 124.93,49.41 124.93,49.54 125.03,49.64 125.35,49.64 125.46,49.54 125.46,49.15 125.56,49.05 125.71,49.05 125.81,49.15 125.81,49.54 125.91,49.64 126.06,49.64 126.17,49.54 126.17,49.15 126.27,49.05 126.42,49.05 126.52,49.15 126.52,49.54 126.63,49.64 135.97,49.64 136.57,49.05 142.34,49.05 150.09,41.3 150.09,40.4 160.65,29.84 160.65,25.53 161.39,24.79 161.39,23.06 v1(161.6,22.84)
  BOTTOM w0.089: CPU1.AV32 107.62,64.63 107.96,64.28 v1(107.98,64.28) ; DM2.208 162.64,21.81 v1(161.6,22.84)
M_B_DQ31: length 85.7
  L4 w0.089: v1(108.07,65.04) 108.07,65.04 108.07,65.03 109.89,63.21 109.89,62.84 110.92,61.81 111.4,61.81 112.3,60.91 112.3,55.38 112.69,54.99 115.51,54.99 116.86,53.65 119.3,53.65 120.11,52.83 122.85,52.83 124.35,51.34 124.35,51.19 123.72,50.57 123.72,50.39 123.82,50.29 123.95,50.29 124.6,50.94 124.75,50.94 124.85,50.84 124.85,50.69 124.37,50.22 124.37,50.07 124.48,49.97 124.63,49.97 125.1,50.44 125.25,50.44 125.69,50 136.08,50 136.71,49.36 142.47,49.36 150.41,41.43 150.41,40.53 161.42,29.52 161.42,28.31 161.32,28.21 160.97,28.21 160.87,28.11 160.87,27.96 160.97,27.85 161.32,27.85 161.42,27.75 161.42,27.43 161.32,27.33 160.97,27.33 160.87,27.22 160.87,27.08 160.97,26.97 161.32,26.97 161.42,26.87 161.42,26.72 161.32,26.62 160.97,26.62 160.87,26.51 160.87,26.37 160.97,26.26 161.32,26.26 161.42,26.16 161.42,25.84 v1(161.86,25.4)
  BOTTOM w0.089: DM2.203 161.38,25.88 v1(161.86,25.4) ; v1(108.07,65.04) 108.07,65.05 CPU1.AV31
M_B_DQ32: length 50.9
  L6 w0.089: v1(110.06,58.63) 109.29,57.86 109.29,49.86 109.39,49.76 109.39,42.46 111.2,40.65 111.2,40.18 111.43,39.95 111.57,39.95 111.76,40.14 111.91,40.14 112.01,40.04 112.01,39.89 111.83,39.7 111.83,39.55 111.93,39.45 112.08,39.45 112.27,39.64 112.41,39.64 112.52,39.53 112.52,39.39 112.33,39.2 112.33,39.05 112.43,38.95 112.58,38.95 112.77,39.14 112.92,39.14 113.02,39.03 113.02,38.88 112.83,38.7 112.83,38.55 112.94,38.44 113.08,38.44 113.27,38.63 113.42,38.63 113.52,38.53 113.52,38.38 113.34,38.19 113.34,38.05 113.44,37.94 113.59,37.94 113.77,38.13 113.92,38.13 114.03,38.03 114.03,37.88 113.84,37.69 113.84,37.54 118.35,33.03 118.35,32.9 118.03,32.58 118.03,32.43 118.13,32.33 118.28,32.33 118.78,32.83 118.91,32.83 119.03,32.7 119.03,32.58 118.53,32.08 118.53,31.93 118.64,31.82 118.78,31.82 119.42,32.46 119.57,32.46 119.8,32.24 119.8,32.1 119.45,31.75 119.45,31.02 119.8,30.67 119.8,26.28 v1(119.93,26.14)
  BOTTOM w0.076: CPU1.BA35 109.48,62.69 109.68,62.48 109.72,62.41 109.73,62.38 109.73,62.21 109.71,62.05 109.71,61.88 109.73,61.75 109.76,61.65 109.76,60.55 109.54,60.32 109.54,59.15 v1(110.06,58.63)
  BOTTOM w0.089: DM2.45 119.88,26.19 v1(119.93,26.14)
M_B_DQ33: length 51.6
  L6 w0.089: v1(122.85,22.05) 122.44,22.47 122.44,26.25 121.62,27.07 121.62,27.39 121.72,27.49 122.39,27.49 122.5,27.6 122.5,27.75 122.39,27.85 121.72,27.85 121.62,27.95 121.62,32.95 115.83,38.74 115.83,49.58 114.8,50.61 114.8,51.89 110.06,56.63 v1(110.06,56.64)
  BOTTOM w0.076: v1(110.06,56.64) 109.25,57.45 109.25,58.73 109.04,58.94 109.04,60.61 109.26,60.83 109.26,61.21 109.05,61.42 109.05,61.82 109.06,61.83 109.17,62.02 109.17,62.96 CPU1.BA34
  BOTTOM w0.089: DM2.58 123.14,20.76 123.31,20.94 123.31,21.05 123.33,21.07 123.33,21.58 v1(122.85,22.05)
M_B_DQ34: length 51.4
  L6 w0.089: v1(122.89,23.35) 122.89,28.38 122.79,28.48 122.26,28.48 122.17,28.57 122.17,28.75 122.26,28.84 122.79,28.84 122.89,28.94 122.89,32.37 116.16,39.11 116.16,49.5 114.98,50.68 114.98,51.96 110.67,56.27 110.67,59.06 v1(111.44,59.83)
  BOTTOM w0.076: CPU1.BC35 110.84,62.87 111.1,62.62 111.1,61.99 111.2,61.78 111.2,61.42 110.99,61.21 110.99,60.72 111.44,60.27 v1(111.44,59.83)
  BOTTOM w0.089: DM2.59 123.39,23.84 v1(122.89,23.35)
M_B_DQ35: length 51.7
  L6 w0.089: v1(120.09,24.14) 119.87,23.93 119.33,23.93 119.25,24.02 119.25,28.93 119.35,29.03 119.35,30.66 117.47,32.54 117.47,33.44 110.89,40.03 110.89,40.52 109.07,42.33 109.07,59.17 109.16,59.26 v1(110.07,59.26)
  BOTTOM w0.076: v1(110.07,59.26) 109.7,59.63 109.7,60.26 109.93,60.48 109.93,61.68 109.89,61.79 109.87,61.89 109.87,62.04 109.9,62.2 109.9,62.45 109.87,62.51 109.85,62.53 109.85,63.38 110.06,63.59 CPU1.BC34
  BOTTOM w0.089: v1(120.09,24.14) 119.61,23.66 119.61,21.29 120.14,20.76 DM2.46
M_B_DQ36: length 50.2
  L6 w0.089: v1(120.07,22.79) 120.51,23.22 120.51,24.47 120.43,24.55 120.43,26.96 120.13,27.26 120.13,32.35 119.2,33.28 118.55,33.28 114.34,37.49 114.34,38.16 109.72,42.78 109.72,49.76 109.47,50.02 109.47,57.4 v1(110.06,57.99)
  BOTTOM w0.076: v1(110.06,57.99) 109.6,58.45 109.6,58.86 109.37,59.08 109.37,60.43 109.6,60.66 109.6,61.51 CPU1.BA37
  BOTTOM w0.089: v1(120.07,22.79) 120.99,23.7 120.99,26.52 120.88,26.63 DM2.49
M_B_DQ37: length 50.7
  L6 w0.089: v1(121.7,23.09) 121.03,23.77 121.03,24.29 120.64,24.67 120.64,32.46 116.43,36.68 116.28,36.68 116.15,36.55 116.03,36.55 115.9,36.67 115.9,36.8 116.03,36.93 116.03,37.08 115.93,37.18 115.78,37.18 115.56,36.96 115.42,36.96 115.31,37.07 115.31,37.22 115.53,37.43 115.53,37.58 115.42,37.68 115.28,37.68 115.06,37.47 114.91,37.47 114.81,37.57 114.81,37.72 115.03,37.94 115.03,38.08 110.05,43.06 110.05,49.76 109.65,50.17 109.65,57.05 109.89,57.3 110.05,57.3 v1(110.06,57.31)
  BOTTOM w0.076: v1(110.06,57.31) 109.42,57.95 109.42,58.8 109.21,59.01 109.21,60.5 109.43,60.72 109.43,61.28 109.22,61.49 109.22,61.78 109.34,61.97 109.34,61.98 109.48,62.23 CPU1.BA36
  BOTTOM w0.089: v1(121.7,23.09) 121.14,22.53 DM2.50
M_B_DQ38: length 50.2
  L6 w0.089: v1(124.68,23.56) 123.43,23.56 123.26,23.73 123.26,33.06 116.49,39.83 116.49,49.42 116.05,49.87 116.05,51.78 114.64,53.19 114.06,53.19 110.85,56.4 110.85,57.97 v1(111.43,58.55)
  BOTTOM w0.076: CPU1.BC36 110.78,62.23 110.93,61.95 111.02,61.75 111.03,61.73 111.03,61.49 110.83,61.28 110.83,60.65 111.05,60.43 111.05,58.93 v1(111.43,58.55)
  BOTTOM w0.089: v1(124.68,23.56) 124.14,23.02 DM2.62
M_B_DQ39: length 48.7
  L6 w0.089: v1(124.69,26.25) 124.69,29.77 124.59,29.88 123.86,29.88 123.76,29.98 123.76,30.13 123.86,30.23 124.59,30.23 124.69,30.34 124.69,30.49 124.59,30.59 123.86,30.59 123.76,30.69 123.76,30.84 123.86,30.95 124.59,30.95 124.69,31.05 124.69,31.2 124.59,31.3 123.86,31.3 123.76,31.41 123.76,31.55 123.86,31.66 124.59,31.66 124.69,31.76 124.69,32.08 116.82,39.95 116.82,49.34 116.22,49.94 116.22,51.86 114.66,53.42 114.09,53.42 111.03,56.48 111.03,57.51 v1(111.44,57.91)
  BOTTOM w0.076: CPU1.BC37 110.6,61.46 110.6,60.64 110.88,60.36 110.88,58.47 v1(111.44,57.91)
  BOTTOM w0.089: DM2.63 124.39,26.56 v1(124.69,26.25)
M_B_DQ40: length 53.5
  L6 w0.089: v1(124.7,22.1) 125.35,22.74 125.35,25.9 125.45,26.01 125.98,26.01 126.08,26.11 126.08,26.26 125.98,26.36 125.45,26.36 125.35,26.47 125.35,26.61 125.45,26.72 125.98,26.72 126.08,26.82 126.08,26.97 125.98,27.07 125.45,27.07 125.35,27.18 125.35,27.33 125.45,27.43 125.98,27.43 126.08,27.53 126.08,31.75 118.13,39.7 118.13,42.86 117.49,43.49 117.49,49.56 116.63,50.42 116.63,51.95 114.39,54.19 113.83,54.19 112.39,55.64 112.39,56.33 v1(111.43,57.28)
  BOTTOM w0.076: CPU1.BE35 111.67,62.62 111.64,62.55 111.64,61.93 111.57,61.81 111.57,61.4 111.84,61.13 111.84,57.68 v1(111.43,57.28)
  BOTTOM w0.089: v1(124.7,22.1) 125.14,21.67 DM2.66
M_B_DQ41: length 53.3
  L6 w0.089: v1(112.87,57.64) 113.57,56.94 113.57,55.17 114.19,54.55 114.93,54.55 116.64,52.85 117.72,52.85 118.47,52.1 118.47,49.6 119.31,48.76 119.31,44.1 120.8,42.61 120.8,38 127.36,31.43 127.36,31.1 127.25,31 126.9,31 126.79,30.89 126.79,30.74 126.9,30.64 127.47,30.64 127.6,30.51 127.6,24.16 127.24,23.8 v1(126.91,23.8)
  BOTTOM w0.076: v1(112.87,57.64) 112.67,57.64 112.41,57.89 112.41,61.56 112.26,61.71 112.25,61.76 112.25,63.33 CPU1.BE34
  BOTTOM w0.089: v1(126.91,23.8) 126.14,23.02 DM2.70
M_B_DQ42: length 54
  L6 w0.089: v1(129.74,21.41) 130.19,21.86 130.19,26.57 130.29,26.67 130.78,26.67 130.88,26.77 130.88,26.92 130.78,27.03 130.29,27.03 130.19,27.13 130.19,27.28 130.29,27.38 130.78,27.38 130.88,27.48 130.88,27.63 130.78,27.74 130.29,27.74 130.19,27.84 130.19,31.07 122.42,38.83 122.42,43.31 121.06,44.68 121.06,50.77 120.95,50.88 120.95,52.78 116.87,56.87 v1(114.57,56.87)
  BOTTOM w0.076: v1(114.57,56.87) 114.08,57.36 114.08,60.45 113.66,60.87 113.66,61.35 113.71,61.4 113.71,61.81 113.69,61.85 113.69,61.86 113.59,62.03 113.59,62.18 113.57,62.39 113.54,62.44 113.52,62.46 113.5,62.51 113.29,62.87 CPU1.BG35
  BOTTOM w0.089: DM2.84 129.63,21.31 v1(129.74,21.41)
M_B_DQ43: length 54.1
  L6 w0.089: v1(130.93,25.22) 131.28,25.22 131.37,25.31 131.37,29.54 131.27,29.65 130.61,29.65 130.5,29.75 130.5,29.9 130.61,30 131.27,30 131.37,30.11 131.37,30.42 131.27,30.52 130.61,30.52 130.52,30.61 130.52,31.27 123.23,38.57 123.23,42.01 124.25,43.04 124.25,47.07 123.23,48.09 123.23,51.38 121.97,52.63 121.54,52.63 116.85,57.32 115.47,57.32 v1(114.57,58.22)
  BOTTOM w0.076: CPU1.BG34 113.62,62.91 113.62,62.63 113.65,62.58 113.66,62.55 113.79,62.43 113.94,62.43 114.24,62.12 114.24,61.47 114.47,61.24 114.47,60.29 114.35,60.17 114.35,58.44 v1(114.57,58.22)
  BOTTOM w0.089: DM2.83 129.39,26.76 129.25,26.62 129.25,26.12 130.14,25.22 v1(130.93,25.22)
M_B_DQ44: length 52.2
  L6 w0.089: v1(112.87,56.37) 113.38,55.86 113.38,55.01 114.02,54.37 114.86,54.37 116.56,52.67 117.64,52.67 118.18,52.13 118.18,49.36 117.85,49.02 117.85,43.58 118.45,42.99 118.45,42.28 118.52,42.2 119.26,42.2 119.37,42.09 119.37,41.77 119.27,41.67 118.59,41.67 118.49,41.56 118.49,41.42 118.59,41.31 119.27,41.31 119.37,41.21 119.37,41.06 119.27,40.96 118.59,40.96 118.49,40.85 118.49,40.71 118.59,40.6 119.27,40.6 119.37,40.5 119.37,40.28 119.27,40.18 118.61,40.18 118.51,40.07 118.51,39.93 118.61,39.82 119.27,39.82 119.37,39.72 119.37,38.93 126.44,31.86 126.44,25.6 v1(126.93,25.1)
  BOTTOM w0.076: v1(112.87,56.37) 112.21,57.03 112.21,61.28 111.99,61.49 CPU1.BE37
  BOTTOM w0.089: DM2.71 126.39,25.65 v1(126.93,25.1)
M_B_DQ45: length 52.4
  L6 w0.089: v1(111.46,56.62) 112.21,55.87 112.21,55.56 113.87,53.9 114.43,53.9 116.45,51.88 116.45,50.35 117.15,49.65 117.15,43.37 117.8,42.72 117.8,39.57 125.13,32.23 125.13,31.25 125.23,31.14 125.66,31.14 125.76,31.04 125.76,30.89 125.66,30.79 125.23,30.79 125.13,30.68 125.13,30.54 125.23,30.43 125.66,30.43 125.76,30.33 125.76,30.18 125.66,30.08 125.23,30.08 125.13,29.97 125.13,29.83 125.23,29.72 125.66,29.72 125.76,29.62 125.76,29.47 125.66,29.37 125.23,29.37 125.13,29.26 125.13,29.12 125.23,29.01 125.66,29.01 125.76,28.91 125.76,28.76 125.66,28.66 125.23,28.66 125.13,28.55 125.13,28.4 125.23,28.3 125.66,28.3 125.76,28.2 125.76,28.05 125.66,27.94 125.23,27.94 125.13,27.84 125.13,25.4 v1(124.69,24.96)
  BOTTOM w0.076: v1(111.46,56.62) 112.05,57.21 112.05,61.15 112,61.2 112,61.2 111.74,61.46 111.74,61.48 111.74,61.49 111.74,61.71 arc(111.75,61.76) 111.77,61.81 111.99,62.23 CPU1.BE36
  BOTTOM w0.089: v1(124.69,24.96) 125.55,25.82 125.55,26.64 125.39,26.81 DM2.67
M_B_DQ46: length 53.5
  L6 w0.089: v1(129.71,24.35) 129.3,24.76 129.3,26.64 129.84,27.18 129.84,28.07 129.73,28.17 129.44,28.17 129.33,28.28 129.33,28.43 129.44,28.53 129.73,28.53 129.84,28.63 129.84,28.78 129.73,28.89 129.44,28.89 129.33,28.99 129.33,29.14 129.44,29.24 129.73,29.24 129.84,29.35 129.84,30.95 122.09,38.7 122.09,43.15 120.74,44.5 120.74,52.74 119.63,53.85 118.75,53.85 118.21,54.4 118.21,54.65 116.18,56.67 115.05,56.67 v1(114.51,56.13)
  BOTTOM w0.076: CPU1.BG36 113.29,62.23 113.45,61.94 113.55,61.77 113.55,61.47 113.49,61.42 113.49,60.8 113.82,60.48 113.82,56.82 v1(114.51,56.13)
  BOTTOM w0.089: DM2.79 128.39,26.89 128.35,26.85 128.35,25.24 129.24,24.35 v1(129.71,24.35)
M_B_DQ47: length 52.9
  L6 w0.089: v1(129.74,22.99) 129.57,22.81 128.96,22.81 128.87,22.9 128.87,29.62 128.98,29.72 129.25,29.72 129.36,29.83 129.36,29.97 129.25,30.08 128.98,30.08 128.87,30.18 128.87,30.33 128.98,30.43 129.25,30.43 129.36,30.54 129.36,30.69 129.25,30.79 128.98,30.79 128.87,30.89 128.87,31.21 121.76,38.32 121.76,43.01 120.41,44.37 120.41,52.07 119,53.48 117.08,53.48 115.08,55.48 v1(114.52,55.48)
  BOTTOM w0.076: CPU1.BG37 113.18,61.52 113.18,60.89 113.61,60.45 113.61,56.39 v1(114.52,55.48)
  BOTTOM w0.089: DM2.80 128.63,21.88 v1(129.74,22.99)
M_B_DQ48: length 80.8
  L4 w0.089: v1(109.91,64.37) 109.91,64.37 110.46,63.83 110.46,63.03 111.05,62.44 111.71,62.44 114.01,60.13 114.01,59.85 118.74,55.12 119.08,55.12 120.75,53.44 123.79,53.44 126.11,51.13 130.23,51.13 130.33,51.24 130.33,51.8 130.43,51.91 130.58,51.91 130.69,51.8 130.69,51.24 130.79,51.13 142.05,51.13 151.36,41.83 151.36,41.2 163.83,28.72 163.83,24.46 v1(163.41,24.03)
  BOTTOM w0.089: CPU1.BA32 109.68,64.39 109.89,64.39 v1(109.91,64.37) ; DM2.215 164.38,27.09 164.3,27 164.3,24.93 v1(163.41,24.03)
M_B_DQ49: length 81.9
  L4 w0.089: v1(163.43,23.4) 164.06,24.03 164.06,28.94 151.68,41.33 151.68,41.96 149.96,43.68 149.96,45.23 142.96,52.23 125.52,52.23 124.09,53.65 120.82,53.65 119.14,55.32 118.79,55.32 114.31,59.8 114.31,60.09 111.79,62.61 111.12,62.61 110.64,63.09 110.64,64.28 109.89,65.04 v1(109.89,65.05)
  BOTTOM w0.089: DM2.216 164.64,22.5 163.79,23.35 163.51,23.35 163.46,23.4 v1(163.43,23.4) ; v1(109.89,65.05) CPU1.BA31
M_B_DQ50: length 83.3
  L4 w0.089: v1(111.68,65) 111.68,64.9 112.12,64.45 112.12,64.13 112.4,63.85 112.4,63.42 113.51,62.31 114.55,62.31 118.69,58.17 119.2,58.17 120.25,57.13 122.45,57.13 122.88,56.7 123.07,56.7 123.17,56.59 123.17,56.22 123.28,56.11 123.42,56.11 123.53,56.22 123.53,56.59 123.63,56.7 126.22,56.7 128.41,54.51 143.08,54.51 151.64,45.95 151.64,44.19 153.23,42.6 153.23,42.03 165.81,29.44 165.81,27.63 167.04,26.4 167.04,24.77 167.88,23.94 167.88,23.16 167.17,22.45 v1(167.17,22.13)
  BOTTOM w0.089: CPU1.BD31 111.4,65.28 v1(111.68,65) ; DM2.228 167.64,21.06 167.67,21.1 167.67,21.62 v1(167.17,22.13)
M_B_DQ51: length 83.3
  L4 w0.089: v1(111.67,64.33) 112.22,63.78 112.22,63.35 113.44,62.13 114.45,62.13 118.59,57.99 119.13,57.99 120.27,56.85 120.57,56.85 121.48,55.93 125.17,55.93 126.71,54.38 127.64,54.38 127.66,54.41 128.06,54.41 128.27,54.19 128.91,54.19 129.01,54.09 129.01,53.65 129.12,53.55 129.26,53.55 129.37,53.65 129.37,54.09 129.47,54.19 129.62,54.19 129.72,54.09 129.72,53.65 129.83,53.55 129.97,53.55 130.08,53.65 130.08,54.09 130.18,54.19 142.94,54.19 151.32,45.82 151.32,44.06 152.91,42.47 152.91,41.89 165.5,29.31 165.5,27.64 166.69,26.45 166.69,24.36 v1(167.45,23.6)
  BOTTOM w0.089: v1(167.45,23.6) 166.7,22.85 166.7,21.3 166.64,21.24 DM2.224 ; v1(111.67,64.33) 111.64,64.33 111.62,64.36 111.53,64.36 CPU1.BD32
M_B_DQ52: length 82.2
  L4 w0.089: v1(163.38,26.09) 163.51,26.09 163.6,26.18 163.6,27.19 163.51,27.28 162.21,27.28 162.12,27.37 162.12,27.67 162.23,27.77 163.41,27.77 163.5,27.86 163.5,28.04 163.41,28.13 162.23,28.13 162.12,28.23 162.12,28.38 162.23,28.48 163.41,28.48 163.5,28.57 163.5,28.75 163.41,28.84 162.23,28.84 162.12,28.94 162.12,29.81 151.04,40.9 151.04,41.69 142.02,50.71 125.93,50.71 123.4,53.24 120.69,53.24 119.02,54.92 118.69,54.92 113.84,59.77 113.84,60.06 111.69,62.2 111.03,62.2 110.27,62.96 110.27,63.33 109.44,64.16 109.44,65.24 v1(109.89,65.68)
  BOTTOM w0.089: DM2.211 163.38,26.09 v1(163.38,26.09) ; v1(109.89,65.68) CPU1.BA30
M_B_DQ53: length 83.5
  L4 w0.089: v1(163.51,21.47) 164.38,22.34 164.38,29.09 151.99,41.47 151.99,42.09 150.31,43.77 150.31,45.41 143.14,52.58 125.6,52.58 122.9,55.27 119.45,55.27 119.12,55.6 118.92,55.6 115.26,59.26 115.26,60.5 114.23,61.53 113.16,61.53 111.89,62.79 111.2,62.79 110.82,63.17 110.82,64.36 110.32,64.85 110.32,65.88 v1(109.89,66.32)
  BOTTOM w0.089: v1(163.51,21.47) 163.64,21.34 DM2.212 ; v1(109.89,66.32) CPU1.BA29
M_B_DQ54: length 84.5
  L4 w0.089: v1(167.83,24.72) 168.25,25.14 168.25,27.02 168.15,27.12 167.71,27.12 167.61,27.22 167.61,27.37 167.71,27.48 168.15,27.48 168.25,27.58 168.25,27.9 168.14,28.01 166.6,28.01 166.47,28.15 166.47,29.68 156.03,40.12 156.03,41.56 152.27,45.31 152.27,46.21 143.26,55.22 128.7,55.22 126.62,57.31 123.06,57.31 122.73,57.64 121.28,57.64 118.97,59.95 118.51,59.95 116.38,62.08 115.28,62.08 114.63,62.73 113.66,62.73 112.9,63.5 112.9,63.86 112.48,64.27 112.48,64.6 112.26,64.82 112.26,65.38 112.19,65.46 112.19,65.84 v1(111.71,66.32)
  BOTTOM w0.089: DM2.225 166.89,25.18 167.35,24.72 v1(167.83,24.72) ; v1(111.71,66.32) CPU1.BD29
M_B_DQ55: length 83.5
  L4 w0.089: v1(167.79,25.99) 167.35,26.42 167.35,27.51 167.23,27.64 166.22,27.64 166.14,27.73 166.14,29.56 155.14,40.56 155.14,41.93 154.91,42.16 154.76,42.16 154.23,41.62 154.08,41.62 153.98,41.72 153.98,41.87 154.51,42.41 154.51,42.56 153.26,43.81 153.11,43.81 152.86,43.56 152.71,43.56 152.61,43.67 152.61,43.82 152.86,44.06 152.86,44.21 152.75,44.32 152.6,44.32 152.36,44.07 152.21,44.07 152.1,44.17 152.1,44.32 152.35,44.57 152.35,44.72 151.96,45.11 151.96,46.08 143.17,54.87 128.55,54.87 126.47,56.95 123.06,56.95 122.55,57.46 121.2,57.46 120.99,57.67 120.84,57.67 120.49,57.33 120.35,57.33 120.24,57.43 120.24,57.58 120.59,57.92 120.59,58.07 118.94,59.72 118.46,59.72 116.28,61.9 115.2,61.9 114.58,62.52 113.55,62.52 112.65,63.42 112.65,63.85 112.3,64.2 112.3,64.52 112.08,64.74 112.08,65.31 v1(111.71,65.68)
  BOTTOM w0.089: v1(111.71,65.68) CPU1.BD30 ; v1(167.79,25.99) 167.89,26.08 DM2.229
M_B_DQ56: length 85
  L4 w0.089: v1(113.58,65.59) 113.99,65.18 113.99,64.29 114.29,63.99 114.44,63.99 115.6,62.84 117.1,62.84 117.7,62.23 118.92,62.23 121.57,59.59 122.1,59.59 123.18,58.5 133.43,58.5 135.28,56.64 143.64,56.64 153.54,46.74 153.54,45.84 157.35,42.04 157.35,40.6 171.83,26.12 171.83,25.8 171.72,25.7 171.17,25.7 171.06,25.59 171.06,25.45 171.17,25.34 171.72,25.34 171.83,25.24 171.83,24.6 171.74,24.51 170.81,24.51 v1(170.51,24.81)
  BOTTOM w0.089: v1(170.51,24.81) 170.31,24.81 169.82,25.3 169.82,27.88 DM2.237 ; CPU1.BG31 113.36,65.56 113.53,65.56 113.56,65.59 v1(113.58,65.59)
M_B_DQ57: length 84.9
  L4 w0.089: v1(169.33,25.23) 169.81,25.71 169.81,27.69 156.98,40.52 156.98,41.95 153.23,45.71 153.23,46.61 143.54,56.29 135.13,56.29 133.31,58.12 132.99,58.12 132.88,58.01 132.88,57.21 132.78,57.1 132.63,57.1 132.53,57.21 132.53,58.01 132.42,58.12 132.28,58.12 132.17,58.01 132.17,57.21 132.07,57.1 131.92,57.1 131.82,57.21 131.82,58.01 131.71,58.12 131.57,58.12 131.46,58.01 131.46,57.21 131.36,57.1 131.21,57.1 131.11,57.21 131.11,58.01 130.85,58.27 123.06,58.27 122.24,59.08 120.62,59.08 119.91,59.79 119.91,60.84 118.71,62.03 117.65,62.03 117.02,62.66 115.52,62.66 114.37,63.81 114.21,63.81 113.67,64.35 v1(113.56,64.35)
  BOTTOM w0.089: DM2.233 168.89,25.67 v1(169.33,25.23) ; v1(113.56,64.35) 113.53,64.35 113.42,64.47 CPU1.BG32
M_B_DQ58: length 84.6
  L4 w0.089: v1(115.67,64.14) 116.64,64.14 117.01,63.77 117.48,63.77 118.36,62.89 119.9,62.89 121.24,61.55 124.02,61.55 125.17,60.4 125.17,60.25 125.06,60.15 125.06,60 125.16,59.9 125.31,59.9 125.42,60 125.57,60 125.71,59.86 126.01,59.86 126.11,59.75 126.11,59.49 126.22,59.39 126.36,59.39 126.47,59.49 126.47,59.75 126.57,59.86 126.72,59.86 126.82,59.75 126.82,59.49 126.93,59.39 127.08,59.39 127.18,59.49 127.18,59.75 127.28,59.86 127.43,59.86 127.54,59.75 127.54,59.49 127.64,59.39 127.79,59.39 127.89,59.49 127.89,59.75 128,59.86 133.54,59.86 135.73,57.67 143.94,57.67 154.5,47.11 154.5,46.18 158.26,42.42 158.26,40.98 172.49,26.75 172.49,22.11 173.18,21.41 v1(173.19,21.41)
  BOTTOM w0.089: DM2.250 173.14,21.36 v1(173.19,21.41) ; v1(115.67,64.14) 115.66,64.14 115.61,64.09 115.44,64.09 CPU1.BK32
M_B_DQ59: length 85.5
  L4 w0.089: v1(173.15,22.68) 172.72,23.12 172.72,26.97 158.58,41.11 158.58,42.55 154.81,46.32 154.81,47.24 144.03,58.03 140.21,58.03 140.11,58.13 140.11,58.52 140,58.63 139.86,58.63 139.75,58.52 139.75,58.13 139.65,58.03 139.5,58.03 139.4,58.13 139.4,58.52 139.29,58.63 139.14,58.63 139.04,58.52 139.04,58.13 138.94,58.03 135.87,58.03 134.35,59.55 134.35,59.7 134.55,59.89 134.55,60.04 134.44,60.14 134.29,60.14 134.1,59.95 133.95,59.95 133.73,60.18 125.65,60.18 124.1,61.72 121.36,61.72 119.04,64.04 116.99,64.04 116.02,65.01 v1(115.35,65.01)
  BOTTOM w0.089: v1(173.15,22.68) 172.14,21.67 DM2.246 ; CPU1.BK31 115.13,65.28 115.3,65.11 115.3,65.06 v1(115.35,65.01)
M_B_DQ60: length 86
  L4 w0.089: v1(113.5,66.94) 113.02,66.46 113.02,66.15 113.01,66.14 113.01,65.3 113.1,65.2 113.1,64.8 112.92,64.62 112.92,64.09 113.5,63.51 113.5,63.14 113.74,62.91 114.73,62.91 115.38,62.26 116.5,62.26 118.61,60.15 119.02,60.15 120.59,58.58 122.14,58.58 122.93,57.79 126.64,57.79 128.85,55.58 143.36,55.58 152.59,46.34 152.59,45.44 156.34,41.69 156.34,40.25 168.65,27.95 168.65,23.8 168.93,23.52 169.21,23.52 169.36,23.37 169.36,22.22 169.23,22.08 v1(168.22,22.08)
  BOTTOM w0.089: DM2.232 168.64,20.79 168.75,20.91 168.75,21.55 v1(168.22,22.08) ; v1(113.5,66.94) 113.14,66.58 CPU1.BG29
