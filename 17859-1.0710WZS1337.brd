# Allegro board 17859-1.0710WZS1337.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_A7: length 74
  L6 w0.142: v1(94.15,56.07) 93.26,55.18 93.26,52.61 91.57,50.91 91.57,48.68 85.42,42.52 85.03,42.52 84.58,42.98 84.26,42.98 83.94,42.66 83.94,42.43 84.51,41.86 84.51,41.62 84.35,41.46 84.11,41.46 83.54,42.03 83.31,42.03 83.14,41.86 83.14,41.62 83.71,41.05 83.71,40.82 83.54,40.65 83.31,40.65 82.74,41.22 82.5,41.22 82.34,41.05 82.34,40.82 82.91,40.25 82.91,40.01 82.74,39.85 82.5,39.85 81.93,40.42 81.7,40.42 81.53,40.25 81.53,40.01 82.1,39.44 82.1,39.21 81.93,39.04 81.7,39.04 81.13,39.61 80.89,39.61 80.73,39.44 80.73,39.21 81.3,38.64 81.3,38.4 81.13,38.24 80.89,38.24 80.32,38.81 80.09,38.81 79.92,38.64 79.92,38.4 80.49,37.83 80.49,37.6 80.32,37.43 80.09,37.43 79.52,38 79.28,38 78.13,36.85 71.91,36.85 61.33,26.26 61.33,21.96 v1(62.1,21.19)
  BOTTOM w0.076: v1(94.15,56.07) 94.46,56.39 94.46,56.94 95.03,57.51 95.03,58.95 96.51,60.42 96.54,60.42 96.85,60.73 96.85,61.27 96.64,61.49 96.64,61.77 96.89,62.23 CPU1.AA36
  BOTTOM w0.14: DM1.122 62.14,20.58 62.1,20.61 v1(62.1,21.19)
M_A_A8: length 70.5
  L6 w0.142: v1(94.11,53.5) 94.11,52.36 92.5,50.75 92.5,47.01 85.26,39.78 85.02,39.78 84.6,40.2 84.36,40.2 84.19,40.04 84.19,39.8 84.62,39.37 84.62,39.14 84.45,38.97 84.22,38.97 83.79,39.4 83.56,39.4 83.39,39.23 83.39,39 83.82,38.57 83.82,38.33 83.65,38.17 83.41,38.17 82.99,38.59 82.75,38.59 82.59,38.43 82.59,38.19 83.01,37.76 83.01,37.53 82.84,37.36 82.61,37.36 82.18,37.79 81.95,37.79 81.78,37.62 81.78,37.39 82.21,36.96 82.21,36.72 82.04,36.56 81.8,36.56 81.38,36.98 81.14,36.98 80.98,36.82 80.98,36.58 81.4,36.16 81.4,35.92 81.22,35.74 80.12,35.74 79.98,35.88 79.98,36.35 79.81,36.51 79.58,36.51 79.41,36.35 79.41,35.88 79.27,35.74 72.14,35.74 62.9,26.5 62.9,25.24 62.73,25.07 v1(62.05,25.07)
  BOTTOM w0.076: CPU1.AB34 97.29,63.01 97.29,62.51 97.31,62.44 97.31,62.18 97.29,62.06 97.29,61.88 97.35,61.67 97.35,60.53 96.75,59.93 96.71,59.93 95.58,58.79 95.58,56.66 95.34,56.42 95.34,54.72 v1(94.11,53.5)
  BOTTOM w0.14: DM1.125 62.89,25.85 62.1,25.07 v1(62.05,25.07)
M_A_A9: length 71.5
  L6 w0.142: v1(94.04,56.75) 93.02,55.73 93.02,52.77 91.12,50.87 91.12,48.86 88.9,46.64 88.5,46.64 88.04,47.09 87.74,47.09 87.43,46.78 87.43,46.54 88,45.97 88,45.74 87.83,45.57 87.59,45.57 87.02,46.14 86.79,46.14 86.62,45.97 86.62,45.74 87.19,45.17 87.19,44.93 87.03,44.77 86.79,44.77 86.22,45.33 85.98,45.33 85.82,45.17 85.82,44.93 86.39,44.36 86.39,44.13 86.22,43.96 85.99,43.96 85.42,44.53 85.18,44.53 85.01,44.36 85.01,44.13 85.58,43.56 85.58,43.32 85.42,43.16 85.18,43.16 84.61,43.73 84.37,43.73 77.96,37.32 71.75,37.32 61,26.57 61,23.95 v1(60.52,23.47)
  BOTTOM w0.076: v1(94.04,56.75) 93.62,57.17 93.62,58.34 95.69,60.4 95.69,61.23 95.9,61.44 95.93,61.51 95.93,61.72 95.9,61.81 95.69,62.27 CPU1.W36
  BOTTOM w0.14: v1(60.52,23.47) 60.55,23.47 61.28,24.2 61.28,26.31 61.89,26.92 DM1.121
M_A_A10: length 72.8
  L6 w0.142: v1(70.17,23.2) 70.17,25.73 74.32,29.89 85.69,29.89 97.76,41.95 97.76,50.19 97.9,50.34 97.9,60.13 97.89,60.14 97.89,60.16 97.37,60.68 97.37,61.61 95.83,63.15 95.83,64.47 v1(95.31,64.98)
  BOTTOM w0.14: DM1.146 70.13,20.96 69.98,21.12 69.23,21.12 69.03,21.32 69.03,21.62 69.18,21.78 69.74,21.78 69.9,21.93 69.9,22.26 69.74,22.41 68.98,22.41 68.82,22.56 68.82,22.89 68.98,23.04 69.48,23.04 69.64,23.19 69.64,23.5 69.48,23.65 68.98,23.65 68.82,23.8 68.82,24.09 69.08,24.34 69.49,24.34 70.17,23.67 v1(70.17,23.2) ; v1(95.31,64.98) 95.35,64.94 96.01,64.94 CPU1.Y31
M_A_A11: length 69.5
  L6 w0.142: v1(92.09,54.41) 91.64,53.96 91.64,52.89 80.02,41.27 79.78,41.27 79.33,41.72 79.09,41.72 78.93,41.55 78.93,41.32 79.38,40.86 79.38,40.63 79.21,40.46 78.98,40.46 78.52,40.91 78.29,40.91 78.12,40.75 78.12,40.51 78.58,40.06 78.58,39.82 78.41,39.66 78.17,39.66 77.72,40.11 77.48,40.11 77.32,39.94 77.32,39.71 77.77,39.25 77.77,39.02 77.45,38.7 71.24,38.7 69.12,36.58 68.14,36.58 66.21,34.65 66.21,33.68 59.39,26.87 59.39,23.76 59.73,23.42 59.73,22.28 59.99,22.02 v1(60.55,22.02)
  BOTTOM w0.076: v1(92.09,54.41) 93.24,55.57 93.24,58.45 95.28,60.5 95.28,62.97 95.41,63.32 CPU1.W34
  BOTTOM w0.14: DM1.120 61.63,21.78 61.39,22.02 v1(60.55,22.02)
M_A_A12: length 71.9
  L6 w0.142: v1(60.14,24.13) 60.51,24.13 60.65,24.28 60.65,25.5 60.48,25.66 60.23,25.66 60.07,25.83 60.07,26.07 60.23,26.23 60.48,26.23 60.65,26.4 60.65,26.85 71.59,37.79 77.81,37.79 87.77,47.76 88.01,47.76 88.58,47.19 88.82,47.19 88.98,47.35 88.98,47.59 88.41,48.16 88.41,48.4 88.58,48.56 88.81,48.56 89.38,47.99 89.62,47.99 89.79,48.16 89.79,48.39 89.22,48.96 89.22,49.2 89.49,49.47 89.69,49.47 90.19,48.97 90.39,48.97 90.68,49.26 90.68,49.56 90.16,50.07 90.16,50.35 92.78,52.96 92.78,56.73 92.95,56.9 93.25,56.9 93.42,57.06 93.42,57.3 93.25,57.46 92.95,57.46 92.78,57.63 92.78,58.46 92.92,58.6 93.75,58.6 94.02,58.33 v1(94.02,58.05)
  BOTTOM w0.076: v1(94.02,58.05) 94.45,58.05 94.82,58.42 94.82,58.97 96.44,60.59 96.47,60.59 96.69,60.8 96.69,61.14 96.47,61.36 96.47,61.81 96.49,61.85 96.59,62.02 96.59,62.96 CPU1.AA34
  BOTTOM w0.14: DM1.119 61.39,27.95 61.39,26.93 61,26.54 61,24.99 v1(60.14,24.13)
M_A_A13: length 72.3
  L6 w0.142: v1(98.06,64.37) 98.54,64.37 99.61,63.3 99.61,61.01 100.15,60.48 100.15,41.16 99.56,40.57 99.56,40.39 100.15,39.8 100.15,39.56 99.83,39.24 99.59,39.24 99.03,39.8 98.79,39.8 98.63,39.64 98.63,39.4 99.19,38.84 99.19,38.6 99.02,38.43 98.79,38.43 98.22,39 97.99,39 97.82,38.83 97.82,38.6 98.39,38.03 98.39,37.8 98.22,37.63 97.98,37.63 97.42,38.19 97.18,38.19 97.02,38.03 97.02,37.79 97.58,37.23 97.58,36.99 88.58,27.99 75.1,27.99 72.94,25.83 v1(72.94,23.96)
  BOTTOM w0.14: CPU1.AC32 v1(98.06,64.37) ; v1(72.94,23.96) 73.27,23.96 73.68,23.55 73.68,22.15 73.13,21.61 DM1.158
M_A_A14: length 73.8
  L6 w0.142: v1(71.87,24.75) 72.33,25.21 72.33,25.64 74.99,28.3 88.22,28.3 93.43,33.51 93.43,33.74 92.88,34.29 92.88,34.53 93.05,34.69 93.29,34.69 93.83,34.14 94.07,34.14 94.24,34.31 94.24,34.55 93.69,35.1 93.69,35.33 93.85,35.5 94.09,35.5 94.64,34.95 94.87,34.95 95.04,35.12 95.04,35.35 94.49,35.9 94.49,36.14 94.66,36.3 94.89,36.3 95.44,35.75 95.68,35.75 95.85,35.92 95.85,36.16 95.3,36.71 95.3,36.94 95.46,37.11 95.7,37.11 96.25,36.56 96.48,36.56 96.65,36.73 96.65,36.96 96.1,37.51 96.1,37.75 99.68,41.32 99.68,49.95 99.91,50.17 99.91,60.37 99.36,60.91 99.36,62.13 97.61,63.88 97.61,64.62 v1(98.04,65.05)
  BOTTOM w0.14: v1(98.04,65.05) CPU1.AC31 ; v1(71.87,24.75) 71.48,24.75 71.16,25.06 71.16,25.59 71.36,25.78 71.62,25.78 71.79,25.96 71.79,26.2 71.64,26.35 71.32,26.35 71.16,26.5 71.16,26.81 71.39,27.03 71.39,27.95 DM1.151
M_A_A15: length 73.3
  L6 w0.142: v1(97.14,64.32) 97.14,64.02 98.16,63 98.16,61.02 99.63,59.55 99.63,50.36 99.21,49.94 99.21,41.48 92.09,34.36 92.09,34.13 92.57,33.64 92.57,33.41 92.4,33.24 92.17,33.24 91.68,33.72 91.45,33.72 91.28,33.56 91.28,33.32 91.77,32.84 91.77,32.6 91.6,32.43 91.36,32.43 90.88,32.92 90.64,32.92 90.48,32.75 90.48,32.52 90.96,32.03 90.96,31.8 90.79,31.63 90.56,31.63 90.07,32.11 89.84,32.11 89.67,31.95 89.67,31.71 90.16,31.23 90.16,30.99 89.99,30.82 89.75,30.82 89.27,31.31 89.03,31.31 88.87,31.14 88.87,30.91 89.35,30.42 89.35,30.19 87.75,28.59 74.42,28.59 71.4,25.57 71.4,24.38 71.55,24.23 v1(71.55,22.38)
  BOTTOM w0.14: v1(71.55,22.38) 71.69,22.38 72.63,21.44 DM1.156 ; v1(97.14,64.32) 97.14,64.39 97.18,64.42 CPU1.AB32
M_A_A16: length 69
  L6 w0.142: v1(97.17,64.96) 96.7,64.5 96.7,64.05 97.88,62.88 97.88,60.9 99.4,59.37 99.4,50.61 98.74,49.95 98.74,41.65 88.06,30.97 88.06,30.74 88.49,30.3 88.49,30.07 88.33,29.9 88.09,29.9 87.66,30.33 87.42,30.33 87.26,30.17 87.26,29.93 87.69,29.5 87.69,29.26 87.52,29.1 87.29,29.1 86.85,29.53 86.62,29.53 85.95,28.86 74.31,28.86 71.1,25.65 71.1,22.2 71.57,21.72 v1(71.67,21.72)
  BOTTOM w0.14: DM1.152 71.64,19.75 71.64,21.68 71.67,21.72 v1(71.67,21.72) ; v1(97.17,64.96) 97.01,64.96 CPU1.Y32
M_A_ACT_N: length 71.5
  L6 w0.142: v1(59.22,23.19) 59.13,23.29 59.13,27.37 65.76,34.01 65.76,34.84 67.95,37.03 68.93,37.03 71.05,39.15 75.89,39.15 79.82,43.08 80.05,43.08 80.48,42.65 80.72,42.65 80.88,42.82 80.88,43.05 80.46,43.48 80.46,43.71 80.62,43.88 80.86,43.88 81.28,43.45 81.52,43.45 81.69,43.62 81.69,43.86 81.26,44.28 81.26,44.52 81.43,44.69 81.66,44.69 82.09,44.26 82.32,44.26 82.49,44.43 82.49,44.66 82.06,45.09 82.06,45.32 82.23,45.49 82.47,45.49 82.89,45.06 83.13,45.06 83.3,45.23 83.3,45.47 82.87,45.89 82.87,46.13 83.04,46.3 83.27,46.3 83.7,45.87 83.93,45.87 84.1,46.03 84.1,46.27 83.67,46.7 83.67,46.93 83.84,47.1 84.08,47.1 84.5,46.67 84.74,46.67 84.91,46.84 84.91,47.08 84.48,47.5 84.48,47.74 84.65,47.9 84.88,47.9 85.31,47.48 85.54,47.48 91.33,53.27 91.33,54.93 v1(92.09,55.68)
  BOTTOM w0.076: v1(92.09,55.68) 92.89,56.49 92.89,58.61 94.79,60.51 94.79,60.51 94.79,60.52 94.79,61.78 94.78,61.82 94.77,61.9 94.77,62.06 CPU1.V35
  BOTTOM w0.14: v1(59.22,23.19) 59.63,22.78 59.63,21.31 60.14,20.81 DM1.114
M_A_ALERT_N: length 61.2
  L6 w0.142: v1(60.5,22.79) 60.04,23.25 60.04,23.53 59.66,23.9 59.66,26.49 71.42,38.26 77.64,38.26 88.95,49.57 88.95,49.61 92.09,52.75 v1(92.09,53.78)
  BOTTOM w0.076: CPU1.W37 95.47,61.43 95.47,60.45 95.45,60.43 95.45,60.43 93.45,58.43 93.45,55.14 v1(92.09,53.78)
  BOTTOM w0.14: DM1.116 60.63,20.74 60.04,21.34 60.04,22.33 v1(60.5,22.79)
M_A_BA0: length 68.4
  L6 w0.142: v1(95.31,64.35) 95.31,63.16 97.11,61.36 97.11,60.6 97.67,60.04 97.67,50.81 97.29,50.42 97.29,42.18 85.44,30.34 74.14,30.34 69.72,25.92 69.72,22.99 68.57,21.85 68.57,21.49 69.01,21.06 69.31,21.06 70.17,21.92 v1(70.49,21.92)
  BOTTOM w0.14: v1(70.49,21.92) 70.62,22.05 71,22.05 71.13,21.91 DM1.150 ; CPU1.W32 95.65,64.52 v1(95.31,64.35)
M_A_BA1: length 71.3
  L6 w0.142: v1(97.12,65.67) 96.33,65.67 96.18,65.52 96.18,64.21 97.61,62.79 97.61,60.78 99.17,59.22 99.17,54.91 98.8,54.54 98.8,54.13 99.17,53.76 99.17,51.04 98.27,50.14 98.27,41.83 85.88,29.44 74.51,29.44 70.62,25.55 70.62,22.75 v1(70.43,22.56)
  BOTTOM w0.14: CPU1.AB31 97.2,65.67 v1(97.12,65.67) ; DM1.145 69.89,24.9 71.19,23.6 71.19,22.7 71.05,22.56 v1(70.43,22.56)
M_A_BG0: length 72.9
  L6 w0.142: v1(58.01,22.53) 58.02,22.53 58.74,23.26 58.74,27.86 65.32,34.44 65.32,35.02 68.12,37.82 69.1,37.82 70.87,39.6 75.7,39.6 85.08,48.97 85.31,48.97 85.74,48.54 85.97,48.54 86.14,48.71 86.14,48.94 85.71,49.37 85.71,49.61 85.88,49.77 86.12,49.77 86.54,49.35 86.78,49.35 86.94,49.51 86.94,49.75 86.52,50.17 86.52,50.41 86.69,50.58 86.92,50.58 87.35,50.15 87.58,50.15 87.75,50.32 87.75,50.55 87.32,50.98 87.32,51.22 87.49,51.38 87.73,51.38 88.15,50.96 88.39,50.96 88.55,51.12 88.55,51.36 88.13,51.78 88.13,52.02 88.29,52.19 88.53,52.19 88.96,51.76 89.19,51.76 91.08,53.65 91.08,55.28 v1(92.11,56.32)
  BOTTOM w0.076: CPU1.V34 94.63,62.86 94.63,62.22 94.62,62.12 94.61,62.1 94.61,61.88 94.63,61.72 94.63,60.58 92.72,58.67 92.72,56.93 v1(92.11,56.32)
  BOTTOM w0.14: DM1.115 60.39,27.95 60.39,26.94 60.29,26.84 60.29,26.18 58.54,24.44 58.54,23.05 58.02,22.53 v1(58.01,22.53)
M_A_BG1: length 72.6
  L6 w0.142: v1(57.98,24.44) 57.98,24.44 57.26,25.15 57.26,28.92 69.41,41.07 73.91,41.07 76.63,43.79 76.63,44.03 76.53,44.13 76.53,44.37 76.69,44.54 76.93,44.54 77.03,44.43 77.27,44.43 77.43,44.6 77.43,44.84 77.33,44.94 77.33,45.17 77.5,45.34 77.73,45.34 77.84,45.24 78.07,45.24 78.24,45.4 78.24,45.64 78.14,45.74 78.14,45.98 78.3,46.14 78.54,46.14 78.64,46.04 78.88,46.04 79.04,46.21 79.04,46.44 78.94,46.55 78.94,46.78 79.11,46.95 79.34,46.95 79.45,46.85 79.68,46.85 79.85,47.01 79.85,47.25 79.75,47.35 79.75,47.59 79.91,47.75 80.15,47.75 80.25,47.65 80.49,47.65 80.8,47.97 80.8,48.2 80.7,48.31 80.7,48.54 80.87,48.71 81.1,48.71 81.21,48.61 81.44,48.61 81.61,48.77 81.61,49.01 81.51,49.11 81.51,49.35 81.67,49.51 81.91,49.51 82.01,49.41 82.25,49.41 82.41,49.58 82.41,49.81 82.31,49.92 82.31,50.15 82.48,50.32 82.71,50.32 82.82,50.22 83.05,50.22 83.22,50.38 83.22,50.62 83.12,50.72 83.12,50.96 83.28,51.12 83.52,51.12 83.62,51.02 83.86,51.02 84.02,51.19 84.02,51.42 83.92,51.53 83.92,51.76 84.09,51.93 84.32,51.93 84.42,51.83 84.66,51.83 84.83,51.99 84.83,52.23 84.72,52.33 84.72,52.57 84.89,52.73 85.13,52.73 85.23,52.63 85.46,52.63 85.63,52.8 85.63,53.03 85.53,53.13 85.53,53.37 85.7,53.54 85.93,53.54 86.03,53.43 86.27,53.43 87.47,54.64 87.47,57.57 88.89,58.99 88.91,58.99 88.92,59 93.96,59 v1(94.4,58.56)
  BOTTOM w0.076: CPU1.W35 95.92,62.42 95.93,62.36 96.04,61.94 96.08,61.79 96.1,61.75 96.1,61.48 96.04,61.34 95.88,61.19 95.88,60.3 94.4,58.82 v1(94.4,58.56)
  BOTTOM w0.14: DM1.113 59.89,26.24 58.08,24.44 v1(57.98,24.44)
M_A_CKE0: length 74.5
  L6 w0.142: v1(57.98,25.88) 57.71,25.88 57.53,26.06 57.53,27.21 57.7,27.38 58.01,27.38 58.18,27.54 58.18,27.78 58.01,27.95 57.7,27.95 57.53,28.11 57.53,28.56 58.32,29.35 58.56,29.35 58.64,29.26 58.88,29.26 59.05,29.43 59.05,29.66 58.96,29.75 58.96,29.99 59.12,30.15 59.36,30.15 59.45,30.07 59.68,30.07 59.85,30.23 59.85,30.47 59.76,30.56 59.76,30.79 59.93,30.96 60.16,30.96 60.25,30.87 60.49,30.87 60.65,31.04 60.65,31.27 60.57,31.36 60.57,31.6 60.73,31.76 60.97,31.76 61.06,31.68 61.29,31.68 61.46,31.84 61.46,32.08 61.37,32.17 61.37,32.4 69.59,40.62 74.2,40.62 74.83,41.25 75.07,41.25 75.46,40.86 75.7,40.86 75.87,41.02 75.87,41.26 75.47,41.65 75.47,41.89 75.64,42.06 75.87,42.06 76.27,41.66 76.5,41.66 76.67,41.83 76.67,42.06 76.28,42.46 76.28,42.69 76.44,42.86 76.68,42.86 77.07,42.47 77.31,42.47 77.47,42.63 77.47,42.87 77.08,43.26 77.08,43.5 77.25,43.66 77.48,43.66 77.88,43.27 78.11,43.27 78.28,43.44 78.28,43.67 77.89,44.07 77.89,44.3 78.05,44.47 78.29,44.47 78.68,44.08 78.92,44.08 79.08,44.24 79.08,44.48 78.69,44.87 78.69,45.11 78.86,45.27 79.09,45.27 79.49,44.88 79.72,44.88 79.89,45.05 79.89,45.28 79.5,45.68 79.5,45.91 79.66,46.08 79.9,46.08 80.29,45.69 80.53,45.69 80.69,45.85 80.69,46.09 80.3,46.48 80.3,46.72 80.47,46.88 80.7,46.88 81.1,46.49 81.33,46.49 81.5,46.66 81.5,46.89 81.1,47.29 81.1,47.52 87.71,54.13 87.71,57.48 88.99,58.76 89.01,58.76 89.02,58.77 91.88,58.77 92.09,58.56 v1(92.09,58.22)
  BOTTOM w0.076: v1(92.09,58.22) 92.09,58.55 94.16,60.62 94.16,61.43 94.12,61.47 94.12,61.77 94.37,62.23 CPU1.U36
  BOTTOM w0.14: DM1.109 58.89,26.19 58.43,25.73 58.13,25.73 v1(57.98,25.88)
M_A_CKE1: length 75.1
  L6 w0.142: v1(58.01,23.17) 58.45,23.6 58.45,28.2 62.63,32.38 62.63,32.61 62.54,32.7 62.54,32.94 62.71,33.1 62.94,33.1 63.03,33.02 63.27,33.02 63.43,33.18 63.43,33.42 63.35,33.51 63.35,33.74 63.51,33.91 63.75,33.91 63.84,33.82 64.07,33.82 64.39,34.14 64.39,34.79 67.87,38.27 68.91,38.27 70.68,40.04 75.52,40.04 82.31,46.84 82.31,47.07 81.92,47.47 81.92,47.7 82.09,47.87 82.32,47.87 82.71,47.48 82.95,47.48 83.12,47.64 83.12,47.88 82.72,48.27 82.72,48.51 82.89,48.67 83.13,48.67 83.52,48.28 83.75,48.28 83.92,48.45 83.92,48.68 83.53,49.08 83.53,49.31 83.69,49.48 83.93,49.48 84.32,49.08 84.56,49.08 84.73,49.25 84.73,49.49 84.33,49.88 84.33,50.12 84.5,50.28 84.74,50.28 85.13,49.89 85.36,49.89 85.53,50.06 85.53,50.29 85.14,50.69 85.14,50.92 85.3,51.09 85.54,51.09 85.93,50.69 86.17,50.69 86.34,50.86 86.34,51.1 85.94,51.49 85.94,51.73 86.11,51.89 86.34,51.89 86.74,51.5 86.97,51.5 87.14,51.67 87.14,51.9 86.75,52.29 86.75,52.53 86.91,52.7 87.15,52.7 87.54,52.3 87.78,52.3 88.06,52.58 88.06,57.5 89.08,58.52 91.15,58.52 v1(92.09,57.59)
  BOTTOM w0.076: v1(92.09,57.59) 92.54,58.05 92.54,58.77 94.37,60.6 CPU1.U37
  BOTTOM w0.14: DM1.110 59.14,20.57 57.55,22.15 57.55,22.72 58,23.17 v1(58.01,23.17)
M_A_CLK0: length 72.6
  L6 w0.089: v1(94.4,64.96) 94,64.56 94,64.14 94.21,63.93 94.21,62 97.02,59.18 97.02,51.54 96.18,50.7 96.18,42.91 96.18,42.58 85,31.4 73.28,31.4 68.49,26.6 68.49,25.41 69.02,24.87 69.02,23.17 68.29,22.44 66.82,22.44 66.54,22.73 66.54,25.06 66.63,25.15 66.9,25.15 v1(67.18,24.84)
  BOTTOM w0.102: DM1.137 65.89,25.73 66.49,25.12 66.9,25.12 v1(67.18,24.84) ; CPU1.V31 v1(94.4,64.96)
M_A_CLK1: length 72.9
  L6 w0.089: v1(93.47,65.56) 93.09,65.18 93.09,64.62 93.43,64.28 93.43,63.86 92.62,63.05 92.62,59.87 93.03,59.45 94.16,59.45 94.41,59.69 94.41,60.46 94.54,60.59 94.72,60.59 94.85,60.46 94.85,59.69 95.09,59.45 96.03,59.45 96.58,58.9 96.58,51.95 95.6,50.97 95.6,42.83 84.75,31.98 72.99,31.98 67.84,26.83 67.84,25.48 68.42,24.9 68.42,24.15 68.11,23.84 v1(67.82,23.84)
  BOTTOM w0.102: DM1.138 66.13,22.96 66.74,23.56 67.54,23.56 v1(67.82,23.84) ; v1(93.47,65.56) 93.51,65.51 93.7,65.51 CPU1.T31
M_A_CLK#0: length 72.7
  L6 w0.089: v1(94.4,64.31) 94.4,62.08 97.21,59.26 97.21,51.46 96.37,50.62 96.37,42.99 96.37,42.51 85.08,31.21 73.36,31.21 68.68,26.52 68.68,25.49 69.21,24.95 69.21,23.09 68.37,22.25 66.75,22.25 66.35,22.65 66.35,25.14 66.55,25.34 67.12,25.34 67.21,25.43 v1(67.21,25.64)
  BOTTOM w0.102: v1(67.21,25.64) 67.21,25.45 67.11,25.35 66.59,25.35 66.11,25.82 66.11,26.86 66.38,27.14 DM1.139 ; CPU1.V32 v1(94.4,64.31)
M_A_CLK#1: length 72.8
  L6 w0.089: v1(93.49,64.87) 93.49,64.57 93.62,64.44 93.62,63.78 92.81,62.97 92.81,59.95 93.11,59.64 94.08,59.64 94.21,59.77 94.21,60.54 94.46,60.78 94.8,60.78 95.04,60.54 95.04,59.77 95.17,59.64 96.11,59.64 96.77,58.98 96.77,51.87 95.79,50.89 95.79,42.75 84.83,31.79 73.07,31.79 68.03,26.75 68.03,25.56 68.61,24.98 68.61,24.07 68.46,23.92 68.46,23.29 68.16,22.98 v1(67.8,22.98)
  BOTTOM w0.102: v1(93.49,64.87) 93.5,64.87 93.7,64.87 CPU1.T32 ; DM1.140 66.63,20.79 66.36,21.06 66.36,22.86 66.84,23.33 67.7,23.33 67.8,23.23 v1(67.8,22.98)
M_A_CS#0: length 76.1
  L6 w0.142: v1(72.48,23.4) 72.74,23.14 73.29,23.14 73.52,23.37 73.52,25.99 75.21,27.69 88.94,27.69 96.07,34.82 96.31,34.82 96.78,34.34 97.02,34.34 97.18,34.51 97.18,34.74 96.71,35.22 96.71,35.45 96.87,35.62 97.11,35.62 97.59,35.14 97.82,35.14 97.99,35.31 97.99,35.55 97.51,36.02 97.51,36.26 97.68,36.42 97.92,36.42 98.39,35.95 98.63,35.95 98.79,36.11 98.79,36.35 98.32,36.83 98.32,37.06 98.48,37.23 98.72,37.23 99.2,36.75 99.43,36.75 99.6,36.92 99.6,37.16 99.12,37.63 99.12,37.87 99.29,38.03 99.52,38.03 100,37.56 100.24,37.56 100.4,37.72 100.4,37.96 99.93,38.44 99.93,38.67 100.62,39.36 100.62,55.21 101.07,55.67 101.07,59.9 99.86,61.11 v1(99.86,64.4)
  BOTTOM w0.14: v1(72.48,23.4) 72.43,23.4 70.89,24.95 DM1.149 ; CPU1.AE32 99.43,64.64 99.86,64.42 v1(99.86,64.4)
M_A_CS#1: length 76.2
  L6 w0.142: v1(74.59,23.5) 74.1,23.98 74.1,25.75 75.4,27.04 89.66,27.04 93.71,31.09 93.95,31.09 94.69,30.35 94.89,30.35 95.17,30.64 95.17,30.9 94.46,31.61 94.46,31.84 94.63,32.01 94.86,32.01 95.65,31.22 95.86,31.22 96.05,31.42 96.05,31.63 95.27,32.41 95.27,32.65 95.43,32.82 95.67,32.82 96.43,32.06 96.69,32.06 97.01,32.37 97.01,32.61 96.9,32.72 96.9,32.95 97.07,33.12 97.3,33.12 97.41,33.01 97.65,33.01 97.82,33.18 97.82,33.41 97.71,33.52 97.71,33.76 97.87,33.93 98.11,33.93 98.22,33.82 98.45,33.82 98.77,34.13 98.77,34.37 98.66,34.48 98.66,34.71 98.83,34.88 99.06,34.88 99.17,34.77 99.41,34.77 101.56,36.92 101.56,60.11 100.73,60.94 100.73,61.51 100.9,61.68 101.3,61.68 101.47,61.85 101.47,62.08 101.3,62.25 100.9,62.25 100.73,62.41 100.73,64.15 v1(100.75,64.17)
  BOTTOM w0.14: v1(74.59,23.5) 73.02,25.07 73.02,26.9 72.89,27.03 DM1.157 ; v1(100.75,64.17) 100.41,64.34 CPU1.AF32
M_A_DIMA_ODT0: length 77.3
  L6 w0.142: v1(74.54,22.69) 74.07,22.22 74.07,21.42 73.88,21.24 72.79,21.24 72.55,21.48 72.55,22.21 72.69,22.35 73.12,22.35 73.81,23.04 73.81,25.87 75.3,27.36 89.34,27.36 96.1,34.11 96.37,34.11 96.73,33.76 97.07,33.76 99.32,36.01 99.56,36.01 99.67,35.9 99.9,35.9 100.07,36.06 100.07,36.3 99.96,36.41 99.96,36.64 100.13,36.81 100.36,36.81 100.47,36.7 100.71,36.7 100.87,36.87 100.87,37.1 100.76,37.21 100.76,37.45 101.09,37.77 101.09,49.95 101.31,50.17 101.31,50.76 101.04,51.03 101.04,51.32 101.31,51.6 101.31,51.89 101.04,52.17 101.04,52.46 101.31,52.74 101.31,53.03 101.04,53.31 101.04,53.6 101.31,53.88 101.31,60 100.3,61.01 100.3,64.61 v1(99.86,65.05)
  BOTTOM w0.14: DM1.155 72.38,26.94 72.62,26.71 72.62,25.09 74.01,23.7 74.01,23.21 v1(74.54,22.69) ; v1(99.86,65.05) CPU1.AE31
M_A_DIMA_ODT1: length 76.1
  L6 w0.142: v1(74.57,24.87) 75.21,24.87 75.36,25.02 75.36,26.61 75.5,26.75 76.44,26.75 76.64,26.56 76.64,25.09 76.8,24.92 77.04,24.92 77.21,25.09 77.21,26.56 77.4,26.75 81.72,26.75 81.89,26.58 81.89,25.57 82.06,25.4 82.29,25.4 82.46,25.57 82.46,26.58 82.62,26.75 85.39,26.75 85.55,26.58 85.55,25.62 85.72,25.45 85.96,25.45 86.12,25.62 86.12,26.58 86.29,26.75 87.72,26.75 87.88,26.58 87.88,25.57 88.05,25.4 88.28,25.4 88.45,25.57 88.45,26.58 88.62,26.75 90,26.75 93.1,29.85 95.12,29.85 102.03,36.76 102.03,52.76 101.82,52.96 101.82,55.53 101.9,55.6 101.9,63.75 100.83,64.82 100.82,64.82 v1(100.76,64.87)
  BOTTOM w0.14: CPU1.AF31 100.76,65.05 v1(100.76,64.87) ; DM1.161 73.89,25.55 v1(74.57,24.87)
M_A_DQ0: length 84
  L6 w0.089: v1(81.19,67.95) 81.19,67.64 81.05,67.49 78.1,67.49 77.85,67.25 76.69,67.25 70.05,60.61 70.05,56.6 67.27,53.83 64.28,53.83 63.06,52.61 60.98,52.61 59.11,50.73 58.97,50.73 58.51,51.19 58.36,51.19 58.25,51.09 58.25,50.94 58.72,50.48 58.72,50.34 58.61,50.23 58.46,50.23 58,50.69 57.86,50.69 56.64,49.47 56.64,48.63 56.55,48.54 56.4,48.54 56.28,48.66 56.28,49.4 56.18,49.51 55.39,49.51 55.17,49.29 55.17,48.72 52.62,46.17 51.63,46.17 46.91,41.45 46.91,41.09 46.78,40.96 46.78,38.84 44.13,36.19 40.79,36.19 38.76,34.16 38.76,27.18 38.19,26.61 38.19,23.7 37.61,23.12 37.61,21.74 v1(38.04,21.32)
  BOTTOM w0.076: v1(81.19,67.95) 82.17,68.66 83.97,68.66 84.08,68.63 84.29,68.43 84.58,68.38 84.89,68.38 85.1,68.55 85.11,68.55 CPU1.A26
  BOTTOM w0.089: DM1.24 37.64,19.75 37.64,20.92 v1(38.04,21.32)
M_A_DQ1: length 85.8
  L6 w0.089: v1(79.29,67.95) 78.13,67.95 77.74,67.57 76.56,67.57 69.72,60.72 69.72,56.72 67.15,54.16 64.15,54.16 62.94,52.94 60.85,52.94 60.06,52.14 58.86,52.14 56.58,49.87 55.3,49.87 53.72,48.29 53.3,48.29 46.59,41.58 46.59,41.22 46.45,41.08 46.45,38.97 45.21,37.72 43.59,37.72 43,37.13 43,36.84 42.67,36.51 40.35,36.51 37.9,34.06 37.9,31.64 38.24,31.3 38.24,26.98 37.96,26.7 37.96,24.06 v1(36.79,22.89)
  BOTTOM w0.076: v1(79.29,67.95) 80.71,68.99 84.14,68.99 84.21,68.97 84.45,68.73 84.6,68.71 84.78,68.71 84.88,68.79 84.9,68.81 85.04,68.92 85.09,68.97 85.41,68.97 85.43,68.96 85.62,68.91 86.71,68.8 CPU1.D26
  BOTTOM w0.089: DM1.29 38.88,24.99 38.8,24.9 v1(36.79,22.89)
M_A_DQ2: length 85.9
  L6 w0.089: v1(83.1,67.95) 83.71,67.34 84.93,67.34 85.16,67.11 85.16,65.92 84.7,65.46 80.7,65.46 79.51,64.27 79.51,59.1 77.79,57.38 75.98,57.38 75.88,57.28 75.88,56.93 75.78,56.82 75.63,56.82 75.52,56.93 75.52,57.28 75.42,57.38 75.1,57.38 74.84,57.12 74.84,56.52 74.54,56.21 72.82,56.21 72.36,55.76 72.36,54.69 71.54,53.87 71.39,53.87 71.2,54.07 71.05,54.07 70.95,53.96 70.95,53.82 71.14,53.62 71.14,53.47 71.04,53.37 70.89,53.37 70.7,53.56 70.55,53.56 70.44,53.46 70.44,53.31 70.64,53.12 70.64,52.97 66.46,48.79 65.37,48.79 64.59,48.01 61.99,48.01 55.41,41.43 54.41,41.43 49.97,36.99 48.79,36.99 45.18,33.38 42.8,33.38 41.91,32.49 41.91,27.53 42.05,27.39 42.05,23.67 v1(41.11,22.74)
  BOTTOM w0.076: CPU1.D28 87.2,67.91 87.2,68.02 87.04,68.18 86.8,68.18 86.18,68.18 86.08,68.13 85.86,68.13 85.74,68.15 85.48,68.15 85.31,68.08 85.23,68.05 84.47,68.05 84.46,68.06 84.19,68.1 84.12,68.1 83.89,68.33 83.57,68.33 83.55,68.31 83.45,68.31 v1(83.1,67.95)
  BOTTOM w0.089: v1(41.11,22.74) 42.14,21.71 DM1.42
M_A_DQ3: length 84.7
  L6 w0.089: v1(83.88,66.55) 83.88,66.06 83.46,65.64 80.63,65.64 79.31,64.32 79.31,59.15 77.86,57.7 74.62,57.7 74.52,57.59 74.52,56.65 74.42,56.54 74.27,56.54 74.16,56.65 74.16,57.59 74.06,57.7 73.91,57.7 73.81,57.59 73.81,56.65 73.71,56.54 73.56,56.54 73.45,56.65 73.45,57.59 73.35,57.7 73.2,57.7 73.1,57.59 73.1,56.65 72.99,56.54 72.85,56.54 72.74,56.65 72.74,57.59 72.64,57.7 72.17,57.7 72.03,57.56 72.03,55.76 69.72,53.45 69.72,53.3 70.05,52.98 70.05,52.83 69.94,52.73 69.8,52.73 69.47,53.05 69.32,53.05 65.38,49.11 65.24,49.11 64.47,48.34 61.87,48.34 58.01,44.48 57.2,44.48 54.92,42.19 53.78,42.19 51.11,39.53 51.11,38.58 50.05,37.52 48.87,37.52 45.65,34.29 42.96,34.29 41.59,32.93 41.59,27.39 41.83,27.15 41.83,25 41.04,24.21 v1(41.03,24.21)
  BOTTOM w0.076: 84.12,66.63 84.48,66.99 84.74,66.99 85.15,66.83 85.39,66.83 85.42,66.83 85.6,66.89 86.08,67.01 CPU1.C28
  BOTTOM w0.089: v1(41.03,24.21) 41.12,24.21 41.88,24.98 DM1.41 ; v1(83.88,66.55) 84.12,66.63
M_A_DQ4: length 83.2
  L6 w0.089: v1(36.89,25.02) 37.33,25.45 37.33,26.39 37.92,26.99 37.92,31.03 37.59,31.37 37.59,34.19 40.89,37.49 41.37,37.49 42.01,38.13 43.91,38.13 44.24,38.46 44.24,38.92 43.66,39.5 43.66,39.78 43.95,40.07 44.1,40.07 44.4,39.76 44.53,39.76 44.66,39.89 44.66,40.01 44.35,40.32 44.35,40.47 44.45,40.57 44.6,40.57 44.97,40.2 45.12,40.2 45.22,40.3 45.22,40.45 44.85,40.82 44.85,40.97 44.96,41.08 45.1,41.08 45.48,40.7 45.62,40.7 46.27,41.35 46.27,41.71 53.36,48.8 53.78,48.8 55.74,50.75 56.77,50.75 58.48,52.46 59.9,52.46 60.71,53.27 62.81,53.27 64.03,54.49 67.03,54.49 69.31,56.77 69.31,60.77 76.43,67.88 77.53,67.88 78,68.35 80.16,68.35 v1(80.56,67.95)
  BOTTOM w0.076: CPU1.B26 85.49,68.76 85.47,68.78 85.38,68.8 85.15,68.8 85.12,68.78 85.08,68.74 85.07,68.74 85.01,68.69 84.99,68.67 84.83,68.55 84.59,68.55 84.37,68.58 84.13,68.82 84.12,68.82 81.66,68.82 v1(80.56,67.95)
  BOTTOM w0.089: v1(36.89,25.02) 37.21,25.02 37.88,25.69 DM1.25
M_A_DQ5: length 84.1
  L6 w0.089: v1(38.04,22.69) 38.42,23.07 38.42,26.51 39.11,27.2 39.11,34.06 40.93,35.87 44.68,35.87 47.37,38.56 47.37,39.95 47.3,40.02 47.3,40.17 47.1,40.36 47.1,40.51 47.21,40.61 47.36,40.61 47.55,40.42 47.7,40.42 47.92,40.64 47.92,40.84 47.41,41.35 47.41,41.5 47.52,41.61 47.66,41.61 47.97,41.3 48.12,41.3 49.21,42.38 49.21,42.53 48.9,42.84 48.9,42.99 49,43.09 49.15,43.09 49.46,42.78 49.6,42.78 49.83,43 49.83,43.71 51.82,45.7 52.67,45.7 55.19,48.21 57.04,48.21 61.11,52.28 63.19,52.28 64.41,53.5 67.39,53.5 70.38,56.49 70.38,60.49 76.82,66.93 77.95,66.93 78.3,67.29 81.79,67.29 v1(82.46,67.95)
  BOTTOM w0.076: 83.48,68.48 83.49,68.49 83.97,68.49 83.97,68.49 84.2,68.27 84.57,68.22 85.2,68.22 85.48,68.33 85.67,68.33 85.88,68.3 86.05,68.3 CPU1.C26
  BOTTOM w0.089: v1(82.46,67.95) 82.99,68.48 83.48,68.48 ; DM1.28 38.63,20.69 38.87,20.93 38.87,21.86 v1(38.04,22.69)
M_A_DQ6: length 84
  L6 w0.089: v1(82.59,66.63) 82.59,66.01 82.39,65.81 80.56,65.81 79.13,64.39 79.13,59.38 77.77,58.02 73.7,58.02 73.59,58.12 73.59,59.36 73.49,59.46 73.34,59.46 73.24,59.36 73.24,58.12 73.13,58.02 72.82,58.02 72.66,58.17 72.66,60.05 72.43,60.28 71.91,60.28 71.7,60.07 71.7,55.88 65.25,49.43 65.1,49.43 64.37,48.7 61.75,48.7 61.45,48.4 61.3,48.4 60.79,48.92 60.64,48.92 60.54,48.81 60.54,48.66 61.05,48.15 61.05,48 60.95,47.9 60.8,47.9 60.29,48.41 60.14,48.41 60.03,48.31 60.03,48.16 60.55,47.65 60.55,47.5 57.84,44.8 57.07,44.8 54.79,42.51 53.41,42.51 45.51,34.61 42.83,34.61 41.28,33.06 41.28,26.9 41.61,26.56 41.61,26 41.17,25.56 v1(41.07,25.56)
  BOTTOM w0.076: v1(82.59,66.63) 83.01,66.85 83.1,66.94 84.2,66.94 84.41,67.15 84.81,67.15 84.83,67.13 85.07,67.04 85.08,67.03 85.12,67.02 85.19,66.99 85.38,66.99 85.72,67.09 85.82,67.19 CPU1.B28
  BOTTOM w0.089: DM1.37 40.89,27.95 40.89,26.73 40.76,26.6 40.76,25.87 40.88,25.75 v1(41.07,25.56)
M_A_DQ7: length 83.6
  L6 w0.089: v1(81.93,66.66) 81.26,65.99 80.48,65.99 79.65,65.15 78.64,65.15 78.54,65.05 78.54,63.99 78.43,63.88 78.29,63.88 78.18,63.99 78.18,65.05 78.08,65.15 77.93,65.15 77.83,65.05 77.83,63.99 77.72,63.88 77.58,63.88 77.47,63.99 77.47,65.05 77.37,65.15 77.22,65.15 77.12,65.05 77.12,63.99 77.01,63.88 76.86,63.88 76.76,63.99 76.76,65.05 76.66,65.15 76.34,65.15 76.22,65.03 76.22,64 76.13,63.91 75.09,63.91 71.29,60.11 71.29,55.92 65.12,49.75 64.97,49.75 64.61,49.38 60.64,49.38 59.27,48.02 59.27,46.87 58.41,46 57.6,46 55.44,43.84 55.44,43.64 54.86,43.06 53.11,43.06 53.03,43.13 52.67,43.13 52.42,42.88 52.42,42.87 49.85,40.3 49.85,39.39 45.38,34.93 42.69,34.93 40.64,32.88 40.64,24.44 40.6,24.4 40.6,21.82 v1(41.09,21.33)
  BOTTOM w0.076: v1(81.93,66.66) 82.54,67.08 82.57,67.1 84.13,67.1 84.34,67.32 84.88,67.32 84.92,67.27 84.99,67.25 CPU1.A28
  BOTTOM w0.089: v1(41.09,21.33) 41.14,21.29 DM1.38
M_A_DQ8: length 73.6
  L6 w0.089: v1(43.73,23.68) 43.43,23.97 43.43,27.43 42.91,27.96 42.91,29.25 43,29.34 47.06,29.34 48.44,30.72 48.44,32.55 51.86,35.97 52.24,35.97 52.72,36.46 52.72,38.09 55.03,40.4 56.6,40.4 58.19,41.99 58.19,42.79 60.35,44.95 62.87,44.95 65.76,47.84 67.01,47.84 72.62,53.45 75.32,53.45 81.17,59.3 81.17,64.29 81.35,64.47 82.18,64.47 v1(82.63,64.91)
  BOTTOM w0.076: v1(82.63,64.91) 82.63,64.92 83.07,65.36 84.01,65.67 84.06,65.69 84.09,65.69 84.3,65.76 84.96,65.77 85.38,65.78 85.42,65.79 CPU1.B30
  BOTTOM w0.089: v1(43.73,23.68) 44.18,23.22 44.18,20.8 44.14,20.76 DM1.50
M_A_DQ9: length 74.4
  L6 w0.089: v1(83.26,64.91) 82.33,63.99 82.11,63.99 81.35,63.23 81.35,59.03 75.45,53.13 72.75,53.13 67.14,47.52 65.89,47.52 63,44.63 61.37,44.63 60.08,43.34 60,43.34 56,39.35 54.98,39.35 53.08,37.44 53.08,36.36 50.85,34.13 50.5,34.13 48.76,32.38 48.76,30.58 47.06,28.88 45.03,28.88 44.94,28.79 44.94,28.11 44.85,28.02 44.71,28.02 44.58,28.15 44.58,28.79 44.49,28.88 43.59,28.88 43.5,28.79 43.5,27.71 43.7,27.52 43.7,24.39 44.15,23.94 44.15,22.6 v1(43.75,22.2)
  BOTTOM w0.076: v1(83.26,64.91) 83.69,65.34
  BOTTOM w0.089: v1(43.75,22.2) 43.14,21.59 DM1.46 ; 83.69,65.34 84.11,65.52 85.4,65.61 85.52,65.64 86.71,65.78 CPU1.D30
M_A_DQ10: length 74.1
  L6 w0.089: v1(47.38,23.42) 46.92,23.42 46.83,23.51 46.83,26.27 47.5,26.93 47.64,26.93 47.78,26.8 47.92,26.8 48.03,26.9 48.03,27.05 47.9,27.18 47.9,27.33 51.5,30.94 51.5,31.09 51.32,31.27 51.32,31.41 51.43,31.52 51.57,31.52 51.75,31.34 51.9,31.34 52.01,31.44 52.01,31.59 51.82,31.77 51.82,31.92 51.93,32.02 52.08,32.02 52.26,31.84 52.4,31.84 52.63,32.06 52.63,33.35 56.48,37.2 56.63,37.2 57.14,36.69 57.29,36.69 57.39,36.8 57.39,36.94 56.88,37.45 56.88,37.6 56.98,37.71 57.13,37.71 57.64,37.19 57.79,37.19 58.67,38.08 58.67,38.2 58,38.87 58,39 58.13,39.13 58.25,39.13 58.93,38.45 59.05,38.45 59.18,38.58 59.18,38.71 58.49,39.39 58.49,39.57 58.6,39.68 58.77,39.68 59.43,39.02 59.58,39.02 65.63,45.06 65.66,45.06 66.47,45.06 67.38,45.97 67.85,45.97 71.14,49.27 72.81,49.27 72.91,49.37 72.91,49.48 73.01,49.58 73.16,49.58 73.26,49.48 73.26,49.37 73.37,49.27 74.12,49.27 82.8,57.95 82.8,61.07 v1(83.92,62.19)
  BOTTOM w0.076: v1(83.92,62.19) 84.17,62.44 84.17,62.96 85.21,64 85.56,64 CPU1.B33
  BOTTOM w0.089: v1(47.38,23.42) 47.33,23.42 46.38,24.37 DM1.59
M_A_DQ11: length 73.2
  L6 w0.089: v1(47.43,26.14) 47.65,26.14 48.45,26.94 48.45,27.09 48.28,27.26 48.28,27.41 48.38,27.51 48.53,27.51 48.7,27.34 48.84,27.34 48.95,27.44 48.95,27.59 48.78,27.76 48.78,27.91 48.88,28.01 49.03,28.01 49.2,27.84 49.35,27.84 49.45,27.95 49.45,28.09 49.28,28.26 49.28,28.41 49.39,28.52 49.53,28.52 49.7,28.35 49.85,28.35 49.95,28.45 49.95,28.6 49.78,28.77 49.78,28.91 49.89,29.02 50.04,29.02 50.21,28.85 50.35,28.85 50.53,29.02 50.53,29.15 50.41,29.26 50.41,29.37 54.19,33.15 54.19,33.37 54.36,33.54 54.59,33.54 54.88,33.84 54.88,33.99 54.37,34.5 54.37,34.65 54.48,34.75 54.62,34.75 55.14,34.24 55.28,34.24 55.39,34.34 55.39,34.49 54.88,35 54.88,35.15 54.98,35.25 55.13,35.25 55.64,34.74 55.79,34.74 55.89,34.85 55.89,34.99 55.38,35.5 55.38,35.65 55.48,35.76 55.63,35.76 56.14,35.25 56.29,35.25 56.39,35.35 56.39,35.5 55.88,36.01 55.88,36.15 55.99,36.26 56.13,36.26 56.64,35.75 56.79,35.75 65.79,44.75 66.6,44.75 67.45,45.6 68.12,45.6 71.47,48.95 74.26,48.95 83.05,57.75 83.05,60.1 83.55,60.59 83.55,60.74 83.29,61 83.29,61.14 83.39,61.25 83.54,61.25 83.8,60.99 83.94,60.99 84.05,61.1 84.05,61.24 83.82,61.47 83.82,61.62 83.92,61.73 84.07,61.73 84.3,61.49 84.52,61.49 85.29,62.26 85.29,63.17 85.17,63.29 84.66,63.29 84.57,63.2 v1(84.57,62.73)
  BOTTOM w0.076: CPU1.D32 87.01,64.55 86.52,64.44 86.36,64.44 86.22,64.38 86,64.16 85.89,63.99 85.89,63.93 85.74,63.79 85.67,63.68 85.19,63.68 85.18,63.67 84.87,63.36
  BOTTOM w0.089: DM1.63 47.38,26.19 v1(47.43,26.14) ; v1(84.57,62.73) 84.57,63.06 84.87,63.36
M_A_DQ12: length 73.6
  L6 w0.089: v1(81.36,64.91) 80.97,64.53 80.97,59.54 75.19,53.77 72.49,53.77 66.88,48.16 65.63,48.16 62.74,45.27 60.22,45.27 57.87,42.92 57.87,42.12 56.47,40.72 54.84,40.72 49.32,35.2 49.32,33.89 48.69,33.25 48.03,33.25 47.52,32.74 43.06,32.74 42.55,32.23 42.55,27.96 43.21,27.3 43.21,24.86 v1(42.79,24.44)
  BOTTOM w0.076: v1(81.36,64.91) 81.36,64.94 82.29,65.88 83.96,65.88 84.1,66.01 85.28,66.01 CPU1.A30
  BOTTOM w0.089: v1(42.79,24.44) 43.12,24.44 44.16,25.48 44.16,26.7 43.89,26.97 43.89,27.95 DM1.49
M_A_DQ13: length 73.8
  L6 w0.089: v1(42.74,25.81) 42.74,27.02 42.23,27.54 42.23,32.36 42.93,33.06 47.38,33.06 48.08,33.76 48.08,34.65 49.23,35.8 49.23,35.98 48.95,36.26 48.95,36.41 49.05,36.51 49.2,36.51 49.49,36.23 49.66,36.23 54.53,41.1 55.6,41.1 62.2,47.7 64.72,47.7 65.5,48.48 66.75,48.48 72.43,54.16 75.13,54.16 79.98,59 79.98,63.95 v1(80.34,64.31)
  BOTTOM w0.076: v1(80.34,64.31) 80.13,64.52 80.13,65.31 80.95,66.13 83.98,66.13 84.03,66.18 85.02,66.18 85.13,66.29 86.34,66.29 CPU1.C30
  BOTTOM w0.089: v1(42.74,25.81) 43.34,25.81 43.47,25.94 43.47,26.34 43.24,26.58 43.01,26.58 42.89,26.7 42.89,27.95 DM1.45
M_A_DQ14: length 72
  L6 w0.089: v1(45.88,23.35) 45.5,23.35 45.41,23.44 45.41,24.81 45.51,24.92 46.09,24.92 46.2,25.02 46.2,25.17 46.09,25.27 45.51,25.27 45.41,25.38 45.41,25.86 49.68,30.13 49.68,30.88 50.04,31.24 50.25,31.24 51.99,32.99 51.99,33.75 55.08,36.84 55.08,37.11 60.39,42.43 60.46,42.43 60.75,42.73 60.96,42.73 61.6,42.09 61.75,42.09 61.85,42.19 61.85,42.34 61.35,42.84 61.35,42.99 61.46,43.09 61.6,43.09 62.11,42.59 62.25,42.59 62.36,42.69 62.36,42.84 61.84,43.35 61.84,43.48 62.05,43.69 62.22,43.69 62.71,43.21 62.87,43.21 66.27,46.61 67.58,46.61 70.88,49.91 72.3,49.91 74.56,52.17 76.12,52.17 82.26,58.31 82.26,61.14 83.34,62.22 83.34,62.64 83.36,62.66 83.36,63.21 83.65,63.49 v1(83.65,63.68)
  BOTTOM w0.076: v1(83.65,63.68) 83.71,63.75 84.32,63.75 84.84,64.26 85.12,64.4 85.24,64.4 85.29,64.42 85.48,64.48 85.61,64.61 85.85,64.73 CPU1.B32
  BOTTOM w0.089: DM1.62 47.14,22.1 v1(45.88,23.35)
M_A_DQ15: length 71.9
  L6 w0.089: v1(45.85,22.08) 46.44,22.08 46.53,22.17 46.53,26.48 50.69,30.65 50.69,31.24 52.31,32.85 52.31,33.62 55.4,36.71 55.4,36.97 58.64,40.21 58.84,40.21 59.47,39.58 59.69,39.58 66.4,46.29 67.72,46.29 71.01,49.59 72.43,49.59 72.99,50.14 73.2,50.14 73.75,49.59 73.99,49.59 74.22,49.81 74.22,49.96 73.78,50.4 73.78,50.55 73.88,50.65 74.03,50.65 74.47,50.21 74.62,50.21 74.72,50.32 74.72,50.46 74.26,50.93 74.26,51.05 74.38,51.18 74.51,51.18 74.97,50.71 75.12,50.71 75.22,50.82 75.22,50.97 74.69,51.49 74.69,51.62 74.82,51.74 74.95,51.74 75.47,51.22 75.62,51.22 82.57,58.17 82.57,61.19 83.52,62.14 83.52,62.57 83.76,62.81 v1(83.76,62.88)
  BOTTOM w0.076: CPU1.C32 86.08,64.49 85.4,64.28 85.25,64.21 85.19,64.21 85.05,64.14 83.79,62.88 v1(83.76,62.88)
  BOTTOM w0.089: DM1.58 46.14,20.71 46.27,20.85 46.27,21.65 v1(45.85,22.08)
M_A_DQ16: length 74.4
  L6 w0.089: v1(47.43,24.74) 47.92,25.23 47.92,26.06 50.9,29.04 50.9,29.41 65.92,44.43 66.75,44.43 67.58,45.27 69.59,45.27 71.57,47.25 71.57,47.39 71.33,47.63 71.33,47.78 71.44,47.88 71.58,47.88 71.82,47.65 71.97,47.65 72.07,47.75 72.07,47.9 71.84,48.13 71.84,48.28 71.94,48.39 72.09,48.39 72.32,48.15 72.47,48.15 72.94,48.62 74.5,48.62 83.23,57.35 83.23,59.94 85.64,62.36 85.64,69.17 87.7,71.23 89.01,71.23 89.35,70.89 89.76,70.89 v1(90.18,70.48)
  BOTTOM w0.089: v1(90.18,70.48) 90.05,70.6 90.05,70.69 CPU1.J22 ; v1(47.43,24.74) 48.38,25.69 DM1.67
M_A_DQ17: length 76.6
  L6 w0.089: v1(52.73,22.74) 52.31,23.16 52.31,26.08 68.81,42.57 70.06,42.57 70.57,43.09 70.72,43.09 71.14,42.67 71.26,42.67 71.39,42.8 71.39,42.92 70.97,43.34 70.97,43.48 71.07,43.59 71.22,43.59 71.71,43.1 71.82,43.1 71.96,43.24 71.96,43.35 71.47,43.84 71.47,43.99 71.7,44.21 71.85,44.21 72.3,43.76 72.43,43.76 72.55,43.88 72.55,44.01 72.1,44.46 72.1,44.61 74.12,46.63 74.51,46.63 74.62,46.53 74.62,45.56 74.7,45.47 74.88,45.47 74.97,45.56 74.97,46.53 75.08,46.63 76.85,46.63 77.05,46.83 77.05,46.98 76.71,47.31 76.71,47.44 76.84,47.56 76.97,47.56 77.3,47.23 77.45,47.23 79.69,49.47 79.69,50.91 84.96,56.18 84.96,59.85 87.4,62.28 87.4,68.28 87.87,68.75 89.05,68.75 v1(89.41,68.39)
  BOTTOM w0.089: CPU1.H25 89.19,68.6 89.39,68.4 89.39,68.4 89.4,68.39 v1(89.41,68.39) ; DM1.80 51.64,19.75 51.64,21.81 52.56,22.74 v1(52.73,22.74)
M_A_DQ18: length 73.7
  L6 w0.089: v1(49.68,25.5) 50.32,26.15 50.32,26.64 60.85,37.17 60.85,37.44 63.25,39.84 63.25,39.99 62.89,40.35 62.89,40.5 63,40.6 63.14,40.6 63.51,40.24 63.65,40.24 63.76,40.35 63.76,40.49 63.39,40.86 63.39,41 63.5,41.11 63.65,41.11 64.01,40.74 64.15,40.74 64.26,40.85 64.26,41 63.9,41.36 63.9,41.51 64,41.61 64.15,41.61 64.51,41.25 64.66,41.25 64.76,41.35 64.76,41.5 64.4,41.86 64.4,42.01 64.5,42.11 64.65,42.11 65.01,41.75 65.16,41.75 65.27,41.85 65.27,42 64.9,42.36 64.9,42.51 65.01,42.62 65.15,42.62 65.52,42.25 65.66,42.25 65.98,42.57 67.06,42.57 68.44,43.95 69.62,43.95 73.57,47.9 74.84,47.9 83.97,57.03 83.97,60.1 86.35,62.49 86.35,69.38 87.85,70.88 88.48,70.88 v1(88.88,70.48)
  BOTTOM w0.089: CPU1.G22 88.75,70.69 88.75,70.6 v1(88.88,70.48) ; v1(49.68,25.5) 49.21,25.97 49.21,26.94 49.38,27.12 DM1.71
M_A_DQ19: length 73.4
  L6 w0.089: v1(48.6,22.51) 48.15,22.96 48.15,25.27 49.5,26.62 49.85,26.62 54.05,30.82 54.05,32.11 65.02,43.08 67.12,43.08 68.31,44.27 69.45,44.27 73.44,48.26 74.59,48.26 83.74,57.41 83.74,60.2 86.05,62.51 86.05,69.33 87.77,71.05 88.94,71.05 89.52,70.48 v1(89.53,70.48)
  BOTTOM w0.089: v1(89.53,70.48) 89.4,70.6 89.4,70.69 CPU1.H22 ; DM1.66 48.14,22.04 v1(48.6,22.51)
M_A_DQ20: length 76.7
  L6 w0.089: v1(52.75,25.28) 53.03,25 54.43,25 54.52,25.09 54.52,26.23 54.42,26.34 53.39,26.34 53.28,26.44 53.28,26.59 53.39,26.69 54.42,26.69 54.52,26.8 54.52,27.8 68.87,42.15 71.33,42.15 73.05,43.87 73.5,43.87 73.83,43.54 74.2,43.54 74.3,43.64 74.3,43.78 73.69,44.39 73.69,44.54 73.8,44.65 73.94,44.65 74.55,44.03 74.7,44.03 74.81,44.14 74.81,44.29 74.19,44.9 74.19,45.04 74.3,45.15 74.45,45.15 75.06,44.54 75.2,44.54 75.93,45.27 75.93,45.41 75.29,46.06 75.29,46.21 75.39,46.31 75.54,46.31 76.18,45.67 76.33,45.67 80,49.34 80,50.78 82.57,53.34 82.71,53.34 82.9,53.15 83.05,53.15 83.15,53.26 83.15,53.4 82.96,53.59 82.96,53.74 83.07,53.84 83.22,53.84 83.4,53.66 83.55,53.66 83.66,53.76 83.66,53.91 83.47,54.1 83.47,54.24 83.57,54.35 83.72,54.35 83.91,54.16 84.05,54.16 84.16,54.26 84.16,54.41 83.97,54.6 83.97,54.75 84.07,54.85 84.22,54.85 84.41,54.66 84.56,54.66 84.66,54.77 84.66,54.91 84.47,55.1 84.47,55.25 84.58,55.35 84.72,55.35 84.91,55.16 85.06,55.16 85.16,55.27 85.16,55.42 84.98,55.6 84.98,55.75 85.13,55.91 85.13,59.77 87.57,62.2 87.57,67.89 v1(88.03,68.35)
  BOTTOM w0.089: v1(88.03,68.35) 88.03,68.39 87.89,68.53 CPU1.F25 ; v1(52.75,25.28) 52.32,25.7 52.32,26.17 52.38,26.24 DM1.83
M_A_DQ21: length 75
  L6 w0.089: v1(52.73,21.42) 55.82,24.51 55.82,28.08 69.24,41.49 71.57,41.49 72.98,42.9 74.47,42.9 81.03,49.46 81.03,49.61 80.78,49.86 80.78,50.01 80.88,50.11 81.03,50.11 81.28,49.86 81.43,49.86 81.53,49.97 81.53,50.11 81.28,50.36 81.28,50.51 81.38,50.62 81.53,50.62 81.78,50.36 81.93,50.36 82.28,50.71 82.28,50.86 82.03,51.11 82.03,51.26 82.13,51.36 82.28,51.36 82.53,51.11 82.68,51.11 82.78,51.22 82.78,51.36 82.53,51.61 82.53,51.76 82.64,51.87 82.78,51.87 83.03,51.62 83.18,51.62 83.28,51.72 83.28,51.87 83.03,52.12 83.03,52.27 83.14,52.37 83.29,52.37 83.54,52.12 83.68,52.12 83.79,52.22 83.79,52.37 83.54,52.62 83.54,52.77 83.64,52.87 83.79,52.87 84.04,52.62 84.19,52.62 84.29,52.73 84.29,52.87 84.04,53.12 84.04,53.27 84.14,53.38 84.29,53.38 84.54,53.13 84.69,53.13 84.79,53.23 84.79,53.38 84.54,53.63 84.54,53.77 84.65,53.88 84.79,53.88 85.04,53.63 85.19,53.63 85.3,53.73 85.3,53.88 85.05,54.13 85.05,54.28 85.15,54.38 85.3,54.38 85.55,54.13 85.69,54.13 85.82,54.26 85.82,59.41 89.81,63.4 89.81,64.7 90.24,65.13 90.24,68.24 90.13,68.35 90.13,68.35 v1(90.12,68.36)
  BOTTOM w0.089: v1(52.73,21.42) 52.64,21.32 52.64,19.75 DM1.84 ; v1(90.12,68.36) 90.13,68.37 90.13,68.57 CPU1.J25
M_A_DQ22: length 74.4
  L6 w0.089: v1(52.75,24.01) 53.38,23.37 54.38,23.37 54.84,23.84 54.84,24.16 54.74,24.26 53.57,24.26 53.46,24.36 53.46,24.51 53.57,24.62 54.74,24.62 54.84,24.72 54.84,27.55 69.11,41.81 71.44,41.81 72.85,43.22 74.34,43.22 80.41,49.3 80.41,50.09 80.57,50.26 80.57,50.4 80.4,50.58 80.4,50.73 80.5,50.83 80.65,50.83 80.83,50.65 80.97,50.65 81.08,50.76 81.08,50.91 80.9,51.08 80.9,51.23 81.01,51.33 81.15,51.33 81.33,51.16 81.48,51.16 81.58,51.26 81.58,51.41 81.41,51.58 81.41,51.73 81.51,51.84 81.66,51.84 81.83,51.66 81.98,51.66 82.08,51.76 82.08,51.91 81.91,52.09 81.91,52.23 82.01,52.34 82.16,52.34 82.33,52.16 82.48,52.16 82.59,52.27 82.59,52.41 82.41,52.59 82.41,52.74 82.52,52.84 82.66,52.84 82.84,52.67 82.99,52.67 85.49,55.17 85.49,59.87 88.51,62.89 88.51,68.11 v1(88.73,68.33)
  BOTTOM w0.089: DM1.79 51.48,27.86 51.48,25.17 52.65,24.01 v1(52.75,24.01) ; CPU1.G25 88.75,68.65 88.75,68.35 v1(88.73,68.33)
M_A_DQ23: length 73
  L6 w0.089: v1(48.6,23.85) 48.6,24.43 48.84,24.67 50.46,24.67 50.74,24.95 50.74,25.31 50.63,25.42 50.63,26.5 59.78,35.64 59.92,35.64 60.18,35.39 60.33,35.39 60.43,35.49 60.43,35.64 60.17,35.9 60.17,36.04 60.28,36.15 60.43,36.15 60.68,35.89 60.83,35.89 60.93,36 60.93,36.14 60.68,36.4 60.68,36.55 61.24,37.11 61.24,37.26 64.12,40.14 65.08,40.14 68.57,43.63 69.75,43.63 73.7,47.58 74.97,47.58 84.27,56.89 84.27,60.15 86.66,62.54 86.66,69.44 87.7,70.48 v1(88.23,70.48)
  BOTTOM w0.089: DM1.70 49.14,23.32 v1(48.6,23.85) ; v1(88.23,70.48) 88.23,70.56 CPU1.F22
M_A_DQ24: length 87.1
  L6 w0.089: v1(79.02,70.89) 77.45,70.89 77.27,70.7 76.15,70.7 67.1,61.65 67.1,58.7 66.41,58.02 63.47,58.02 62.11,56.66 59.3,56.66 58.02,55.38 54.75,55.38 45.21,45.84 45.04,45.84 40.58,41.39 40.58,41.23 38.37,39.02 38.37,38.07 35.24,34.94 35.24,34.14 34.43,33.32 34.43,31.67 33.84,31.08 33.84,27.41 33.22,26.79 33.22,25.46 33.6,25.08 33.6,24.28 v1(34.1,23.78)
  BOTTOM w0.076: CPU1.D22 86.73,71.31 86.69,71.32 85.62,71.42 85.45,71.47 85.31,71.5 85.08,71.5 84.93,71.35 84.47,71.35 83.99,71.83 83.64,71.83
  BOTTOM w0.089: v1(79.02,70.89) 79.02,71.36 79.5,71.83 83.64,71.83 ; v1(34.1,23.78) 34.05,23.78 33.38,24.45 DM1.7
M_A_DQ25: length 86.1
  L6 w0.089: v1(82.23,70.9) 81.48,71.65 75.76,71.65 61.72,57.61 58.85,57.61 57.58,56.34 54.36,56.34 44.84,46.81 44.65,46.81 39.75,41.91 38.81,41.91 37.69,40.79 37.69,40.52 36.03,38.86 35.6,38.86 35.02,38.28 34.72,38.28 33.65,37.21 33.65,35.72 32.89,34.95 32.89,30.98 32.78,30.87 32.1,30.87 31.99,30.77 31.99,30.62 32.1,30.52 32.78,30.52 32.89,30.41 32.89,29.1 32.78,28.99 32.15,28.99 32.05,28.89 32.05,28.74 32.15,28.64 32.78,28.64 32.89,28.53 32.89,28.39 32.78,28.28 32.15,28.28 32.05,28.18 32.05,28.03 32.15,27.93 32.78,27.93 32.89,27.82 32.89,27.47 32.8,27.38 32.02,27.38 31.88,27.24 v1(31.88,26.44)
  BOTTOM w0.076: v1(82.23,70.9) 82.76,71.23 82.86,71.28 83.71,71.28 83.81,71.25 83.82,71.24 83.86,71.24 84.29,70.81 85.41,70.81 85.56,70.87 85.7,70.87 85.85,70.81 86.05,70.81 CPU1.C22
  BOTTOM w0.089: DM1.3 32.38,27.04 31.88,26.53 v1(31.88,26.44)
M_A_DQ26: length 85.8
  L6 w0.089: v1(82.94,69.53) 82.41,68.99 77.34,68.99 77.27,68.91 76.11,68.91 68.33,61.14 68.33,58.05 67.06,56.78 63.97,56.78 62.62,55.43 59.94,55.43 56.22,51.71 55.33,51.71 54.36,50.73 52.04,50.73 47.01,45.71 47.01,44.29 45.99,43.27 44.5,43.27 43.45,42.23 43.45,41.01 42.29,39.85 40.99,39.85 39.68,38.54 39.68,37.63 36.6,34.56 36.6,30.91 35.98,30.29 35.19,30.29 35.1,30.2 35.1,29.8 35.27,29.62 35.6,29.62 35.73,29.49 35.73,27.64 35.2,27.1 35.2,23.21 v1(35.6,22.81)
  BOTTOM w0.076: v1(82.94,69.53) 83.61,69.16 83.79,69.16 84.55,69.5 84.7,69.5 85.16,69.35 85.42,69.35 85.6,69.4 86.07,69.52 86.09,69.53 CPU1.C24
  BOTTOM w0.089: DM1.20 36.63,21.78 v1(35.6,22.81)
M_A_DQ27: length 85.9
  L6 w0.089: v1(83.64,70.88) 84.13,70.88 84.24,70.78 84.24,68.78 84,68.54 77.72,68.54 77.39,68.2 76.3,68.2 68.98,60.89 68.98,57.8 67.2,56.03 67.2,55.15 66.92,54.87 63.67,54.87 62.4,53.6 59.16,53.6 56.64,51.08 55.6,51.08 54.61,50.09 53.82,50.09 53.01,49.27 51.6,49.27 47.9,45.57 47.9,44.17 46.37,42.63 45.34,42.63 44.09,41.38 44.09,40.66 41.24,37.81 40.75,37.81 37.27,34.33 37.27,31.24 37.61,30.9 37.61,29.81 37.5,29.7 36.85,29.7 36.75,29.6 36.75,29.45 36.85,29.35 37.5,29.35 37.61,29.24 37.61,29.1 37.5,28.99 36.85,28.99 36.75,28.89 36.75,28.74 36.85,28.64 37.5,28.64 37.61,28.53 37.61,28.38 37.5,28.28 37.19,28.28 37.1,28.19 37.1,28.01 37.19,27.93 37.5,27.93 37.61,27.82 37.61,27 v1(36.89,26.29)
  BOTTOM w0.076: v1(83.64,70.88) 83.66,70.88 83.9,70.65 84.6,70.65 85.08,70.64 85.19,70.65 85.44,70.65 85.5,70.67 85.76,70.67 85.83,70.65 86.08,70.65 86.1,70.65 86.74,70.77 86.99,70.77 87.24,70.51 CPU1.D24
  BOTTOM w0.089: v1(36.89,26.29) 36.89,26.67 36.89,26.68 36.89,27.95 DM1.21
M_A_DQ28: length 84.9
  L6 w0.089: v1(32.51,22.84) 32.85,22.84 32.94,22.93 32.94,25.13 32.79,25.28 32.79,26.97 33.2,27.38 33.2,33.72 33.65,34.17 33.8,34.17 34.16,34.52 34.16,35.86 35.9,37.6 35.9,38.28 37.15,39.53 37.98,39.53 39.82,41.38 39.82,41.52 44.78,46.48 44.95,46.48 54.49,56.02 57.72,56.02 59,57.29 61.85,57.29 75.89,71.34 77.27,71.34 77.4,71.47 81.36,71.47 81.57,71.26 v1(81.57,70.9)
  BOTTOM w0.076: CPU1.A22 85.22,70.99 84.36,70.99 84.28,71.07 84.2,71.15 83.91,71.44 83.74,71.44 83.72,71.44 82.82,71.44 82.81,71.44 82.11,71.44 v1(81.57,70.9)
  BOTTOM w0.089: v1(32.51,22.84) 33.52,21.84 33.52,21.21 33.63,21.09 DM1.8
M_A_DQ29: length 85.9
  L6 w0.089: v1(32.51,21.42) 33.16,22.06 33.16,25.22 33.01,25.37 33.01,26.88 33.52,27.4 33.52,32.97 33.83,33.28 33.83,33.43 33.67,33.59 33.67,33.74 33.77,33.84 33.92,33.84 34.08,33.68 34.23,33.68 34.93,34.38 34.93,35.06 34.82,35.17 34.58,35.17 34.49,35.25 34.49,35.43 34.58,35.52 34.82,35.52 34.93,35.63 34.93,36.18 36.24,37.49 36.24,38.15 37.21,39.12 38.03,39.12 40.25,41.35 40.25,41.51 44.91,46.16 45.08,46.16 54.62,55.7 57.89,55.7 59.16,56.97 61.98,56.97 76.02,71.02 77.27,71.02 77.54,71.29 79.9,71.29 v1(80.3,70.89)
  BOTTOM w0.076: 83.51,71.66 83.92,71.66 83.97,71.6 83.97,71.6 84.31,71.27 84.39,71.19 84.41,71.17 85,71.17 85.15,71.32 85.38,71.32 85.41,71.31 85.47,71.3 85.49,71.28 CPU1.B22
  BOTTOM w0.089: v1(32.51,21.42) 32.63,21.3 DM1.4 ; 83.51,71.66 80.79,71.66 80.3,71.16 v1(80.3,70.89)
M_A_DQ30: length 84.7
  L6 w0.089: v1(35.6,21.43) 34.98,21.43 34.82,21.59 34.82,27.46 34.94,27.58 35.27,27.58 35.4,27.71 35.4,29.19 35.3,29.29 34.84,29.29 34.75,29.38 34.75,30.52 34.84,30.61 35.85,30.61 36.29,31.05 36.29,34.69 39.36,37.77 39.36,38.67 40.86,40.17 42.16,40.17 43.14,41.14 43.14,42.36 52.14,51.36 52.87,51.36 54.03,52.52 54.9,52.52 55.11,52.31 56.24,52.31 59.67,55.74 62.49,55.74 63.84,57.1 66.88,57.1 68.02,58.23 68.02,61.27 75.98,69.23 81.17,69.23 v1(81.65,69.71)
  BOTTOM w0.076: CPU1.A24 85.21,69.72 84.61,69.9 83.89,69.93 83.87,69.95 83.29,69.95 82.46,69.96 82.45,69.97 82.12,69.97 82.1,69.96 82.09,69.96 81.72,69.78 v1(81.65,69.71)
  BOTTOM w0.089: v1(35.6,21.43) 35.63,21.39 DM1.16
M_A_DQ31: length 86.2
  L6 w0.089: v1(83.71,69.55) 82.97,68.81 77.64,68.81 77.35,68.52 76.16,68.52 68.65,61 68.65,57.92 67.19,56.46 67.14,56.46 66.87,56.46 66.76,56.36 66.76,56.06 66.66,55.95 66.51,55.95 66.41,56.06 66.41,56.36 66.3,56.46 66.16,56.46 66.05,56.36 66.05,56.06 65.95,55.95 65.8,55.95 65.7,56.06 65.7,56.36 65.59,56.46 65.45,56.46 65.34,56.36 65.34,56.06 65.24,55.95 65.09,55.95 64.99,56.06 64.99,56.36 64.88,56.46 64.11,56.46 62.75,55.11 62.49,55.11 60.08,55.11 56.36,51.39 55.47,51.39 54.49,50.42 52.17,50.42 47.43,45.68 47.43,44.26 46.12,42.95 44.9,42.95 43.77,41.82 43.77,40.79 41.19,38.2 40.7,38.2 36.92,34.43 36.92,30.78 36.39,30.25 36.39,26.48 36.29,26.37 35.73,26.37 35.63,26.27 35.63,26.12 35.73,26.02 36.29,26.02 36.39,25.91 36.39,25.77 36.29,25.66 35.73,25.66 35.63,25.56 35.63,25.41 35.73,25.31 36.29,25.31 36.39,25.2 36.39,24.88 v1(36.89,24.38)
  BOTTOM w0.076: v1(83.71,69.55) 84.54,69.66 84.72,69.66 85.21,69.51 85.4,69.51 CPU1.B24
  BOTTOM w0.089: DM1.17 35.88,26.92 35.95,26.86 35.95,25.33 v1(36.89,24.38)
M_A_DQ32: length 52.9
  L4 w0.089: v1(87.25,59.32) 87.14,59.43 86.24,59.43 84.86,58.04 83.23,58.04 79.65,54.46 79.65,41.28 85.96,34.97 85.96,29 86.05,28.92 86.89,28.92 86.98,28.83 86.98,28.65 86.89,28.56 86.05,28.56 85.96,28.47 85.96,28.29 86.05,28.2 86.89,28.2 86.98,28.12 86.98,27.94 86.89,27.85 86.05,27.85 85.96,27.76 85.96,27.58 86.05,27.49 86.87,27.49 86.98,27.38 86.98,27.23 86.89,27.14 86.05,27.14 85.96,27.05 85.96,26.53 v1(86.83,25.65)
  BOTTOM w0.076: v1(87.25,59.32) 87.71,59.32 89.34,60.95 CPU1.H37
  BOTTOM w0.089: DM1.211 86.36,27.93 86.36,26.12 86.65,25.84 86.65,25.84 v1(86.83,25.65)
M_A_DQ33: length 54.2
  L4 w0.089: v1(87.6,60.2) 87.6,60.29 87.5,60.39 86.61,60.39 84.87,58.65 82.85,58.65 78.94,54.74 78.94,41 85.29,34.65 85.29,24.64 85.57,24.36 85.57,21.67 85.82,21.42 v1(86.63,21.42)
  BOTTOM w0.076: CPU1.H34 89.02,63.27 89.02,61.99 88.91,61.8 88.91,61.04 88.07,60.2 v1(87.6,60.2)
  BOTTOM w0.089: v1(86.63,21.42) 86.64,21.18 DM1.212
M_A_DQ34: length 56.2
  L4 w0.089: v1(91.41,25.65) 90.99,25.65 90.9,25.74 90.9,28.78 90.81,28.87 89.49,28.87 89.4,28.96 89.4,29.14 89.49,29.23 90.61,29.23 90.7,29.32 90.7,29.49 90.61,29.58 89.36,29.58 89.28,29.66 89.28,29.85 89.36,29.94 90.63,29.94 90.72,30.03 90.72,30.39 90.63,30.48 89.43,30.48 89.28,30.63 89.28,31.2 89.1,31.39 88.14,32.34 88.14,35.93 82.02,42.06 82.02,52.18 84.43,54.59 86.89,54.59 87.45,55.16 87.45,58.42 v1(87.34,58.53)
  BOTTOM w0.076: CPU1.K34 89.92,63.59 89.71,63.38 89.71,62.57 89.73,62.53 89.76,62.44 89.76,62.13 89.74,62.05 89.74,61.83 89.76,61.77 89.76,60.86 87.43,58.53 v1(87.34,58.53)
  BOTTOM w0.089: v1(91.41,25.65) 91.18,25.65 90.89,25.95 DM1.229
M_A_DQ35: length 56.3
  L4 w0.089: v1(86.45,54.99) 84.34,54.99 81.7,52.35 81.7,41.93 87.83,35.8 87.83,32.21 88.96,31.07 88.96,28.71 89.1,28.58 90.23,28.58 90.32,28.49 90.32,24.64 90.58,24.38 v1(91.34,24.38)
  BOTTOM w0.076: v1(86.45,54.99) 86.75,54.7 86.98,54.7 88.33,56.04 88.33,57.74 90.86,60.27 90.86,60.28 90.86,60.28 90.86,60.84 90.86,60.84 90.86,61.17 91.08,61.39 91.08,61.77 91.06,61.8 91.06,61.81 90.96,61.99 90.96,62.62 CPU1.K35
  BOTTOM w0.089: v1(91.34,24.38) 90.72,25 90.41,25 90.26,24.85 90.26,23.15 90.64,22.77 DM1.228
M_A_DQ36: length 53.8
  L4 w0.089: v1(87.01,59.95) 86.99,59.97 86.48,59.97 84.85,58.35 83.03,58.35 79.29,54.61 79.29,41.18 85.64,34.83 85.64,25.52 85.73,25.43 86.24,25.43 86.33,25.34 86.33,25.16 86.24,25.07 85.73,25.07 85.64,24.98 85.64,24.67 85.74,24.56 86.2,24.56 86.33,24.44 86.33,23.98 v1(86.61,23.7)
  BOTTOM w0.076: v1(87.01,59.95) 87.18,59.95 87.33,59.79 87.93,59.79 89.14,61 89.14,61.42 89.09,61.47 89.09,61.77 89.34,62.23 CPU1.H36
  BOTTOM w0.089: DM1.216 87.64,20.74 87.5,20.88 87.5,22.81 v1(86.61,23.7)
