# Allegro board 17859-1.0710WZS1337.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM: 122.35,9.02 121.69,9.68 121.69,12.86 122.1,13.27 124.37,13.27 126.41,15.32 126.41,17.73 126.92,18.24 135.45,18.24 136.82,16.87 136.82,15.99 136.57,15.74 135.29,15.74 134.87,15.32 128.82,15.32 128.57,15.06 128.57,10.49 128.44,10.37 127.38,10.37 126.03,9.02 ; 5 cut-outs
GND on BOTTOM: 189.27,48.31 189.02,48.57 189.02,50.68 189.22,50.88 190.39,50.88 190.49,50.78 190.49,49.33 190.7,49.13 192.45,49.13 192.65,48.92 192.65,48.49 192.48,48.31
GND on BOTTOM: 24.17,51.62 24.07,51.72 24.07,55.04 22.45,56.67 22.45,58.04 22.68,58.27 23.01,58.27 24.17,59.44 28.7,59.44 28.98,59.16 28.98,55.45 27.38,53.85 27.38,51.74 27.25,51.62
GND on BOTTOM: 83.99,98.5 83.86,98.63 83.86,100.08 83.71,100.23 83.71,100.59 83.76,100.64 85.08,100.64 85.19,100.54 86.23,100.54 86.86,101.17 86.86,101.73 87.01,101.88 90.88,101.88 91.46,102.47 91.46,103.23 91.59,103.36 92.22,103.36 92.23,103.34 92.36,103.34 92.45,103.25 92.45,101.32 92.02,100.89 91.48,100.89 91.13,100.54 90.62,100.54 90.42,100.33 87.22,100.33 86.84,99.95 84.93,99.95 84.5,99.52 84.5,98.63 84.37,98.5 ; 3 cut-outs
GND on BOTTOM: 153,8.77 152.9,8.87 152.9,10.44 153.49,11.03 153.49,12.96 153.03,13.41 152.37,13.41 152.11,13.67 152.11,16.18 152.37,16.44 152.88,16.44 153.21,16.11 153.21,14.99 154.06,14.14 154.06,12.84 154.38,12.52 154.98,12.52 155.11,12.65 155.11,13.01 155.19,13.08 155.87,13.08 155.95,13.01 155.95,11.99 155.7,11.74 155.7,11.25 155.57,11.13 154.63,11.13 154.38,10.87 154.38,10.44 154.53,10.29 155.65,10.29 155.72,10.21 155.72,9.78 155.52,9.58 154.93,9.58 154.12,8.77 ; 2 cut-outs
GND on BOTTOM: 149.99,83.33 149.78,83.54 149.3,83.54 148.89,83.95 147.87,83.95 147.85,83.98 147.85,84.51 147.72,84.64 146.58,84.64 146.35,84.86 146.35,86.41 146.25,86.52 145.43,86.52 145.41,86.54 145.41,87.12 145.21,87.33 144.09,87.33 143.83,87.07 142.95,87.07 142.84,87.18 142.84,88.57 143.33,89.06 144.16,89.06 144.37,88.85 145.03,88.85 145.43,88.45 146.22,88.45 147.01,87.66 147.01,85.45 147.14,85.32 147.92,85.32 148.74,84.51 149.88,84.51 150.49,83.9 151.4,83.9 151.81,84.31 153.97,84.31 154.1,84.18 154.1,83.52 153.91,83.33 ; 2 cut-outs
GND on BOTTOM: 19.07,91.57 18.97,91.67 18.97,94.36 19.6,95 22.98,95 23.13,94.85 23.13,93.14 23.06,93.07 21.91,93.07 21.81,93.17 21.81,93.32 21.66,93.47 20.21,93.47 19.98,93.25 19.98,91.72 19.83,91.57
GND on BOTTOM: 177.41,90.48 176.7,91.19 176.7,93.65 177.11,94.06 177.11,94.95 178.02,95.86 179.17,95.86 179.42,96.12 180.41,96.12 181.68,94.85 181.68,93.14 179.01,90.48
GND on BOTTOM: 18.33,23.57 18.21,23.7 18.21,24.21 17.7,24.72 16.55,24.72 16.05,25.22 16.05,26.24 16.3,26.49 16.63,26.49 17.09,26.04 18.97,26.04 19.22,25.78 19.22,23.7 19.09,23.57 ; 1 cut-out
GND on BOTTOM: 151.17,72.93 151.1,73 151.1,73.64 150.97,73.76 150.44,73.76 150.34,73.66 149.73,73.66 149.59,73.8 149.59,74.21 150.06,74.68 151.71,74.68 152.29,74.09 152.29,73 152.22,72.93 ; 2 cut-outs
GND on BOTTOM: 54.22,75.75 54.15,75.82 54.15,79.96 54.1,80.01 54.1,83.95 54.58,84.43 55.8,84.43 56.05,84.18 56.05,77.9 55.85,77.7 55.85,76.33 55.26,75.75 ; 6 cut-outs
GND on BOTTOM: 211.98,84.28 211.81,84.46 211.81,86.41 211.91,86.52 213.56,86.52 213.71,86.36 213.71,84.48 213.51,84.28 ; 2 cut-outs
GND on BOTTOM: 23.69,12.91 23.49,13.11 23.49,14.15 23.29,14.35 22.7,14.35 22.63,14.43 22.63,15.37 22.17,15.83 22.17,17.5 22.37,17.71 25.7,17.71 25.71,17.69 26.04,17.69 26.18,17.55 26.18,14.94 26.11,14.86 25.83,14.86 25.57,14.61 25.57,14.25 25.5,14.18 24.76,14.18 24.56,13.97 24.56,12.98 24.48,12.91 ; 11 cut-outs
GND on BOTTOM: 129.71,80.93 129.25,81.38 127.83,81.38 127.12,82.1 126.36,82.1 126.26,82.2 126.26,83.75 126.99,84.48 127.27,84.48 127.38,84.38 127.38,84.2 126.92,83.75 126.92,82.91 127.22,82.6 128.01,82.6 128.14,82.48 128.14,82.12 128.37,81.89 129.43,81.89 129.69,81.64 129.97,81.64 130.07,81.54 130.07,81.03 129.97,80.93
GND on BOTTOM: 101.14,65.1 100.91,65.33 100.91,66.02 101.06,66.17 101.06,67.13 100.88,67.31 100.65,67.31 100.32,67.64 99.38,67.64 99.23,67.8 99.23,69.73 99.64,70.13 100.86,70.13 101.37,69.62 101.95,69.62 102.28,69.29 102.28,68.63 102.18,68.53 101.95,68.53 101.82,68.66 101.57,68.66 101.39,68.48 101.39,67.47 101.52,67.34 101.85,67.34 101.95,67.44 102.25,67.44 102.36,67.34 102.36,67.13 101.95,66.73 101.95,66.12 101.82,65.99 101.59,65.99 101.42,65.81 101.42,65.2 101.31,65.1
GND on BOTTOM: 124.1,95.2 123.95,95.35 123.95,96.62 124.81,97.49 124.81,99.01 122.42,101.4 122.42,102.34 124.07,103.99 124.07,104.73 124.5,105.16 127.6,105.16 128.21,104.55 128.21,100.99 128.54,100.66 133.75,100.66 134.72,101.63 138.96,101.63 139.87,100.71 139.87,99.34 139.62,99.09 134.49,99.09 134.28,99.29 132.43,99.29 132.25,99.11 132.25,98.33 132.15,98.22 128.67,98.22 128.34,97.89 128.34,95.56 128.11,95.33 124.89,95.33 124.86,95.35 124.71,95.2 ; 8 cut-outs
GND on BOTTOM: 62.22,11.1 61.69,11.64 60.65,11.64 60.57,11.71 60.57,12.58 60.67,12.68 64.26,12.68 64.36,12.78 65.78,12.78 65.88,12.68 65.88,11.64 65.35,11.1
GND on BOTTOM: 80.77,12.55 80.46,12.86 80.46,16.23 80.69,16.46 82.54,16.46 82.65,16.36 82.65,12.75 82.44,12.55 ; 1 cut-out
GND on BOTTOM: 202.71,63.55 202.43,63.83 201.85,63.83 201.67,64.01 201.67,64.24 202.46,65.03 202.46,65.86 202.58,65.99 206.01,65.99 206.14,65.86 206.14,65.26 205.3,64.42 204.67,64.42 204.39,64.14 204.39,63.76 204.18,63.55 ; 3 cut-outs
GND on BOTTOM: 180.82,45.88 179.06,47.63 179.06,47.93 180.64,49.51 182.39,49.51 182.52,49.38 182.52,48.54 182.44,48.47 181.86,48.47 181.55,48.16 181.55,46.31 181.12,45.88 ; 2 cut-outs
GND on BOTTOM: 29.33,59.85 28.49,60.68 27.5,60.68 27.25,60.94 27.25,63.1 27.48,63.32 31.64,63.32 32.07,62.89 32.33,62.89 32.53,63.1 32.53,64.26 32.63,64.37 33.24,64.37 33.34,64.26 33.34,62.49 33.29,62.44 32.66,62.44 32.25,62.03 29.28,62.03 29.05,61.8 29.05,61.01 29.51,60.56 32.71,60.56 32.84,60.43 32.84,59.95 32.73,59.85 ; 2 cut-outs
GND on BOTTOM: 85.13,61.45 84.98,61.6 84.98,62.21 85.08,62.31 85.52,62.31 85.72,62.51 86.63,62.51 87.4,63.27 87.4,64.24 87.5,64.34 87.62,64.34 87.83,64.14 88.82,64.14 88.94,64.01 88.94,63.71 88.69,63.45 88.23,63.45 88.01,63.22 88.01,62.79 86.66,61.45
GND on BOTTOM: 22.52,23.83 22.27,24.08 22.27,25.48 22.65,25.86 25.78,25.86 26.08,25.56 26.08,23.95 25.95,23.83 ; 2 cut-outs
GND on BOTTOM: 114.73,104.9 114.6,105.03 114.6,107.22 114.78,107.39 116.07,107.39 116.17,107.29 116.17,106.43 115.49,105.74 115.49,105.01 115.39,104.9
GND on BOTTOM: 97.05,33.48 95.78,34.75 95.78,37.42 96.82,38.46 109.75,38.46 110.48,37.72 110.48,33.81 110.15,33.48
GND on BOTTOM: 155.45,52.38 155.16,52.67 155.16,55.2 155.92,55.96 155.92,56.75 155.2,57.47 155.09,57.36 155.09,56.49 154.98,56.39 154.38,56.39 154.27,56.49 154.27,57.61 154.53,57.86 154.53,63.58 153.89,64.21 153.89,64.93 154.22,65.26 157.27,65.26 157.86,65.84 157.86,67.01 157.68,67.19 156.74,67.19 156.59,67.34 156.59,68.79 156.31,69.07 156.31,70.59 156.51,70.79 157.88,70.79 158.79,69.88 158.79,65.08 157.88,64.16 157.88,59.49 157.87,59.48 157.87,59.38 157.25,58.75 157.25,55.76 157.45,55.55 161.06,55.55 161.59,55.02 161.59,52.94 161.03,52.38 ; 10 cut-outs
GND on BOTTOM: outline of 480 points within 0.51,0.51 224.8,109.49 ; 62 cut-outs
GND on BOTTOM: 104.95,82.07 104.77,82.25 104.77,83.42 104.85,83.49 107.89,83.49 108.05,83.34 108.48,83.34 108.73,83.09 108.93,83.09 109.24,83.39 109.52,83.39 109.75,83.62 110.36,83.62 110.53,83.44 110.53,82.86 110.66,82.73 110.84,82.73 111.6,83.49 112.67,83.49 112.85,83.31 112.85,82.91 113.05,82.71 113.35,82.71 113.41,82.65 113.41,82.25 113.23,82.07
GND on BOTTOM: 176.65,71.63 176.28,72 174.43,72 174.34,72.09 174.16,72.09 171.37,74.88 169.29,74.88 167.66,76.51 167.66,77.14 168.04,77.52 168.04,78.18 167.61,78.62 167.61,78.95 167.96,79.3 168.4,79.3 174.59,73.1 174.77,73.1 174.97,72.9 175.46,72.9 175.69,73.13 176.75,73.13 177.44,72.44 177.44,72.27 176.8,71.63 ; 5 cut-outs
GND on BOTTOM: 149.96,66.3 149.8,66.45 149.8,67.59 149.85,67.64 152.34,67.64 152.44,67.54 152.44,66.35 152.39,66.3
GND on BOTTOM: 26.44,68.94 26.38,68.99 26.38,69.45 26.23,69.6 25.27,69.6 24.68,70.18 24.68,71.1 24.45,71.33 24.45,71.99 24.68,72.21 26.84,72.21 27.2,71.86 27.2,71.66 27.55,71.3 30.37,71.3 30.47,71.2 30.47,70.77 30.02,70.31 30.02,69.4 29.79,69.17 28.29,69.17 27.83,69.62 27.17,69.62 27.12,69.57 27.12,69.04 27.02,68.94 ; 10 cut-outs
GND on BOTTOM: 212.59,63.81 212.41,63.99 212.41,64.57 212.29,64.7 210.43,64.7 210.31,64.82 210.31,65.51 210.38,65.59 213.99,65.59 214.07,65.51 214.07,64.21 213.66,63.81 ; 1 cut-out
GND on BOTTOM: 43.48,55.48 43.15,55.81 43.15,57.46 43.14,57.47 43.14,59.24 42.93,59.44 42.93,59.86 42.67,60.12 41.45,60.12 41.32,60.25 41.32,61.29 41.42,61.39 42.01,61.39 42.29,61.12 43.12,61.12 43.28,60.96 43.28,60.25 43.5,60.02 43.5,59.31 43.66,59.16 44.52,59.16 45.21,58.47 48.2,58.47 48.43,58.24 48.43,57.89 46.68,56.14 46.68,55.55 46.6,55.48
GND on BOTTOM: 52.88,66.12 52.62,66.37 52.62,70.08 52.5,70.21 52.5,72.6 51.73,73.36 51.23,73.36 50.97,73.61 50.97,74.37 51.1,74.5 52.37,74.5 52.5,74.63 53.77,74.63 54.53,73.87 54.53,69.79 55.32,69 55.32,66.91 54.53,66.12 ; 7 cut-outs
GND on BOTTOM: 117.32,68.46 117.22,68.56 117.22,68.91 117.32,69.01 118.61,69.01 118.76,69.17 118.76,69.42 118.92,69.57 118.92,69.85 118.79,69.98 118.79,70.28 119.2,70.69 119.55,70.69 119.63,70.61 119.63,70.49 119.45,70.31 119.45,69.88 119.83,69.5 120.21,69.5 120.57,69.85 120.75,69.85 120.85,69.75 120.85,69.52 120.34,69.01 120.16,69.01 119.6,68.46
GND on L2GND: outline of 232 points within 0.51,0.51 224.8,109.49 ; 52 cut-outs
GND on L3: 55.65,64.24 55.92,63.96 55.92,60.4 55.67,60.15 53.26,60.15 53,60.4 53,62.05 51.99,63.07 51.99,63.96 52.27,64.24
GND on L3: 138.92,64.25 152.6,50.57 152.65,50.57 157.55,45.67 157.73,45.67 161.89,41.51 161.89,41.07 174.14,28.83 174.14,21.82 173.45,21.14 152.29,21.14 151.35,22.08 150.36,22.08 149.45,21.16 98.27,21.16 97.91,20.81 76.17,20.81 74.9,22.08 74.9,26.09 74.57,26.42 74.57,32.9 72.49,34.98 72.49,36.43 68.07,40.85 68.07,45.19 67.51,45.75 67.51,64.87 75.69,73.05 82.34,73.05 83.31,72.09 89.22,72.09 92.78,68.53 122.42,68.53 124.76,66.2 125.55,66.2 126.46,65.28 126.46,63.17 127.12,62.51 133.78,62.51 135.52,64.25 ; 1 cut-out
GND on L3: 124.25,103.69 139.47,103.69 139.69,103.46 139.69,94.08 139.03,93.42 136.09,93.42 135.58,93.93 135.58,95.58 134.79,96.37 134.79,100.87 134.26,101.4 122.55,101.4 122.3,101.65 122.3,102.39 122.96,103.05 123.62,103.05
GND on L3: 55.8,84.48 55.95,84.33 55.95,81.33 55.75,81.13 53.11,81.13 52.75,81.49 52.75,84.28 52.95,84.48
GND on L3: 54.48,74.25 54.58,74.15 54.58,71.02 54.38,70.82 52.37,70.82 52.24,70.94 52.24,72.21 51.99,72.47 51.73,72.47 51.35,72.85 51.35,73.87 51.73,74.25
GND on L3: outline of 332 points within 0.51,0.51 224.8,109.49 ; 2 cut-outs
GND on L4: 124.38,103.84 139.49,103.84 139.87,103.46 139.87,93.93 139.49,93.55 129.33,93.55 127.43,95.46 125.52,95.46 125.01,95.96 125.01,101.04 124.63,101.42 122.47,101.42 122.22,101.68 122.22,102.57 122.85,103.2 123.74,103.2
GND on L4: 53.61,74.25 54.65,74.25 54.78,74.12 54.78,68.79 54.65,68.66 53.26,68.66 52.6,69.32 52.6,73.23
GND on L4: 39.54,10.49 43.99,10.49 44.37,10.11 44.37,9.22 43.35,8.21 43.35,4.78 45.38,2.75 45.38,1.86 45,1.48 39.54,1.48 39.29,1.73 39.29,2.24 38.65,2.87 38.53,2.87 38.53,9.48
GND on L4: 48.43,11.51 52.5,11.51 53.13,10.87 53.13,9.6 50.97,7.44 48.56,7.44 48.18,7.83 48.18,11.25
GND on L4: 196.21,103.41 216.53,103.41 222.47,97.46 222.47,71.78 215.28,64.59 214.45,64.59 213.58,63.73 212.59,63.73 212.29,64.04 212.29,64.24 212.01,64.52 203.19,64.52 201.21,66.5 199.05,66.5 193.44,72.11 193.44,74.53 192.09,75.87 192.09,78.54 190.9,79.73 190.9,80.47 191.84,81.41 191.84,82.98 193.21,84.36 193.21,84.86 191.41,86.67 190.72,86.67 190.47,86.41 188.16,86.41 186.81,87.76 186.81,89.13 185.69,90.25 185.69,90.83 186.86,92 186.86,92.76 189.27,95.18 189.27,96.47
GND on L4: outline of 288 points within 0.51,0.51 224.8,109.49 ; 2 cut-outs
GND on L4, L6: 55.65,64.24 55.92,63.96 55.92,60.4 55.67,60.15 53.26,60.15 53,60.4 53,62.05 51.99,63.07 51.99,63.96 52.27,64.24
GND on L4, L6: 55.8,84.48 55.95,84.33 55.95,81.33 55.75,81.13 53.11,81.13 52.75,81.49 52.75,84.28 52.95,84.48
GND on L5VCC: outline of 152 points within 0.51,0.51 224.8,109.49 ; 4 cut-outs
GND on L6: 54.48,74.25 54.58,74.15 54.58,71.02 54.38,70.82 52.37,70.82 52.24,70.94 52.24,72.21 51.99,72.47 51.73,72.47 51.35,72.85 51.35,73.64 51.96,74.25
GND on L6: outline of 317 points within 0.51,0.51 224.8,109.49
GND on L7GND: outline of 245 points within 0.51,0.51 224.8,109.49 ; 33 cut-outs
0D6V_S0 on TOP: 175.43,19.38 175.3,19.51 175.3,21.72 175.03,22 175.03,23.07 175.13,23.17 176.45,23.17 176.73,22.89 176.73,21.31 176.19,20.78 176.19,19.51 176.07,19.38 ; 2 cut-outs
0D6V_S0 on TOP: 58.21,14.63 57.98,14.86 57.98,17.4 58.39,17.81 71.57,17.81 72.31,18.54 75.46,18.54 75.69,18.32 75.69,17.35 75.33,17 73.07,17 72.18,16.11 64.31,16.11 62.83,14.63
0D6V_S0 on TOP: 98.83,20.75 98.67,20.91 98.67,22.81 98.8,22.94 100.07,22.94 100.35,23.22 100.35,24.06 100.48,24.18 100.93,24.18 101.06,24.06 101.06,20.86 100.96,20.75 ; 5 cut-outs
0D6V_S0 on BOTTOM: 57.88,14.66 57.14,15.4 57.14,17.15 57.19,17.2 58.29,17.2 58.92,16.56 58.92,15.17 58.41,14.66
0D6V_S0 on L4: 98.7,22.38 100.37,22.38 100.65,22.1 100.65,20.2 99.13,18.67 78.38,18.67 78.37,18.66 76.54,18.66 75.33,17.45 74.26,17.45 73.73,17.99 73.73,18.87 75.81,20.96 97.07,20.96 97.1,20.93 97.73,20.93 98.5,21.69 98.5,22.18
0D6V_S0 on L6: 99.49,22.35 101.7,22.35 101.9,22.15 104.64,22.15 106.62,20.17 145.23,20.17 145.99,20.93 173.81,20.93 175.48,22.61 176.04,22.61 176.24,22.41 176.24,21.97 174.24,19.97 146.09,19.97 145.54,19.41 106.22,19.41 104.64,20.98 99.51,20.98 99.28,21.21 99.28,22.15
1D0V_PWR on TOP: 148.74,55.76 148.43,56.06 148.43,60.4 148.58,60.56 153.61,60.56 154.12,60.05 154.12,55.93 153.94,55.76 ; 3 cut-outs
1D0V_PWR on BOTTOM: 153.79,55.45 153.49,55.76 148.74,55.76 148.48,56.01 148.48,57.46 148.36,57.58 148.36,60.38 148.53,60.56 153.61,60.56 154.12,60.05 154.12,55.53 154.05,55.45 ; 6 cut-outs
1D0V_S5 on TOP: 122.88,93.63 121.74,94.77 121.74,95.05 121.84,95.15 124.53,95.15 124.61,95.07 124.61,93.86 124.38,93.63 ; 2 cut-outs
1D0V_S5 on TOP: 148.38,52.45 148.23,52.61 148.23,53.09 148.3,53.16 148.63,53.16 148.89,53.42 148.89,55.53 148.97,55.6 154.1,55.6 154.25,55.76 154.25,59.06 155.8,60.61 157.65,60.61 161.11,64.06 162.25,64.06 163.44,65.26 163.44,66.86 163.46,66.87 163.46,67.05 164.92,68.51 167.25,68.51 169.95,65.81 169.95,63.6 169.87,63.53 168.88,63.53 168.75,63.66 168.75,65.36 166.75,67.36 165.32,67.36 164.64,66.68 164.64,64.26 159.51,59.13 157.04,59.13 156.8,58.89 156.8,57.67 156.84,57.64 156.84,57.03 156.31,57.03 156.05,56.77 156.05,55.91 156,55.86 156,54.33 155.92,54.26 155.52,54.26 153.71,52.45 ; 7 cut-outs
1D0V_S5 on TOP: 119.6,71.43 119.42,71.61 119.42,72.04 119.3,72.16 118.79,72.16 118.23,72.72 118.23,73.05 117.77,73.51 116.45,73.51 115.74,74.22 114.85,74.22 114.75,74.32 114.75,77.75 114.85,77.85 115.49,77.85 117.16,76.18 118.54,76.18 118.61,76.1 121.15,76.1 121.28,76.23 121.28,77.17 121.36,77.24 123.77,77.24 123.87,77.14 123.87,76.61 123.77,76.51 122.65,76.51 122.55,76.41 122.55,75.77 122.35,75.57 120.14,75.57 119.96,75.39 119.96,74.83 120.59,74.2 120.59,72.37 120.75,72.21 121.18,72.21 121.28,72.32 121.28,72.82 121.38,72.93 121.76,72.93 121.91,72.77 121.91,71.55 121.79,71.43 ; 4 cut-outs
1D0V_S5 on BOTTOM: 148.81,53.27 148.51,53.57 148.51,55.45 148.71,55.65 153.33,55.65 153.54,55.45 154.71,55.45 154.93,55.22 154.93,53.47 154.73,53.27 ; 2 cut-outs
1D0V_S5 on BOTTOM: 110.71,101.76 110.31,102.16 110.13,102.16 109.7,102.59 109.7,105.36 110,105.67 110.48,105.67 110.79,105.97 110.79,108.31 111.04,108.56 114.12,108.56 114.22,108.46 114.22,104.19 114.17,104.14 113.79,104.14 113,104.93 112.62,104.93 112.31,104.63 112.31,104.19 112.26,104.14 111.45,104.14 111.35,104.04 111.35,102.85 111.45,102.75 111.58,102.75 111.86,102.47 111.86,101.96 111.65,101.76 ; 5 cut-outs
1D0V_S5 on BOTTOM: 158.69,62.21 158.62,62.28 158.62,64.65 159.13,65.15 159.13,68.71 159.3,68.89 159.96,68.89 160.12,68.74 160.12,65.08 159.86,64.82 159.86,64.06 160.04,63.88 161.11,63.88 161.12,63.87 161.78,63.87 161.87,63.78 161.87,62.36 161.72,62.21
1D0V_S5 on BOTTOM: 118.54,71.12 118.43,71.22 118.43,71.45 118.54,71.55 119.2,71.55 119.35,71.71 119.35,71.91 119.53,72.09 119.53,72.29 119.42,72.39 118.61,72.39 118.49,72.27 118.49,72.19 118.41,72.11 118.31,72.11 118.05,71.86 118.05,71.71 117.57,71.22 117.27,71.22 117.24,71.25 117.24,71.45 117.32,71.53 117.32,71.96 117.27,72.01 117.27,72.24 117.39,72.37 117.85,72.37 118.05,72.57 118.05,72.72 118.26,72.93 118.26,73.13 118.08,73.31 118.08,73.64 118.51,74.07 119.22,74.07 119.35,74.2 119.35,74.45 119.53,74.63 119.53,74.86 119.45,74.93 118.36,74.93 117.19,76.1 117.19,76.58 117.93,77.32 119.45,77.32 119.5,77.27 119.5,77.12 119.4,77.02 119.4,76.56 119.53,76.43 119.53,76.2 119.63,76.1 121.33,76.1 121.51,76.28 121.51,76.56 121.36,76.71 121.36,77.02 121.74,77.4 123.36,77.4 123.44,77.32 123.44,76.94 122.65,76.15 122.65,75.85 122.78,75.72 122.78,75.47 122.55,75.24 122.55,75.01 121.99,74.45 121.99,74.17 122.14,74.02 122.14,72.95 121.99,72.8 121.99,72.44 122.09,72.34 122.09,72.06 121.96,71.94 121.96,71.68 121.84,71.55 121.08,71.55 120.64,71.12
1D0V_S5 on L2GND: 135.99,52.59 127.96,60.62 120.34,60.62 118.73,62.24 118.73,66.96 118.32,67.37 118.32,70.59 117.56,71.35 117.56,75.92 117.95,76.32 120.23,76.32 120.41,76.14 121.84,76.14 121.97,76.27 123.26,76.27 123.41,76.11 127.5,76.11 128.08,75.53 129.94,75.53 130.32,75.15 131.41,75.15 132.02,74.54 132.96,74.54 137.23,70.27 138.7,70.27 144.92,64.05 151.07,64.05 154.85,60.27 154.85,53.65 153.79,52.59
1D0V_S5 on L4: 118.84,91.82 116.05,94.62 114.9,94.62 114.4,95.13 113.46,95.13 112.85,94.52 111.96,94.52 110.92,95.56 110.92,98.25 110.1,99.06 110.1,102.39 110.41,102.69 111.8,102.69 111.93,102.57 111.93,101.76 111.7,101.53 111.7,99.32 113.33,97.69 113.33,97.39 113.57,97.15 114.81,97.15 115.3,96.66 115.63,96.66 119.48,92.81 123.84,92.81 127.63,89.03 134.46,89.03 135.1,89.66 139.77,89.66 140.99,88.45 145.57,88.45 146.82,89.69 146.83,89.69 147.09,89.94 148.28,89.94 148.48,89.74 148.48,88.88 148.38,88.78 147.77,88.78 146.4,87.4 140.23,87.4 139.11,88.52 135.78,88.52 135.15,87.89 127.22,87.89 123.29,91.82
1D0V_S5 on L6: 152.75,84.66 170.28,67.13 170.28,63.38 170.15,63.25 169.31,63.25 169.13,63.43 169.13,63.45 168.78,63.81 168.78,64.19 169.13,64.54 169.13,66.63 151.61,84.15 151.61,87.76 151.56,87.81 147.57,87.81 147.19,88.19 147.19,89.66 147.34,89.82 151.45,89.82 152.75,88.52
1D0V_VCCPRIM_MPHY on TOP: 118.43,77.09 118.54,77.19 119.93,77.19 120.07,77.33 120.07,78.13 120.24,78.3 120.38,78.3 120.57,78.11 120.57,77.47 120.91,77.13 120.91,76.29 120.92,76.28 120.87,76.23 119.96,76.23 119.93,76.25 118.64,76.25 118.43,76.46
1D0V_VCCPRIM_MPHY on BOTTOM: 119.68,76.18 119.6,76.25 119.6,76.51 119.42,76.69 119.42,76.86 120.09,77.52 120.09,77.73 120.19,77.83 120.47,77.83 120.57,77.73 120.57,77.55 120.75,77.37 121.38,77.37 121.43,77.32 121.43,77.14 121.25,76.96 121.25,76.66 121.43,76.48 121.43,76.28 121.33,76.18
1D0V_VCCPRIM_MPHY on L6: 119.36,77.17 121.61,77.17 121.71,77.07 121.71,76.24 121.58,76.11 119.35,76.11 119.19,76.28 119.19,77
1D2V_S3 on TOP: 169.84,39.7 169.49,40.06 169.49,40.59 169.51,40.62 169.51,41.66 167.84,43.34 163.19,43.34 162.73,43.79 162.73,45.34 163.11,45.72 167.91,45.72 171.44,42.19 171.44,40.21 170.94,39.7
1D2V_S3 on TOP: 158.24,52.83 157.91,53.16 157.91,54 158.21,54.31 160.47,54.31 161.56,55.4 161.56,57.15 161.54,57.15 161.54,57.55 161.2,57.89 161.2,59.25 161.5,59.55 161.5,60.75 162.17,61.42 163.72,61.42 164.33,60.81 164.33,59.64 163.86,59.17 163.86,56.68 162.55,55.37 162.55,54.23 161.61,53.29 160.01,53.29 159.56,52.83
1D2V_S3 on TOP: 93.52,45.8 93.39,45.93 93.39,52.48 93.14,52.73 79.57,52.73 75.5,48.66 75.5,48.15 75.47,48.17 63.94,48.17 63.04,49.08 63.04,51.87 64.74,53.57 73.6,53.57 74.7,54.66 77.08,54.66 85.08,62.66 85.08,63.32 85.8,64.04 88.72,64.04 89.53,64.85 89.53,65.59 89.94,65.99 113.07,65.99 113.28,65.79 113.28,62.99 112.57,62.28 110.46,62.28 107.61,59.44 107.61,48.01 105.4,45.8 ; 13 cut-outs
1D2V_S3 on TOP: outline of 94 points within 33.14,16.03 177.69,29.82 ; 100 cut-outs
1D2V_S3 on BOTTOM: 34.46,11.89 33.83,12.52 33.83,18.37 34.08,18.62 37.08,18.62 37.31,18.39 37.31,16.92 37.59,16.64 38.45,16.64 38.53,16.56 38.53,12.14 38.27,11.89 ; 2 cut-outs
1D2V_S3 on BOTTOM: 163.27,60.35 162.9,60.72 162.9,64.23 163.62,64.95 163.62,66.07 164.28,66.73 164.28,67.47 164.33,67.52 164.84,67.52 164.92,67.44 164.92,64.7 165.65,63.96 165.65,62.94 165.55,62.84 164.54,62.84 164.48,62.79 164.48,60.63 164.21,60.35 ; 2 cut-outs
1D2V_S3 on L2GND: 65,48.66 63.08,50.58 63.08,51.92 64.41,53.25 73.48,53.25 74.77,54.55 77.01,54.55 84.96,62.5 100.68,62.5 101.68,61.49 101.68,56.11 100.02,54.45 97.81,54.45 93.87,50.51 76.37,50.51 74.51,48.66
1D2V_S3 on L3: 169.77,40.95 170.78,40.95 178.53,33.2 178.53,25.66 178.15,25.28 177.21,25.28 176.8,25.68 176.8,28.86 175.2,30.46 175.2,34.19 169.44,39.96 169.44,40.62
1D2V_S3 on L3: 157.52,53.88 158.57,53.88 159.99,52.45 159.99,49.86 164.48,45.37 164.48,43.72 164.18,43.41 163.47,43.41 157.19,49.69 157.19,53.55
1D2V_S3 on L4: 67.74,42.55 67.74,38.66 73.63,32.77 73.63,20.48 72.51,19.36 70.66,19.36 69.84,20.17 58.67,20.17 55.65,23.19 55.65,26.62 59,29.97 59,42.14 60.24,43.39 60.24,52.15 60.73,52.63 65.22,52.63 65.54,52.31 65.54,44.74
1D2V_VCCSFR_OC on L3: 128.06,78.44 123.62,78.44 122.85,77.68 122.85,76.66 123.49,76.02 128.06,76.02 128.44,76.41 128.44,78.06
1D8V_PWR on TOP: 81.43,13.52 81.22,13.72 81.22,15.65 81.35,15.78 83.86,15.78 84.14,16.06 84.14,16.82 84.32,17 85.92,17 86.23,16.69 86.23,14.2 85.54,13.52
1D8V_PWR on BOTTOM: 83.15,13.49 83.03,13.62 83.03,16.31 83.15,16.44 85.62,16.44 85.82,16.64 87.5,16.64 87.6,16.54 87.6,14.56 87.47,14.43 84.4,14.43 84.2,14.23 84.2,13.59 84.09,13.49 ; 4 cut-outs
1D8V_S0 on BOTTOM: 18.84,12.86 18.76,12.93 18.76,13.85 18.43,14.18 18.43,14.58 18.64,14.79 19.58,14.79 19.73,14.94 20.39,14.94 20.44,14.89 20.44,13.97 20.09,13.62 19.48,13.62 19.3,13.44 19.3,12.93 19.22,12.86 ; 1 cut-out
1D8V_S0 on BOTTOM: 115.61,34.57 110.79,39.4 76.65,39.4 73.48,42.57 67.43,42.57 66.49,43.51 66.49,44.12 66.67,44.3 74.7,44.3 78.02,40.97 107.74,40.97 108.16,40.55 111.79,40.55 116.71,35.64 149.35,35.64 150.49,36.78 162.5,36.78 166.34,40.62 166.67,40.62 167.15,41.1 167.15,44.1 166.47,44.78 166.47,45.27 165.42,46.31 165.42,48.67 168.14,51.39 170.35,51.39 171.83,52.86 172.43,52.86 174.49,54.92 174.49,59.39 171.9,61.98 171.9,64.54 171.29,65.15 171.29,67.08 171.9,67.69 171.9,67.85 171.62,68.13 171.62,69.95 172.71,71.05 176.02,71.05 177.01,70.06 177.01,69.78 176.88,69.65 176.35,69.65 176.09,69.9 173.96,69.9 173.07,69.01 173.07,66.83 172.64,66.4 172.64,65.18 173.16,64.66 173.16,62.16 175.84,59.48 175.84,54.59 171.22,49.96 168.75,49.96 166.64,47.86 166.64,46.69 167.84,45.49 167.84,45.06 168.24,44.66 168.24,40.16 167.09,39 166.63,39 162.99,35.36 151,35.36 150.21,34.57
1D8V_S0 on BOTTOM: 56.86,56.72 56.66,56.92 56.66,58.12 56.76,58.22 57.96,58.22 58.08,58.09 58.08,56.95 57.86,56.72
1D8V_S0 on BOTTOM: 170.91,95.76 170.68,95.99 170.68,97.31 170.81,97.44 171.67,97.44 171.77,97.34 171.77,96.73 171.57,96.52 171.57,96.09 171.24,95.76
1D8V_S0 on L3: 170.76,96.57 171.22,96.57 173.7,94.08 173.7,89.49 171.55,87.33 171.55,81.69 171.6,81.64 171.6,80.06 171.55,80.01 171.55,79.86 177.57,73.84 177.57,69.67 177.26,69.37 176.52,69.37 176.3,69.6 176.3,73.05 170.45,78.9 170.45,80.7 170.35,80.8 170.35,89.16 172.51,91.32 172.51,93.55 170.38,95.68 170.38,96.19
1D8V_S0 on L4: 57.3,58.3 57.83,58.3 59.56,56.57 62.1,56.57 63.7,54.97 65.68,54.97 66.77,53.88 66.77,47.88 67.61,47.04 67.61,45.04 67.41,44.83 67.41,44.55 67.56,44.4 67.74,44.4 67.89,44.25 67.89,43.69 67.71,43.51 67.02,43.51 65.68,44.86 65.68,52.76 64.76,53.67 63.11,53.67 61.54,55.25 59.07,55.25 57.02,57.31 57.02,58.02
1D8V_S5 on TOP: 124.53,69.9 124.14,70.3 124.14,71.19 124.33,71.38 127.5,71.38 127.68,71.2 128.31,71.2 128.57,71.45 129.2,71.45 129.31,71.35 129.31,70.84 129.2,70.74 128.49,70.74 128.09,70.34 127.43,70.34 126.99,69.9
1D8V_S5 on TOP: 81.35,15.95 81.22,16.08 81.22,17.07 81.45,17.3 83.79,17.3 83.89,17.2 83.89,16.11 83.74,15.95
1D8V_S5 on TOP: 59.73,49.99 59.58,50.14 59.58,50.52 59.28,50.83 59.28,52.15 59.66,52.53 59.66,53.39 58.19,54.87 57.09,54.87 56.26,54.03 55.24,54.03 55.01,54.26 55.01,55.02 56.56,56.57 59.13,56.57 60.67,55.02 61.13,55.02 61.21,54.94 61.21,52.4 60.98,52.17 60.98,51.89 60.7,51.62 60.7,51.41 60.83,51.29 61.34,51.29 61.77,50.85 61.77,50.24 61.51,49.99 ; 4 cut-outs
1D8V_S5 on BOTTOM: 60.93,50.47 59,52.4 58.57,52.4 57.49,53.48 57.49,53.91 57.21,54.19 56.8,54.19 56.46,53.85 55.16,53.85 54.86,54.16 54.86,54.77 55.57,55.48 57.35,55.48 58.03,54.79 58.03,53.88 58.46,53.44 59.61,53.44 59.99,53.06 59.99,52.23 60.98,51.23 61.13,51.23 61.41,50.96 61.41,50.62 61.26,50.47
1D8V_S5 on BOTTOM: 62.38,49.02 60.78,50.62 60.78,51.08 60.93,51.23 62.63,51.23 63.6,50.27 66.01,50.27 66.62,50.88 67.84,50.88 68.02,50.7 68.02,49.63 67.41,49.02
1D8V_S5 on L3: 63.62,46.89 63.62,40.97 64.89,39.7 65.5,39.7 69.92,35.28 69.92,25.73 68.83,24.64 68.83,19.23 69.36,18.7 69.87,18.7 70.48,18.09 80.92,18.09 82.7,16.31 84.45,16.31 84.6,16.46 84.6,17.4 82.14,19.87 74.62,19.87 72.38,22.1 72.38,22.99 71.55,23.83 71.55,36.05 67.46,40.13 67.46,42.78 67.13,43.11 66.72,43.11 65.5,44.33 65.5,47.53 61.74,51.29 60.93,51.29 60.67,51.03 60.67,49.84
1D8V_S5 on L4: 124.71,71 124.71,70.16 124.07,69.52 118.66,69.52 117.85,70.34 116.99,70.34 116.55,70.77 116.55,71.28 116.76,71.48 124.23,71.48
1D8V_S5 on L4: 67.05,50.24 67.66,50.24 67.86,50.45 67.86,63.63 75.48,71.25 83.99,71.25 84.37,70.87 85.77,70.87 86.89,69.75 90.29,69.75 91.1,68.94 94.61,68.94 94.91,69.24 94.91,70.74 94.69,70.97 91.87,70.97 90.09,72.75 75.28,72.75 66.8,64.26 66.8,55.88 66.92,55.76 66.92,50.37
1D8V_VCCPRIM on BOTTOM: 122.88,72.37 122.75,72.49 122.75,73.56 123.36,74.17 123.36,74.42 123.51,74.58 123.51,74.96 123.07,75.4 123.07,75.58 123.18,75.69 123.92,75.69 124.25,75.36 124.25,72.65 123.97,72.37
1D8V_VCCPRIM on L3: 123.16,73.74 124,73.74 124.25,73.48 124.25,73.46 124.28,73.43 129,73.43 131.13,71.3 131.13,70.23 130.88,69.98 130.37,69.98 128.44,71.91 123.29,71.91 122.93,72.27 122.93,73.51
1D8V_VCCPRIM on L6: 123.62,74.63 130.65,74.63 130.78,74.5 130.78,74.02 130.45,73.69 124.53,73.69 123.95,73.1 123.95,72.44 123.69,72.19 123.21,72.19 122.88,72.52 122.88,73.89
1D8V_VGA_PLL on TOP: 181.07,78.08 180.82,78.34 180.82,79.48 180.13,80.17 179.65,80.17 178.33,81.49 178.33,82.96 180.05,84.69 180.46,84.69 180.46,84.69 180.87,84.28 180.87,83.77 180.87,83.77 180.87,83.62 181.22,83.26 181.22,83.09 180.99,82.86 179.95,82.86 179.52,82.43 179.52,82.27 181.02,80.77 181.4,80.77 181.91,81.28 182.09,81.28 182.67,80.7 182.67,80.37 182.21,79.91 182.21,79.12 182.42,78.92 183.48,78.92 183.81,79.25 184.02,79.25 184.3,78.97 184.3,78.74 183.92,78.36 182.21,78.36 181.93,78.08 ; 2 cut-outs
1D24V_VCCDPHY on BOTTOM: 121.2,69.47 121.08,69.6 121.08,70.54 121.15,70.61 122.09,70.61 122.14,70.56 122.14,69.62 121.99,69.47
1D35V_PWR on TOP: 186.81,51.03 186.58,51.26 186.58,55.68 187.19,56.29 187.19,57.1 187.37,57.28 189.66,57.28 189.92,57.01 190.33,57.01 190.48,56.86 190.48,52.42 191,51.89 191,51.36 190.67,51.03 ; 7 cut-outs
1D35V_PWR on BOTTOM: 187.69,51.04 187.19,51.54 187.19,56.29 187.95,57.05 189.33,57.05 189.47,57.19 189.47,57.7 189.58,57.81 189.71,57.81 190.06,57.46 190.29,57.46 190.52,57.23 190.52,51.06 190.51,51.04
1D35V_VGA_S0 on TOP: outline of 112 points within 184.79,52.5 220.24,108.41 ; 34 cut-outs
1D35V_VGA_S0 on BOTTOM: 187.09,88.85 184.55,91.39 184.55,91.9 185.7,93.04 185.82,93.04 186.08,92.79 186.08,92.53 185.57,92.03 185.57,91.65 187.85,89.36 187.85,88.98 187.73,88.85
1D35V_VGA_S0 on BOTTOM: 187.47,79.58 187.35,79.71 187.35,80.22 191.03,83.9 191.03,83.9 191.23,84.1 191.23,84.71 188.49,87.45 188.49,87.96 188.74,88.22 188.87,88.22 189.25,87.84 190.11,87.84 190.77,88.5 190.77,88.72 191,88.95 191.66,88.95 191.92,88.7 191.92,88.47 191.71,88.27 191,88.27 190.77,88.04 190.77,88.04 190.77,87.71 190.78,87.71 190.78,86.57 191.41,85.93 191.41,85.55 191.66,85.3 192.17,85.3 193.06,84.41 193.06,83.77 192.93,83.64 191.79,83.64 189.12,80.98 189.12,79.83 188.87,79.58
1D35V_VGA_S0 on BOTTOM: outline of 86 points within 190.86,51.03 220.37,105.92 ; 58 cut-outs
1D35V_VGA_S0 on L2GND: 190.85,52.49 190.35,52.99 190.35,60.12 191.73,61.49 191.73,62.53 191.84,62.65 193.77,62.65 194.24,62.18 194.24,57.92 193.43,57.1 193.43,54.67 193.15,54.39 193.15,53.73 191.91,52.49
1D35V_VGA_S0 on L3: 209.19,104.85 195.73,104.85 194.46,106.12 190.65,106.12 185.19,100.66 185.19,98.25 187.75,95.69 187.75,93.7 184.93,90.88 184.43,90.88 182.01,93.3 182.01,101.17 189.51,108.66 194.91,108.66 196.95,106.63 201.06,106.63 203.09,108.66 212.37,108.66 218.46,102.57 218.46,102.54 223.36,97.64 223.36,74.32 220.92,71.88 213.33,71.88 213.02,72.19 213.02,72.95 214.62,74.55 214.62,74.86 215.79,76.02 218.66,76.02 219.65,77.02 219.65,80.06 216.3,83.42 216.3,85.91 218.55,88.15 218.55,93.34 217.85,94.03 213,94.03 211.98,95.05 211.98,102.06
1D35V_VGA_S0 on L3: 201.92,65.71 201.92,64.37 201.16,63.6 200.65,63.6 200.63,63.63 200.27,63.63 199.43,64.47 199.43,64.8 199.21,65.03 198.52,65.03 197.96,65.59 197.96,66.2 197.78,66.37 196.51,66.37 194.41,64.26 194.41,61.31 193.79,60.69 192.12,60.69 191.89,60.92 191.89,64.82 193.68,66.61 193.68,67.58 194.71,68.61 199.03,68.61
1D35V_VGA_S0 on L4: 200.5,65.43 200.68,65.26 200.68,64.01 200.58,63.91 200.12,63.91 199.82,64.21 199.82,64.47 199.36,64.93 195.45,64.93 195.22,64.7 195.19,64.7 195.19,62.16 193.75,60.71 192.09,60.71 192.09,60.73 192.04,60.73 191.64,61.14 191.64,64.42 195.29,68.07 197.23,68.07 199,66.3 199.92,66.3 200.5,65.71
1D35V_VGA_S0 on L6: outline of 88 points within 182.01,60.28 223.67,108.41
2D5V_S3 on TOP: 176.04,26.85 175.53,27.36 175.53,27.69 174.54,28.68 173.73,28.68 173.48,28.93 173.48,29.24 173.58,29.34 176.3,29.34 176.37,29.42 177.13,29.42 177.18,29.37 177.18,28.53 177.59,28.12 177.59,26.95 177.49,26.85 ; 3 cut-outs
2D5V_S3 on TOP: 99.82,27.13 99.64,27.31 99.64,27.51 99.41,27.74 97.4,27.74 97.25,27.89 97.25,28.15 97.71,28.6 102.58,28.6 102.84,28.35 102.84,27.79 102.74,27.69 100.37,27.69 100.22,27.54 100.22,27.26 100.1,27.13 ; 5 cut-outs
2D5V_S3 on BOTTOM: 60.01,15.52 59.86,15.67 59.86,17.22 59.99,17.35 61,17.35 61.44,16.92 61.44,15.6 61.36,15.52
2D5V_S3 on BOTTOM: 97.83,26.88 97.71,27 97.71,28.65 97.83,28.78 100.12,28.78 100.25,28.65 100.25,27 100.12,26.88
2D5V_S3 on BOTTOM: 175.2,25.99 174.75,26.44 174.75,28.76 174.82,28.83 175.99,28.83 176.78,28.04 176.78,26.14 176.63,25.99
2D5V_S3 on L6: 60.93,19.56 70.5,19.56 71.93,20.98 89.48,20.98 89.83,21.34 89.83,26.24 93.11,29.52 100.2,29.52 100.43,29.29 100.43,27.23 100.02,26.83 93.64,26.83 93.16,26.34 93.16,20.3 92.17,19.31 76.3,19.31 75.33,18.34 72.64,18.34 71.47,17.17 64.18,17.17 63.34,16.33 61.08,16.33 60.34,17.07 60.34,18.98
2D5V_S3 on L6: 106.55,20.32 99.79,27.08 98.62,27.08 98.47,27.23 98.47,28.53 98.65,28.7 100.35,28.7 108.02,21.03 144.14,21.03 145.18,22.08 145.18,26.98 146.45,28.25 176.63,28.25 176.91,27.97 176.91,26.88 176.42,26.39 175.53,26.39 175.08,26.85 146.81,26.85 146.4,26.44 146.4,21.69 145.03,20.32
3D3V_1D8V_AON_S0 on TOP: 179.04,62.28 176.63,64.7 176.63,66.88 177.44,67.69 178,67.69 178.3,67.39 178.68,67.39 179.75,68.46 179.98,68.46 180.31,68.13 180.31,68.02 178.63,66.35 178.63,64.95 179.11,64.47 179.42,64.47 180.16,65.2 180.33,65.2 180.64,64.9 180.64,64.59 179.67,63.63 179.67,62.36 179.6,62.28 ; 2 cut-outs
3D3V_1D8V_AON_S0 on TOP: 185.24,78.41 184.33,79.31 184.33,79.44 184.64,79.75 184.64,80.2 186.02,81.59 186.86,81.59 187.17,81.28 187.17,81.13 186.28,80.24 186.07,80.24 185.31,79.48 185.31,79.28 185.77,78.82 185.77,78.69 185.49,78.41 ; 3 cut-outs
3D3V_1D8V_AON_S0 on TOP: 188.26,59.13 187.01,60.38 187.01,60.73 187.12,60.84 187.47,60.84 187.7,60.61 189,60.61 189.17,60.43 189.17,59.29 189.02,59.13
3D3V_1D8V_AON_S0 on BOTTOM: 174.42,100.66 174.29,100.79 174.29,101.42 174.57,101.7 174.57,103.2 174.72,103.36 176.37,103.36 176.98,102.75 176.98,101.17 176.85,101.04 175.25,101.04 174.87,100.66 ; 6 cut-outs
3D3V_1D8V_AON_S0 on L3: 195.88,55.96 197.4,55.96 197.91,56.47 197.91,57.48 196.77,58.63 195.5,58.63 195.37,58.5 195.37,56.47
3D3V_1D8V_S0 on TOP: 172.26,97.87 172,98.12 172,101.76 171.75,102.01 171.75,102.39 171.9,102.54 173.04,102.54 173.15,102.44 173.15,98.12 172.89,97.87
3D3V_1D8V_S0 on BOTTOM: 172.36,100.76 171.42,101.7 171.42,102.95 171.6,103.13 172.16,103.13 172.33,102.95 172.99,102.95 173.04,102.9 173.04,100.84 172.97,100.76 ; 1 cut-out
3D3V_1D8V_S0 on BOTTOM: 172.08,97.28 171.62,97.74 170.99,97.74 170.78,97.95 170.78,98.76 170.89,98.86 171.09,98.86 171.57,99.34 172.82,99.34 172.87,99.29 172.87,98.55 173.02,98.4 173.02,98.05 172.59,97.61 172.59,97.34 172.54,97.28 ; 2 cut-outs
3D3V_1D8V_VGA_S0 on TOP: 178.4,71.63 176.09,73.94 176.09,74.26 177.01,75.17 179,75.17 182.06,78.23 183.97,78.23 184.6,77.6 184.6,75.75 182.81,73.95 181.72,73.95 179.39,71.63 ; 3 cut-outs
3D3V_1D8V_VGA_S0 on TOP: 174.54,97.18 174.29,97.44 174.29,98.73 175.48,99.93 175.48,101.55 177.69,103.76 178.86,103.76 179.11,103.51 179.11,103 176.91,100.79 176.91,99.06 175.57,97.73 175.57,97.37 175.38,97.18
3D3V_1D8V_VGA_S0 on BOTTOM: 178.4,102.77 178.23,102.95 178.23,103.53 178.58,103.89 179.85,103.89 179.93,103.81 179.93,102.95 179.75,102.77
3D3V_1D8V_VGA_S0 on BOTTOM: 171.49,94.9 171.29,95.1 171.29,95.63 171.42,95.76 172.1,95.76 172.69,96.34 172.69,97.49 173.73,98.53 173.98,98.53 174.09,98.63 174.09,99.32 174.14,99.37 175.13,99.37 175.23,99.27 175.23,98.3 175.38,98.15 176.96,98.15 177.03,98.07 177.03,96.68 176.98,96.62 175.1,96.62 174.71,97.02 173.49,97.02 173.26,96.79 173.26,95.82 172.33,94.9 ; 7 cut-outs
3D3V_1D8V_VGA_S0 on L4: 184.7,96.98 185.97,96.98 186.1,96.85 186.1,93.8 185.72,93.42 184.96,93.42 184.45,93.93 184.45,96.73
3D3V_1D8V_VGA_S0 on L4: 177.84,104.35 178.61,104.35 178.86,104.6 179.62,104.6 179.75,104.47 179.75,104.09 178.48,102.82 178.1,102.82 177.72,103.2 177.72,104.22
3D3V_CAMERA_S0 on TOP: 50.34,90.86 49.75,91.44 49.75,92.71 50.06,93.02 52.22,93.02 52.39,93.2 52.39,93.68 52.52,93.8 53.08,93.8 53.23,93.65 53.23,91.93 52.98,91.67 51.51,91.67 50.69,90.86 ; 2 cut-outs
3D3V_ECVBAT on TOP: 42.31,33.38 42.18,33.51 42.18,34.57 42.59,34.98 43.76,34.98 44.47,34.27 44.47,33.66 43.12,33.66 42.84,33.38
3D3V_FLASH on BOTTOM: 80.16,93.45 80.05,93.55 80.05,94.04 80.11,94.09 80.39,94.09 80.52,94.22 80.52,94.98 80.64,95.1 82.9,95.1 83.28,94.72 83.28,93.55 83.18,93.45 ; 4 cut-outs
3D3V_LCDVDD_R on BOTTOM: 41.05,79.09 40.74,79.4 39.82,79.4 38.37,80.85 37.89,80.85 37.51,81.23 37.51,82.37 37.26,82.63 37.26,86.11 37.48,86.34 39.9,86.34 40.05,86.18 40.05,82.81 40.63,82.22 40.63,81.92 40.66,81.89 40.66,81.77 42.46,79.96 42.46,79.3 42.25,79.09 ; 2 cut-outs
3D3V_LCDVDD_S0 on BOTTOM: 37.79,86.59 37.61,86.77 37.61,89.87 39.41,91.67 39.41,92.56 39.47,92.61 41.14,92.61 41.19,92.56 41.19,91.7 40.94,91.44 40.94,90.99 40.05,90.1 40.05,86.97 39.67,86.59 ; 8 cut-outs
3D3V_S0 on TOP: 155.26,40.57 155.11,40.72 150.31,40.72 150.08,40.95 150.08,41.56 150.49,41.96 153.56,41.96 154.68,43.08 154.68,45.27 153.49,46.46 147.42,46.46 147.21,46.66 147.21,47.22 147.47,47.48 150.9,47.48 154.02,50.6 154.38,50.6 154.58,50.4 154.58,46.71 155.8,45.49 155.8,42.6 155.82,42.57 155.82,40.69 155.7,40.57 ; 1 cut-out
3D3V_S0 on TOP: 222.04,18.7 221.81,18.93 221.81,22.91 221.86,22.96 223.54,22.96 223.84,22.66 223.84,18.95 223.59,18.7 ; 1 cut-out
3D3V_S0 on TOP: 166.41,104.22 165.02,105.62 165.02,107.39 165.4,107.77 168.45,107.77 168.83,107.39 168.83,106.89 168.57,106.63 168.57,105.74 168.45,105.62 167.56,105.62 167.43,105.49 167.43,104.35 167.3,104.22 ; 6 cut-outs
3D3V_S0 on TOP: 127.38,50.74 127.29,50.83 126.28,50.83 125.75,51.36 125.75,52 125.85,52.1 128.47,52.1 128.65,51.92 128.65,51.04 128.34,50.74 ; 1 cut-out
3D3V_S0 on TOP: 63.88,11.05 63.29,11.64 63.29,12.35 63.52,12.58 73.07,12.58 75.91,15.42 75.91,19.33 76.04,19.46 77.46,19.46 78.1,18.82 78.1,14.07 75.75,11.72 74.95,11.72 74.28,11.05 ; 1 cut-out
3D3V_S0 on TOP: 129.53,71.3 129.46,71.38 129.46,71.88 129.53,71.96 129.79,71.96 129.94,72.11 130.07,72.11 130.3,72.34 132.25,72.34 135.73,75.82 146.93,75.82 150.01,78.9 153.05,78.9 154.17,77.78 154.17,76.71 154.07,76.61 153.69,76.61 153.41,76.89 150.54,76.89 150.4,76.75 150.4,76.6 149.73,75.92 148.86,75.92 148.56,75.62 148.56,75.21 147.7,74.35 143.61,74.35 143.38,74.12 143.38,73.87 143.25,73.74 142.92,73.74 142.79,73.87 142.79,74.17 142.62,74.35 138.47,74.35 138.32,74.2 138.32,73.99 138.14,73.82 137.94,73.82 137.79,73.97 136.77,73.97 134.33,71.53 130.22,71.53 129.99,71.3
3D3V_S0 on TOP: 58.59,42.85 58.49,42.95 58.49,44.02 58.64,44.17 61.54,44.17 61.67,44.05 61.67,43.03 61.49,42.85 ; 1 cut-out
3D3V_S0 on TOP: 178.58,21.16 178.48,21.26 178.48,22.38 178.66,22.56 179.19,22.56 179.7,22.05 179.7,21.49 179.37,21.16 ; 1 cut-out
3D3V_S0 on TOP: 27.58,20.12 27.43,20.27 27.43,22.05 27.68,22.3 28.52,22.3 28.82,22 28.82,21.69 29.56,20.96 29.56,20.32 29.36,20.12 ; 2 cut-outs
3D3V_S0 on TOP: 174.17,5.12 173.6,5.69 173.6,7.72 174.06,8.18 175.15,8.18 175.23,8.11 175.23,5.31 175.04,5.12 ; 2 cut-outs
3D3V_S0 on TOP: 215.51,49.71 215.13,50.09 215.13,50.42 215.01,50.55 214.27,50.55 214.17,50.65 214.17,51.56 214.29,51.69 215.01,51.69 216.1,50.6 216.1,49.94 215.87,49.71
3D3V_S0 on TOP: 50.26,93.63 50.03,93.86 50.03,95.25 50.31,95.53 51.99,95.53 52.24,95.28 52.24,93.8 52.06,93.63
3D3V_S0 on TOP: 36.67,92.89 36.16,93.4 36.16,95.51 34.16,97.51 34.16,98.22 34.28,98.35 35.86,98.35 37.79,96.42 37.79,93.09 37.59,92.89
3D3V_S0 on TOP: 209.98,35.64 209.87,35.74 209.87,36.17 208.63,37.42 208.63,40.31 208.99,40.67 211.02,40.67 211.07,40.62 211.07,37.14 211.3,36.91 211.3,35.89 211.04,35.64 ; 4 cut-outs
3D3V_S0 on TOP: 25.85,36.55 25.72,36.68 25.72,37.04 27.22,38.53 27.73,38.53 27.83,38.43 27.83,37.04 27.71,36.91 26.56,36.91 26.21,36.55 ; 1 cut-out
3D3V_S0 on BOTTOM: 141.93,75.82 141.85,75.9 141.85,77.14 142.06,77.35 142.39,77.35 142.79,77.75 142.79,79.83 142.16,80.47 141.65,80.47 141.52,80.6 141.52,81.99 142.64,81.99 142.89,81.74 145.23,81.74 145.38,81.59 145.38,77.83 144.82,77.27 143.83,77.27 142.39,75.82 ; 2 cut-outs
3D3V_S0 on BOTTOM: 130.4,89 129.89,89.51 127.15,89.51 127.02,89.64 127.02,90.38 126.77,90.63 126.77,90.88 126.84,90.96 127.04,90.96 127.48,90.53 131.31,90.53 131.79,90.05 131.79,89.08 131.72,89
3D3V_S0 on BOTTOM: 216.66,38.08 216.53,38.2 216.53,38.84 216.63,38.94 217.49,38.94 217.52,38.92 218.33,38.92 218.36,38.89 218.36,38.61 218.33,38.59 217.44,38.59 217.42,38.56 217.42,38.43 217.44,38.41 218.33,38.41 218.36,38.38 218.36,38.1 218.33,38.08
3D3V_S0 on BOTTOM: 36.75,92.87 36.54,93.07 36.54,94.54 37.48,95.48 52.34,95.48 52.42,95.41 52.42,93.53 51.94,93.04 40.53,93.04 39.77,93.8 38.27,93.8 38.09,93.63 38.09,93.02 37.94,92.87
3D3V_S0 on L3: 179.88,21.16 179.75,21.03 177.13,21.03 176.88,20.78 176.45,20.78 174.9,19.23 107.49,19.23 104.95,16.69 96.13,16.69 95.9,16.92 95.9,18.21 96.16,18.47 102.61,18.47 102.97,18.11 104.49,18.11 106.67,20.3 173.86,20.3 175.46,21.9 176.27,21.9 176.65,22.28 178.28,22.28 178.84,22.84 179.65,22.84 179.88,22.61
3D3V_S0 on L3: 34.67,10.39 35.58,10.39 36.19,11 51.18,11 51.59,10.58 52.71,10.58 53.08,10.21 53.08,10.01 55.26,7.83 59.35,7.83 61.64,5.54 70.23,5.54 70.35,5.67 70.35,6.51 70.2,6.66 69.62,6.66 69.11,7.17 63.93,7.17 63.34,6.58 62.02,6.58 61.46,7.14 61.46,7.7 59.56,9.6 56.94,9.6 56.41,10.14 54.81,10.14 54.32,10.62 54.32,10.92 53.31,11.94 52.37,11.94 50.51,13.79 40.43,13.79 39.34,12.7 34.79,12.7 34.49,12.4 34.49,10.57
3D3V_S0 on L3: 27.22,56.24 27.86,56.24 28.01,56.09 28.01,55.7 27.15,54.84 27.15,54.16 25.78,52.78 25.78,50.9 27.22,49.46 27.22,47.53 27.38,47.37 27.38,44.68 27.02,44.33 27.02,39.8 27.53,39.3 27.53,37.54 26.33,36.35 25.85,36.35 25.67,36.53 25.67,41.86 25.95,42.14 25.95,43.18 25.27,43.87 25.27,48.08 25.55,48.36 25.55,49.51 24.73,50.32 24.73,53.75
3D3V_S0 on L4: 211.22,40.41 211.45,40.19 211.45,37.44 217,31.89 221.22,31.89 224.25,28.86 224.25,19.48 224.21,19.45 224.21,18.61 224.19,18.58 224.19,14.95 220.97,11.74 217.06,11.74 211.07,5.74 205.91,5.74 201.94,9.72 201.94,11.78 199.59,14.13 197.12,14.13 197.1,14.1 194.58,14.1 187.93,7.44 178.4,7.44 175.86,4.9 174.34,4.9 174.03,5.21 174.03,6.66 176.98,9.6 188.39,9.6 190.24,11.46 190.24,14.15 189.73,14.66 182.67,14.66 180.16,17.17 179.8,17.17 179.22,17.76 177.79,17.76 177.62,17.94 177.62,20.04 178.15,20.58 178.15,21.8 178.73,22.38 180.03,22.38 181.95,20.46 181.95,17.92 182.49,17.38 184.12,17.38 184.55,17.81 190.21,17.81 190.77,18.37 194.43,18.37 195.47,17.33 199.64,17.33 205.99,10.98 205.99,9.38 207.03,8.33 209.04,8.33 219.58,18.87 219.58,22.1 206.78,34.9 206.78,39.91 207.28,40.41
3D3V_S0 on L4: 14.73,54.46 17.93,54.46 18.18,54.21 24.02,54.21 26.21,56.39 27.91,56.39 28.06,56.24 28.06,55.65 27.91,55.5 26.77,55.5 24.58,53.32 22.22,53.32 21.99,53.09 17.82,53.09 17.62,53.29 15.44,53.29 15.23,53.5 14.22,53.5 12.87,54.84 12.87,57.13 13.3,57.56 14.14,57.56 14.65,58.07 14.65,62.36 14.17,62.84 14.17,65.86 13.63,66.4 13.63,67.29 13.74,67.39 14.45,67.39 14.62,67.21 14.62,66.68 15.18,66.12 15.18,57.56 14.19,56.57 13.91,56.57 13.74,56.39 13.74,55.45
3D3V_S0 on L4: 70.38,5.72 70.17,5.51 65.93,5.51 65.91,5.54 64.66,5.54 61.82,8.38 61.82,11.66 62.48,12.32 65.27,12.32 66.62,10.98 69.97,10.98 70.38,10.57
3D3V_S0 on L4: 18.18,66.75 18.82,66.75 19.02,66.55 19.02,63.81 19.5,63.32 19.5,62.89 19.27,62.66 18.82,62.66 18.03,63.45 18.03,66.6
3D3V_S0 on L6: 17.09,88.06 17.57,88.06 18.89,89.39 20.87,89.39 21.15,89.66 21.15,89.94 20.57,90.53 18.89,90.53 17.72,91.7 17.72,94.62 20.45,97.35 23.1,97.35 23.95,96.5 27.76,96.5 28.14,96.88 35.33,96.88 35.71,97.26 35.71,98.17 35.55,98.33 33.45,98.33 32.91,98.86 25.85,98.86 25.52,98.53 25.04,98.53 24.68,98.88 19.96,98.88 16.63,95.56 16.63,88.52
3D3V_S0 on L6: 34.46,10.67 33.75,11.38 31.41,11.38 29,13.79 29,20.27 26.54,22.74 26.54,23.24 24.2,25.58 24.2,30.76 25.65,32.21 25.65,36.99 25.78,37.11 26.36,37.11 26.51,36.96 26.51,31.83 26.49,31.8 26.49,28.53 26.13,28.17 26.13,25.81 27.07,24.87 27.07,24.01 27.6,23.47 27.6,22.96 30.07,20.5 30.07,14.38 31.95,12.5 34.59,12.5 35.71,11.38 35.71,10.85 35.53,10.67
3D3V_S0 on L6: 96.79,17.76 96.21,17.17 89.02,17.17 88.16,16.31 86.23,16.31 85.92,16.61 85.31,16.61 84.96,16.26 76.45,16.26 75.94,16.77 75.94,18.72 76.32,19.1 94.1,19.1 94.99,19.99 97.94,19.99 98.55,19.38 98.55,17.99 98.32,17.76
3D3V_S5 on TOP: 182.49,43.64 181.22,44.91 181.22,45.85 181.65,46.28 181.65,48.06 182.57,48.97 183.43,48.97 183.69,48.72 183.69,48.21 183.76,48.14 183.76,43.84 183.56,43.64 ; 2 cut-outs
3D3V_S5 on TOP: 118.71,47.63 118.46,47.88 118.46,48.26 118.71,48.52 120.42,48.52 120.85,48.95 120.85,49.71 120.9,49.76 122.07,49.76 122.17,49.66 122.17,49.05 121.74,48.62 121.25,48.62 120.26,47.63 ; 1 cut-out
3D3V_S5 on TOP: 37.61,28.91 37.48,29.03 37.48,29.87 37.33,30.03 37.1,30.03 36.89,30.24 36.89,31.44 36.98,31.52 37.41,31.52 37.69,31.24 37.69,30.58 37.84,30.43 38.68,30.43 38.83,30.28 39.03,30.28 39.08,30.23 39.08,29.03 38.96,28.91 ; 1 cut-out
3D3V_S5 on TOP: 53.16,33.3 52.95,33.51 52.95,36.2 52.98,36.22 53.84,36.22 53.97,36.1 53.97,33.51 53.77,33.3
3D3V_S5 on TOP: 214.67,47.7 213.91,48.47 213.91,50.29 214.01,50.4 214.93,50.4 215.01,50.32 215.01,50.04 215.56,49.48 215.56,47.96 215.31,47.7 ; 2 cut-outs
3D3V_S5 on TOP: 207.87,41.46 207.08,42.24 207.08,42.57 206.57,43.08 206.57,44.45 206.72,44.61 208.02,44.61 208.3,44.33 208.3,44.12 208.5,43.92 209.65,43.92 209.9,43.67 209.9,43.41 210.03,43.28 210.41,43.28 211.07,42.62 211.07,42.12 210.99,42.04 210.38,42.04 209.8,41.46 ; 2 cut-outs
3D3V_S5 on BOTTOM: 66.26,12.55 66.11,12.7 66.11,16.16 67,17.05 70.94,17.05 71.5,16.49 71.5,15.55 71.37,15.42 71.04,15.42 70.58,15.88 69.23,15.88 69.11,15.75 69.11,12.65 69.01,12.55
3D3V_S5 on BOTTOM: 169.74,60.71 169.34,61.12 169.34,61.85 169.46,61.98 170.58,61.98 170.89,62.28 170.89,63.63 170.83,63.68 170,63.68 169.92,63.76 169.92,64.32 170.12,64.52 171.32,64.52 171.55,64.29 171.55,62.13 170.96,61.55 170.96,61.19 170.48,60.71
3D3V_S5 on BOTTOM: 43.35,76.91 42.84,77.42 42.84,79.96 43.1,80.22 44.49,80.22 44.75,79.96 44.75,79.2 45,78.95 45.89,78.95 46.02,78.82 46.02,78.18 45.89,78.06 45.38,78.06 45,77.68 45,77.17 44.75,76.91 ; 1 cut-out
3D3V_S5 on BOTTOM: 87.93,12.55 87.83,12.65 87.83,16.67 89.3,18.14 92.17,18.14 92.25,18.06 92.25,17.17 93.31,16.11 93.31,15.75 93.09,15.52 92.7,15.52 92.45,15.78 91.03,15.78 90.82,15.57 90.82,12.65 90.72,12.55 ; 1 cut-out
3D3V_S5 on L2GND: 33.63,80.08 33.28,80.42 33.28,83.52 30.21,86.59 30.21,88.55 27.67,91.09 27.67,95.89 28.01,96.23 34.69,96.23 36.38,94.54 36.38,85.35 35.87,84.84 35.87,81.01 34.94,80.08
3D3V_S5 on L2GND: 198.65,40.5 198.09,41.06 196.99,41.06 196.51,40.58 186.08,40.58 181.31,45.34 181.31,45.8 181.82,46.3 181.82,48.18 182.24,48.61 184.24,48.61 184.51,48.34 184.51,45.36 186.3,43.58 192.61,43.58 194.28,45.25 205.68,45.25 206.54,44.39 207.97,44.39 208.03,44.32 208.03,43.71 208.29,43.46 208.29,42.19 207.31,41.21 205.53,41.21 204.82,40.5
3D3V_S5 on L3: 117.27,12.52 183.05,12.52 183.81,11.76 183.81,5.67 183.18,5.03 171.09,5.03 170.68,4.63 167.35,4.63 166.95,5.03 160.19,5.03 158.79,6.43 154.32,6.43 152.17,4.27 147.11,4.27 146.73,3.89 128.06,3.89 124.38,7.57 123.62,7.57 117.9,1.86 112.57,1.86 111.68,2.75 111.68,6.94
3D3V_S5 on L3: 184.25,48.64 184.73,48.16 184.73,45.54 186.53,43.74 192.42,43.74 194.15,45.47 207.99,45.47 208.73,44.73 208.73,41.94 207.51,40.72 205.66,40.72 205.02,40.08 186.61,40.08 185.85,40.85 185.85,40.9 185.72,41.02 185.03,41.02 181.19,44.87 181.19,45.76 181.65,46.23 181.65,48.08 182.21,48.64
3D3V_S5 on L4: 15.6,30.04 17.82,32.26 23.77,32.26 26.66,29.37 27.98,29.37 29.86,27.49 29.86,23.73 33.73,19.87 33.73,17.91 34.51,17.12 34.51,15.62 34.06,15.17 32.91,15.17 31.06,17.02 31.06,18.29 29.76,19.59 29.76,19.64 26.71,22.68 26.71,23.32 22.28,27.75 17.43,27.75 16.89,27.21 16,27.21 15.6,27.6
3D3V_S5 on L4: 212.13,48.21 212.13,46.18 210.61,44.66 206.93,44.66 206.67,44.4 206.67,42.75 206.93,42.5 207.49,42.5 208.4,41.58 214.6,41.58 215.44,42.42 215.44,47.45 216.58,48.59 216.58,48.97 216.45,49.1 213.02,49.1
3D3V_S5 on L5VCC: 181.91,4.16 181.44,4.63 181.44,6.22 182.93,7.71 185.26,7.71 185.28,7.69 188.54,7.69 190.61,9.75 190.61,12.09 195.91,17.39 204.66,17.39 208.08,13.97 208.08,11.3 210.05,9.34 216.25,9.34 216.78,8.8 219.2,8.8 221.22,10.82 221.22,25.4 221.98,26.16 221.98,29.47 220.56,30.89 220.56,34.44 221.09,34.98 221.09,41.89 219.38,43.6 218.39,43.6 217.65,44.34 211.98,44.34 209.74,42.1 208.1,42.1 207.46,42.74 207.18,42.74 206.76,43.16 206.76,44.78 207.73,45.75 207.73,46.23 209.5,48 212.57,48 213.64,49.06 217.06,49.06 223.83,42.29 223.83,8.08 220.95,5.2 210.66,5.2 209.62,4.16 206.12,4.16 204.96,5.31 204.96,6 201.63,9.33 201.63,12.5 199.84,14.29 196.92,14.29 195.31,12.68 195.31,9.91 189.55,4.16
3D3V_S5 on L5VCC: 14.25,26.94 13.37,27.82 13.37,29.47 13.06,29.77 13.06,40.67 13.42,41.02 13.42,51.77 11.67,53.52 11.67,55.5 12,55.83 12,66.93 11.84,67.09 11.84,73.79 12.02,73.96 12.02,75.52 11.84,75.7 11.84,80.06 13.7,81.92 13.7,83.95 12.78,84.87 12.78,87.25 13.11,87.58 13.11,93.4 17.12,97.4 18.13,97.4 20.29,99.56 28.72,99.56 30.26,98.02 30.26,95.41 29.99,95.14 25.8,95.14 25.63,95.32 24.43,95.32 23.98,94.87 23.98,93.86 23.66,93.54 22.27,93.54 20.17,91.45 20.17,89.82 18.37,88.02 18.37,87.08 17.3,86.01 17.3,82.38 14.48,79.56 14.48,72.49 15.25,71.73 15.25,57.33 14.69,56.77 14.69,54.58 15.05,54.22 16.07,54.22 16.54,53.75 16.54,36.78 17.18,36.14 17.18,35.57 16.75,35.13 16.75,33.99 17.18,33.55 17.18,30.02 17.81,29.39 17.81,27.74 17.25,27.18 17.25,26.94
3D3V_S5 on L6: 42.08,79.33 43.99,79.33 44.24,79.07 44.24,78.31 43.22,77.29 39.54,77.29 38.65,78.18 37.13,78.18 36.75,78.56 36.75,79.83 35.99,80.6 35.35,80.6 34.84,80.09 33.45,80.09 33.19,80.34 33.19,84 33.98,84.79 35.48,84.79 37.89,82.37 37.89,81.87 38.27,81.49 39.16,81.49 40.56,80.09 41.32,80.09
3D3V_S5 on L6: 52.75,6.3 93.85,6.3 94.63,5.51 96.92,5.51 97.4,6 97.4,7.01 99.04,8.65 114.03,8.65 115.11,7.57 115.11,2.75 113.58,1.22 46.4,1.22 45.13,2.49 39.8,2.49 38.4,3.89 38.4,8.08 35.99,10.49 35.99,11.41 34.56,12.83 32.02,12.83 30.55,14.3 30.55,17.27 31.26,17.99 46.91,17.99 48.18,16.72 48.18,12.27 49.45,11 50.72,11 52.5,9.22 52.5,6.56
3D3V_S5_KBC on TOP: 47.85,44.5 47.85,45.09 48.1,45.34 49.37,45.34 49.63,45.09 49.63,44.63 49.5,44.5
3D3V_S5_KBC on TOP: 48.74,38.41 48.64,38.51 48.64,38.94 48.84,39.14 50.11,39.14 50.18,39.22 50.18,40.41 50.26,40.49 51.12,40.49 51.23,40.39 51.23,39.93 51.35,39.8 52.01,39.8 52.17,39.65 52.17,38.64 51.94,38.41 ; 2 cut-outs
3D3V_S5_KBC on TOP: 35.33,28.83 33.57,30.58 33.57,31.93 33.83,32.18 34,32.18 35.33,30.86 35.78,30.86 36.04,31.12 36.04,31.4 36.11,31.47 36.67,31.47 36.75,31.4 36.75,30.18 37.03,29.9 37.03,28.96 36.9,28.83 ; 1 cut-out
3D3V_S5_KBC on TOP: 42.46,52.4 42.26,52.61 42.26,53.72 42.62,54.08 43.73,54.08 44.34,54.69 44.98,54.69 45.31,55.02 45.31,55.43 45.36,55.48 48.36,55.48 48.56,55.27 48.56,54.05 48.2,53.7 48,53.7 47.82,53.88 47.82,54.21 47.8,54.23 45.51,54.23 45.28,54 44.62,54 44.24,53.62 44.24,53.42 44.11,53.29 43.71,53.29 42.82,52.4 ; 1 cut-out
3D3V_S5_KBC on TOP: 28.11,43.64 27.35,44.4 26.84,44.4 26.46,44.78 26.46,46.05 25.83,46.69 25.83,51.51 25.57,51.77 25.57,52.4 25.7,52.53 26.71,52.53 26.97,52.28 26.97,51.95 27.58,51.34 27.58,50.55 27.32,50.29 27.32,49.76 27.48,49.61 28.44,49.61 29.05,50.22 32.25,50.22 32.38,50.09 32.38,49.63 32.35,49.61 29.25,49.61 28.7,49.05 27.2,49.05 26.97,48.82 26.97,47.96 27.43,47.5 27.93,47.5 28.14,47.7 28.49,47.7 28.62,47.58 28.62,47.32 28.49,47.2 28.11,47.2 27.98,47.07 27.98,44.66 28.49,44.15 28.49,43.89 28.24,43.64
3D3V_S5_KBC on TOP: 56.23,43.16 56.03,43.36 56.03,45.52 56.13,45.62 57.14,45.62 57.42,45.34 57.42,44.22 57.63,44.02 58.21,44.02 58.26,43.97 58.26,43.34 58.08,43.16 ; 1 cut-out
3D3V_S5_KBC on TOP: 28.39,51.06 27.5,51.95 27.5,53.62 26.87,54.26 25.98,54.26 25.78,54.46 25.78,56.14 25.9,56.26 26.89,56.26 27.96,55.2 28.57,55.2 28.87,54.89 28.87,51.13 28.8,51.06
3D3V_S5_KBC on TOP: 25.72,29.37 25,30.09 25,34.13 25.93,35.05 27.63,35.05 27.76,34.93 27.76,34.52 27.6,34.37 26.79,34.37 26.54,34.11 26.54,29.54 26.36,29.37
