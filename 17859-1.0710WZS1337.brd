# Allegro board 17859-1.0710WZS1337.brd (continued)
## Nets (continued)
USB1_SSRX_CMC_P1: C7331.2 R7312.1
USB1_SSRX_CMC_P2: C7333.2 R7314.1
USB1_SSRX_CON_N1: ED7301.2 ED7301.9 R7313.2 USB1.B10
USB1_SSRX_CON_N2: ED7302.4 ED7302.7 R7315.2 USB1.A10
USB1_SSRX_CON_P1: ED7301.1 ED7301.10 R7312.2 USB1.B11
USB1_SSRX_CON_P2: ED7302.5 ED7302.6 R7314.2 USB1.A11
USB1_SSTX_C_N1: C7323.1 U7301.34
USB1_SSTX_C_N2: C7322.1 U7301.36
USB1_SSTX_C_P1: C7324.1 U7301.33
USB1_SSTX_C_P2: C7321.1 U7301.37
USB1_SSTX_CMC_N1: C7323.2 R7311.1
USB1_SSTX_CMC_N2: C7322.2 R7317.1
USB1_SSTX_CMC_P1: C7324.2 R7310.1
USB1_SSTX_CMC_P2: C7321.2 R7316.1
USB1_SSTX_CON_N1: ED7301.5 ED7301.6 R7311.2 USB1.A3
USB1_SSTX_CON_N2: ED7302.1 ED7302.10 R7317.2 USB1.B3
USB1_SSTX_CON_P1: ED7301.4 ED7301.7 R7310.2 USB1.A2
USB1_SSTX_CON_P2: ED7302.2 ED7302.9 R7316.2 USB1.B2
USB1_USB20_CON_N: ED3502.1 EL3501.2 USB3.2
USB1_USB20_CON_P: ED3502.6 EL3501.3 USB3.3
USB1_USB20_N: CPU1.CE3 R3608.2 U3601.2
USB1_USB20_P: CPU1.CE4 R3607.2 U3601.3
USB1_USB30_RX_CON_N: ED3501.1 ED3501.10 R3504.2 USB3.5
USB1_USB30_RX_CON_P: ED3501.2 ED3501.9 R3503.2 USB3.6
USB1_USB30_RX_N: CPU1.CB5 R3504.1
USB1_USB30_RX_P: CPU1.CB6 R3503.1
USB1_USB30_TX_CMC_N: C3511.2 R3502.1
USB1_USB30_TX_CMC_P: C3512.2 R3501.1
USB1_USB30_TX_CON_N: ED3501.4 ED3501.7 R3502.2 USB3.8
USB1_USB30_TX_CON_P: ED3501.5 ED3501.6 R3501.2 USB3.9
USB1_USB30_TX_N: C3511.1 CPU1.CA4
USB1_USB30_TX_P: C3512.1 CPU1.CA3
USB2_ID: CPU1.CE8 RN1602.2(A)
USB2_USB20_CON_N: AFTP3505.1 ED3502.3 EL3506.2 USB4.2
USB2_USB20_CON_P: AFTP3506.1 ED3502.4 EL3506.3 USB4.3
USB2_USB20_N: CPU1.CE1 EL3506.1
USB2_USB20_P: CPU1.CE2 EL3506.4
USB2_USB30_RX_CON_N: ED3504.1 ED3504.10 R3522.2 USB4.5
USB2_USB30_RX_CON_P: ED3504.2 ED3504.9 R3521.2 USB4.6
USB2_USB30_RX_N: CPU1.BY8 R3522.1
USB2_USB30_RX_P: CPU1.BY9 R3521.1
USB2_USB30_TX_CMC_N: C3514.2 R3533.1
USB2_USB30_TX_CMC_P: C3520.2 R3524.1
USB2_USB30_TX_CON_N: ED3504.4 ED3504.7 R3533.2 USB4.8
USB2_USB30_TX_CON_P: ED3504.5 ED3504.6 R3524.2 USB4.9
USB2_USB30_TX_N: C3514.1 CPU1.CA2
USB2_USB30_TX_P: C3520.1 CPU1.CA1
USB2_VBUSSENSE: CPU1.CC6 RN1602.1(A)
USB3_USB20_N: CPU1.CG3 IOBD1.21
USB3_USB20_P: CPU1.CG4 IOBD1.20
USB4_USB20_N: CPU1.CD3 U7204.K5
USB4_USB20_P: CPU1.CD4 U7204.L5
USB4_USB30_RX_C_N: C7306.2 U7301.4
USB4_USB30_RX_C_P: C7305.2 U7301.5
USB4_USB30_RX_N: C7306.1 CPU1.BW6
USB4_USB30_RX_P: C7305.1 CPU1.BW5
USB4_USB30_TX_C_N: C7304.2 U7301.7
USB4_USB30_TX_C_P: C7303.2 U7301.8
USB4_USB30_TX_N: C7304.1 CPU1.BW2
USB4_USB30_TX_P: C7303.1 CPU1.BW1
USB_ADT: PD4401.2 PD4408.2 PD4409.A R7401.1 U7418.5 U7418.6 U7418.7 U7418.8 U7419.A1 U7419.B1 U7419.C1 U7419.D1
USB_EN#: R2479.1 U2401.13
USB_OC0#: CPU1.CK6 RN1601.5(B) U7204.B2
USB_OC1#: CPU1.CK5 RN1601.6(B) U3601.13
USB_OC2#: CPU1.CK8 R3512.2 RN1601.8(B)
USB_OC2#_R: R3512.1 U3502.3
USB_OC3#: CPU1.CK9 R3432.2 RN1601.7(B)
USB_OC3#_R: R3432.1 U3403.3
USB_POWERSHARE_VBUS_EN: U2401.71 U3601.5
USB_PWR_EN#: R2434.2 R2479.2 U3403.4 U3502.4
USB_PWR_SHR_EN_L#: R2475.2 R3601.1 U2401.118
USBCOMP: CPU1.CC5 R1603.1
V_SM_VREF_CNTA: C1222.1 CPU1.F36 R1206.2
V_SM_VREF_CNTB: C1323.1 CPU1.E36 R1305.2
VCI_IN1#: R2452.2 U2401.126
VCREF0: C2409.1 R2424.1 R2448.1 U2401.25
VD_IN1_C: C2612.2 C2613.2 R2610.2 R2611.1
VGA_CORE: C8001.1 C8002.1 C8008.1 C8009.1 C8010.1 C8011.1 C8012.1 C8013.1 C8014.1 C8015.1 C8016.1 C8017.1 C8018.1 C8019.1 C8020.1 C8021.1 C8022.1 C8023.1 C8024.1 C8025.1 C8026.1 C8030.1 C8031.1 C8032.1 C8038.1 C8039.1 C8040.1 C8041.1 C8042.1 C8043.1 C8044.1 C8045.1 C8046.1 EC8961.1 EC8965.1 EC8966.1 EC8967.1 EC8968.1 GPU1.K10 GPU1.K12 GPU1.K14 GPU1.K16 GPU1.K18 GPU1.L11 GPU1.L13 GPU1.L15 GPU1.L17 GPU1.M10 GPU1.M12 GPU1.M14 GPU1.M16 GPU1.M18 GPU1.N11 GPU1.N13 GPU1.N15 GPU1.N17 GPU1.P10 GPU1.P12 GPU1.P14 GPU1.P16 GPU1.P18 GPU1.R11 GPU1.R13 GPU1.R15 GPU1.R17 GPU1.T10 GPU1.T12 GPU1.T14 GPU1.T16 GPU1.T18 GPU1.U11 GPU1.U13 GPU1.U15 GPU1.U17 GPU1.V10 GPU1.V12 GPU1.V14 GPU1.V16 GPU1.V18 PL8508.2 PL8509.2 PR8518.1 PT8501.1 PT8502.1 PT8503.1 R8642.1
VGA_CORE_DISCHG: Q8605.D R8642.2
VGA_CORE_PSI: PR8516.1 R7966.2 R7967.2
VGA_CORE_VID: PR8507.1 R7960.2 R7961.2
VGA_CT_1: C8608.1 U8601.12
VGACORE_GND_SENSE_1: GPU1.F1 PR8520.2
VGACORE_VDD_SENSE_1: GPU1.F2 PR8519.2
VID_PLLVDD: GPU1.N6 R7954.2
VID_PLLVDD_L: C7934.1 C7936.1 C7937.1 C7938.1 C7939.1 GPU1.M6 L7902.2 R7954.1
VIDEO_CLK_XTAL_SS: GPU1.A10 R7901.1
VR_CAP: C2418.1 U2401.18
VR_EN: PU4601.40 R4002.2
VR_RDY: PR4609.2 PU4601.39 TP4601.1
VRALERT#: CPU1.CC36 TP1708.1
VRAM_ID2: CPU1.CN23 R2037.1 R2038.2
WHITE_LED_BAT: EC6404.1 Q6404.C R6406.1
WIFI_RF_EN: CPU1.CG25 D6102.K R2107.2 R6114.2
WIFI_RF_EN_R: AFTP6106.1 D6102.A R6114.1 R6142.2 WLAN1.56
WLAN_CLK_CPU_N: CPU1.BC1 WLAN1.49
WLAN_CLK_CPU_P: CPU1.BC2 WLAN1.47
WLAN_CLKREQ_CPU_N: AFTP6105.1 CPU1.CE32 RN1813.8(B) WLAN1.53
WLAN_EN#: Q6102.D R6137.2 R6138.1
WLAN_EN_R#: C6104.2 Q6101.G R6138.2
WLAN_PCIE_RX_N: CPU1.BN6 WLAN1.43
WLAN_PCIE_RX_P: CPU1.BN5 WLAN1.41
WLAN_PCIE_TX_CON_N: C6107.1 WLAN1.37
WLAN_PCIE_TX_CON_P: C6108.1 WLAN1.35
WLAN_PCIE_TX_N: C6107.2 CPU1.BR4
WLAN_PCIE_TX_P: C6108.2 CPU1.BR3
XCLK_BIASREF: CPU1.CJ1 R1803.1
XDP_CLK_CPU_N: CPU1.AU1 TP1808.1
XDP_CLK_CPU_P: CPU1.AU2 TP1807.1
XDP_DBRESET#: CPU1.CN10 EC1706.1 EC6801.1 R1701.2 TP1706.1 TP9955.1
XDP_PRDY#: CPU1.W1 TP306.1
XDP_PREQ#: CPU1.W2 TP305.1
XDP_TCK_JTAGX: CPU1.P6 R315.1 R9996.2
XDP_TCLK: CPU1.T6 R317.1 R9996.1
XDP_TDI: CPU1.U6 R311.1 R9995.1
XDP_TDO_CPU: CPU1.Y5 R310.1 R9994.1
XDP_TMS: CPU1.T5 R309.1 R9992.1
XDP_TRST#: CPU1.AB6 CPU1.Y6 R316.1
XTAL_KBC_2: C2424.2 R2458.2 X2401.2
XTL_24M_X1_CPU: CPU1.CK3 R1839.1
XTL_24M_X1_R: C1807.2 R1839.2 R1841.1 X1801.1
XTL_24M_X2_CPU: CPU1.CK2 R1840.1
XTL_24M_X2_R: C1808.2 R1840.2 R1841.2 X1801.3
XTL_32K_X1_CPU: C1804.1 CPU1.BN31 R1815.1 X1802.1
XTL_32K_X2_CPU: C1803.1 CPU1.BN32 R1815.2 X1802.2
N198396033: Q2510.D R2505.1
N203186882: R4008.2 R4018.2 R4020.2 R4034.2 U4007.2
N203399166: C4011.1 R4040.2 R4043.1 U4004.6 U4004.7 U4004.8
N210032824: R2506.2 RTC1.1

Pads without a net: CPU1 A34 A35 AA24 AA26 AB25 AC6 AC7 AC24 AC25 AC26 AD24 AD26 AG6 AG7 AH26 AJ1 AJ2 AJ3 AJ4 AJ27 AL1 AL2 AL3 AL4 AM3 AM4 AM7 AN1 AN2 AN3 AN4 AR3 AT3 AU3 AY9 B35 BB9 BB24 BC24 BC28 BE1 BE2 BH3 BH4 BJ34 BJ36 BK34 BK35 BK36 BL34 BL36 BL37 BP8 BP9 BP28 BP29 BP34 BP35 BR18 BT8 BT9 BT31 BU29 BV24 BV25 BV30 BY3 BY4 BY6 BY7 BY31 C34 CA32 CB8 CB9 CC29 CC30 CE27 CE31 CF17 CF22 CF27 CF29 CF31 CG1 CG2 CG35 CH5 CH6 CH7 CH8 CH9 CH17 CH25 CH27 CH28 CH30 CH32 CH35 CH36 CJ17 CJ27 CJ29 CJ30 CJ31 CK17 CK23 CK34 CL36 CM10 CM16 CM18 CM19 CM20 CM23 CM27 CM28 CM35 CN8 CN16 CN18 CN19 CN22 CN26 CN28 CN35 CN36 CP3 CP4 CP6 CP16 CP18 CP20 CP28 CR3 CR4 CR14 CR16 CR18 CR20 CR24 CR26 CR28 CR35 D34 D35 D37 F34 F37 G1 G2 G3 G4 H3 H4 J1 J2 J3 K12 K14 K15 K17 K18 K20 L1 L2 L3 L4 L5 L25 M3 M4 M24 M26 N1 N2 N3 N4 N5 P24 P26 R1 R2 R4 R24 R25 R26 T3 T4 T25 U34 U35 V24 V25 V28 V29 W3 W25 Y3 Y24 Y25; DBG1 1 12; DCIN1 5; DM1 87 88 91 92 95 97 100 101 104 105 162 165; DM2 87 88 91 92 95 97 100 101 104 105 162 165; ED1701 2; ED1702 2; ED5703 5 6; GPU1 A16 A22 AA1 AA2 AA3 AA4 AA5 AA6 AB1 AB2 AB3 AB4 AB5 AB6 AB13 AB15 AB16 AB18 AB19 AB21 AB27 AC3 AC4 AC13 AC14 AC15 AC16 AC17 AC18 AC19 AC20 AC21 AD1 AD2 AD3 AD4 AD5 AD7 AD10 AD14 AD17 AD20 AD23 AE1 AE2 AE3 AE4 AE10 AE12 AE13 AE15 AE16 AE18 AE19 AE21 AE23 AE24 AF2 AF3 AF4 AF10 AF12 AF13 AF15 AF16 AF18 AF19 AF21 AF24 AG3 AG12 AG13 AG15 AG16 AG18 AG19 AG21 AG22 AG24 AG25 B3 B6 B19 C2 C3 C7 C14 D4 D5 D10 D11 D12 E6 E10 F4 F5 F7 F10 F19 G1 G2 G3 G4 G5 G6 G7 H3 H4 H6 J1 J2 J3 J4 J5 J6 J7 K1 K2 K3 K4 K5 K6 K7 L3 L4 M1 M2 M3 M4 M5 M7 N1 N2 N3 N4 N5 N7 P3 P4 P6 P25 R1 R2 R3 R4 R5 R6 R7 T1 T2 T3 T4 T5 T6 T7 T27 U3 U4 U6 V1 V2 V3 V4 V5 V6 V7 W1 W2 W3 W4 W5 W6 W7 W22 Y3 Y4 Y6; HDMI1 13 14; IOBD1 13 23 27 31 32 33; KB1 2 3; KB_BL1 3; LCD1 3 23 24 25 39; PU4501 15; PU4701 4 6 27 30 31 35; PU4801 4 6 27 30 31 35; PU4802 4 6 27 30 31 35; PU5101 26; PU8602 12; PU8603 5; RN5502 4 5; RN7203 5; SBD1 9; SSD1 6 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67 68; U2401 70 96; U2502 3; U3601 9; U4001 6 7 8 9 10; U4003 1 2 12 13 14; U7204 F4 G4 L11; U9101 4 5 10 11 12 15 25 26 27 28 31; VRAM1 A5 A10 U5 U10; VRAM4 A5 A10 U5 U10; WLAN1 6 8 12 16 20 38 40 42 44 46 48 58 60 62 66 68 70; X1801 2

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 4929 vias
v2: diameter 0.356, hole 0.178, TOP to BOTTOM, 1323 vias
v3: diameter 0.711, hole 0.406, TOP to BOTTOM, 796 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.8V_RUN_FB:
  vias: v2(84.58,12.98)
1V_1D8V_VGA_S0:
  vias: v1(177.84,86.82) v1(178.48,86.57) v1(179.37,88.65) v1(181.12,90.38) v1(181.63,103.38) v1(181.73,90.17) v1(182.11,103.81) v1(183.43,91.54) v1(183.51,97.36) v1(183.48,96.22) v2(180.69,89.74)
1V_CPU_CORE: length 53.6
  L6 w0.508: v3(66.36,73.97) 63.72,71.33 61.34,71.33 60.4,70.39 60.4,68.18 58.72,66.5 56.94,66.5 56.55,66.89 55.83,66.89 55.24,66.3 52.37,66.3 51.71,65.64 51.71,65.54 51,64.83 51,62.89 50.41,62.31 47.82,62.31 46.96,63.17 44.72,63.17 44.65,63.25 42.54,63.25 42.51,63.27 39.01,63.27 37.41,64.87 30.86,64.87 v1(29.23,66.5)
  BOTTOM w0.254: CPU1.BF2 112.49,84.34 v1(112.37,84.46) ; v1(109.94,84.67) 110.05,84.56 CPU1.BB2 ; CPU1.AV2 v1(107.61,84.61) ; CPU1.AP2 105.17,85.29 105.51,85.63 v1(105.72,85.63)
  BOTTOM w0.508: v1(29.23,66.5) 29.23,65.61 30.35,64.49 PR4631.2
  vias: v1(101.52,78.26) v1(104.42,67.59) v1(105.33,67.59) v1(106.22,81.78) v1(106.22,81.14) v1(106.22,80.49) v1(106.22,79.84) v1(107.15,81.78) v1(107.15,80.49) v1(107.15,67.59) v1(108.07,67.59) v1(109,80.49) v1(109,79.84) v1(108.98,67.59) v1(109.92,81.78) v1(109.92,81.14) v1(109.92,80.49) v1(109.89,67.59) v1(110.84,81.78) v1(110.84,79.84) v1(110.8,67.59) v1(111.71,67.59) v1(112.62,67.59) v2(67.74,78.82) v2(68.6,88.14) v2(106.09,92.56) v2(108.4,79) v3(63.77,75.9) v3(63.77,75.06) v3(64.56,79.68) v3(64.56,78.84) v3(64.61,75.9) v3(64.61,75.06) v3(65.45,75.9) v3(65.45,75.06) v3(65.5,79.68) v3(65.5,78.84) v3(65.5,78.01) v3(65.48,77.07) v3(66.24,82.35) v3(66.24,81.51) v3(66.24,80.67) v3(66.34,79.68) v3(66.34,78.84) v3(66.34,78.01) v3(66.31,77.07) v3(66.31,75.9) v3(66.31,75.06) v3(67.08,82.35) v3(67.08,81.51) v3(67.08,80.67) v3(67.25,74.88) v3(67.2,73.97) v3(67.91,82.35) v3(67.91,81.51) v3(67.91,80.67) v3(68.04,73.97) v3(68.09,74.88) v3(68.75,82.35) v3(68.75,81.51) v3(68.75,80.67) v3(68.93,74.88) v3(69.59,82.35) v3(69.59,81.51) v3(69.59,80.67) v3(69.77,74.6) v3(70.12,79.68) v3(70.12,78.84) v3(70.12,78.01) v3(70.12,77.04) v3(70.12,76.2) v3(70.12,75.36) v3(70.43,82.35) v3(70.43,81.51) v3(70.43,80.67) v3(70.96,79.68) v3(70.96,78.84) v3(70.96,78.01) v3(70.96,77.04) v3(70.96,76.2) v3(71.37,82.32) v3(71.37,81.49) v3(71.37,80.65) v3(71.83,78.16) v3(71.8,77.32) v3(71.8,76.48) v3(71.88,79.91) v3(71.88,79.07) v3(102.3,74.2) v3(102.3,73.36) v3(102.3,72.52) v3(102.3,71.68) v3(102.3,70.84) v3(105.79,69.8) v3(106.75,69.8) v3(108.4,69.8) v3(108.56,75.95) v3(108.56,75.11) v3(108.56,74.27) v3(108.56,73.43) v3(108.56,72.6) v3(108.56,71.76) v3(108.56,70.92) v3(109.32,69.8) v3(111.2,69.79)
1V_GT_CORE: length 3.7
  BOTTOM w0.152: CPU1.AF2 v1(100.29,84.99) ; CPU1.AB2 v1(97.85,84.95)
  BOTTOM w0.203: v1(95.42,84.81) 95.41,84.8 CPU1.V2
  BOTTOM w0.254: v1(102.73,84.65) CPU1.AK2
  vias: v1(97.02,78.13) v1(97.89,78.13) v1(99.41,78.18) v1(100.1,78.18) v2(101.06,80.77)
1V_VCCGT: length 41.2
  L4 w0.508: v1(47.82,69.57) 48.33,69.07 48.33,66.87 50.18,65.02 51.19,65.02 51.73,65.57 51.73,66.02 52.24,66.53 52.24,66.81 53.26,67.82 56.51,67.82 56.56,67.87 58.31,67.87 58.74,67.44 58.95,67.44 v3(61.34,65.05)
  L6 w0.508: v1(39.26,76.84) 39.26,76.66 39.29,76.63 39.29,76.46 39.75,76 40.17,76 41.09,75.08 43.5,75.08 45.79,77.37 46.51,77.37 46.88,77 46.88,76.46 v1(46.8,76.38)
  BOTTOM w0.127: CPU1.P2 v1(92.97,84.61) ; CPU1.K2 90.52,84.88 v1(90.53,84.89)
  BOTTOM w0.305: CPU1.H5 88.99,81.57 v1(88.68,81.26) 89.03,80.92 CPU1.H6
  BOTTOM w0.381: PR4663.1 40.1,75.87 39.26,76.71 v1(39.26,76.84)
  BOTTOM w0.508: v1(46.8,76.38) 46.8,76.07 47.77,75.1 47.77,70.41 47.72,70.36 47.72,69.67 v1(47.82,69.57)
  vias: v1(84.7,79.74) v1(84.96,77.81) v1(84.96,76.87) v1(84.96,74.98) v1(84.96,73.1) v1(85.61,77.81) v1(86.26,77.81) v1(86.26,76.87) v1(86.26,74.98) v1(86.26,73.1) v1(86.91,77.81) v1(86.91,76.87) v1(86.91,74.98) v1(86.91,73.1) v1(87.56,77.81) v1(87.75,79.83) v1(88.18,82.1) v1(88.21,77.81) v1(88.21,76.87) v1(88.21,74.98) v1(88.21,73.1) v1(88.68,79.96) v1(88.86,77.81) v1(88.86,76.87) v1(88.86,74.98) v1(88.86,73.1) v1(89.51,77.81) v1(89.61,79.96) v1(90.16,77.81) v1(90.53,79.96) v1(91.46,79.96) v1(91.46,78.34) v1(94.23,79.86) v1(94.21,78.46) v1(95.13,78.41) v2(63.57,59.67) v2(73.17,66.17) v2(76.47,74.4) v2(80.21,79) v2(82.7,75.29) v2(90.52,79.35) v3(60.88,60.99) v3(60.88,60.07) v3(60.9,59.08) v3(61.74,59.9) v3(61.79,61.12) v3(62.22,65.05) v3(62.48,60.56) v3(63.09,65.08) v3(63.93,65.08) v3(64.61,58.7) v3(64.76,65.08) v3(65.5,59.59) v3(65.48,58.7) v3(65.6,65.08) v3(66.34,59.77) v3(66.31,58.85) v3(66.42,64.19) v3(66.39,60.61) v3(84.12,76.28) v3(92.13,72.27) v3(92.13,71.43) v3(92.97,72.27) v3(92.97,71.43) v3(93.81,72.27) v3(93.81,71.43) v3(94.65,72.27) v3(95.48,72.27) v3(96.32,72.27) v3(97.16,72.27) v3(98,72.27)
1V_VCCIO: length 36.1
  TOP w0.305: R401.1 103.27,69.24 v2(103.47,69.45)
  TOP w0.508: v1(102.65,69.85) 102.65,69.84 102.54,69.74 R401.1
  L6 w0.508: v1(113.44,69.88) 113.44,70.78 116.78,74.12 v1(116.92,74.12)
  BOTTOM w0.305: CPU1.BP18 117.2,73.84 v1(116.92,74.12) 116.92,74.21 CPU1.BP16
  BOTTOM w0.508: v1(154.81,52.71) 148.08,52.71 144.01,56.77 135.53,56.77 132.1,60.2 v1(132.1,61.67)
  vias: v1(113.99,69.52) v3(160.57,58.02) v3(160.57,57.15)
1V_VCCIO_R:
  vias: v2(160.47,59.59)
1V_VCCSA: length 1.5
  BOTTOM w0.254: CPU1.BM24 116.3,69.3 116.3,69.73 116.02,70.01
  BOTTOM w0.305: CPU1.BM24 116.72,68.82 CPU1.BN25
  vias: v1(112.95,78.21) v1(113.61,79.84) v1(113.61,78.41) v1(114.54,79.84) v1(114.6,70.13) v1(115.16,69.8) v1(115.46,79.84) v1(115.46,78.44) v2(104,100.69) v2(106.23,101.03) v2(114.77,79.01) v3(104.49,100.26) v3(104.49,99.42) v3(105.33,100.26) v3(105.33,99.42) v3(106.17,100.26) v3(106.17,99.42)
1V_VCCST_CPU: length 169.4
  TOP w0.152: v1(117.37,85.14) 117.37,84.03 116.94,83.59 116.94,81.44 116.89,81.39 116.89,80.22 116.43,79.76
  TOP w0.254: v1(107.94,97.84) 108.07,97.72 109.19,97.72 110.33,96.57 R308.1 ; PR4603.1 PR4606.1 PR4605.1 PR4604.1 41.37,62.46 PC4602.1 41.88,62.11 42.31,61.67 42.31,59.74 42.21,59.64 42.21,59.54 42.13,59.46 42.13,59.36 v1(42.08,59.31) ; v1(117.37,85.14) 115.96,83.73 115.96,80.23 116.43,79.76 ; v1(84.5,91.75) 84.68,91.75 86.02,93.09 87.04,93.09 87.45,93.5 95.63,93.5 99.1,96.98 103.35,96.98 104.13,96.19 104.8,96.19 105.35,95.64 105.35,95.56 v1(105.48,95.43) 105.48,94.21 109.67,90.02 v1(109.67,88.93)
  TOP w0.508: 116.43,78.25 116.43,79.76
  L3 w0.254: v1(107.94,97.84) 105.53,95.43 v1(105.48,95.43) ; v1(84.5,91.75) 82.7,89.94 68.6,89.94 68.27,89.61 60.07,89.61 59.99,89.54 56.03,89.54 55.62,89.13 50.36,89.13 46.02,84.79 46.02,81.13 44.9,80.01 44.9,79.07 43.56,77.73 43.56,75.47 42.67,74.58 42.67,73.66 40.39,71.39 40.39,67.88 41.68,66.6 41.68,65.34 40.84,64.49 40.84,59.59 40.3,59.06 40.3,58.62 40.6,58.32 41.09,58.32 v1(42.08,59.31)
  L6 w0.254: v1(109.67,88.93) 109.62,88.93 109.07,88.38 109.07,84.86 109.74,84.18 110.95,84.18 112.16,85.4 114.3,85.4 114.57,85.13 116.44,85.13 116.45,85.14 v1(117.37,85.14)
  BOTTOM w0.152: CPU1.BP2 v1(117.37,85.14)
  BOTTOM w0.254: v1(84.5,91.75) 87.24,94.49 91.26,94.49 91.28,94.47 v2(91.36,94.47) 91.48,94.47 94.08,91.87 94.08,91.03 R723.1 94.29,90.99 R726.1 95.42,92.12 98,92.12 98.42,91.7 R727.1 ; R4036.2 107.64,102.19 107.64,98.15 v1(107.94,97.84)
  vias: v1(116.83,77.57)
1V_VCCST_CPU_R:
  vias: v2(106.8,105.29)
1V_VCCSTG: length 144.3
  L3 w0.254: v1(88.82,91.7) 90.18,91.7 91.6,90.27 93.47,90.27 97.1,86.64 99.71,86.64 102.05,88.98 104.01,88.98 106.62,86.36 v1(107.74,86.36) 107.79,86.36 108.17,86.74 108.17,90.38 107.61,90.93 107.61,93.37 108.38,94.14 113.66,94.14 115.18,95.66 117.49,95.66 118.18,94.97 118.92,94.97 v1(118.97,94.92)
  L4 w0.254: v1(118.97,94.92) 118.97,94.8 120.09,93.68 123.34,93.68 123.54,93.88 125.32,93.88 127.27,91.93 127.27,91.32 128.57,90.02 133.5,90.02 134.84,91.37 145.13,91.37 145.61,90.88 150.64,90.88 155.32,86.21 155.32,84.89 157.4,82.81 157.4,82.8 157.7,82.5 158.46,82.5 161.18,79.78 161.18,78.48 168.23,71.42 v1(168.67,71.42) ; v1(107.74,86.36) 108.21,85.89 108.21,85.11 109.67,83.65 112.25,83.65 113.01,84.41 v1(113.01,84.79)
  BOTTOM w0.254: R309.2 R314.2 90.45,91.58 90.8,91.93 R301.1 90.67,92.41 C802.1 89.53,92.41 v1(88.82,91.7) ; CPU1.BG3 CPU1.BG2 CPU1.BG1 113.15,84.65 v1(113.01,84.79) ; v1(168.67,71.42) 168.24,71.42 166.8,69.98 166.8,65.81 166.67,65.69 166.67,60.71 165.88,59.92 163.9,59.92 162.91,58.93 R4038.2 ; R311.2 R312.2 R313.2 R310.2 v2(86.61,91.14) 86.79,91.14 87.78,92.13 88.39,92.13 v1(88.82,91.7) ; v1(88.82,91.7) 88.82,91.29 89.1,91.01 R315.2
1V_VGA_EN_B: length 4.1
  BOTTOM w0.102: R8650.2 152.32,87.71 v2(152.04,87.99) 151.78,88.24 U8604.2
1V_VGA_EN_OR: length 6.1
  TOP w0.102: R8543.2 R8542.2 v2(110.1,102.11) 110.1,102.52 109.21,103.41 109.21,104.22 108.76,104.68 108.22,104.68 108.12,104.78 Q8509.2
1V_VGA_EN_R: length 79.3
  TOP w0.102: v1(148.79,89.13) 149.32,89.13 149.83,88.62 151.53,88.62 152.57,87.58 152.57,85.12 151.76,84.31 151.12,84.31 151.07,84.36 v1(151.02,84.36) ; R8543.1 112.54,101.22 v1(112.57,101.25)
  L4 w0.102: v1(112.57,101.25) 112.55,101.25 112.08,100.78 112.08,100.13 112.72,99.49 112.72,98.58 113.38,97.92 114.19,97.92 115.21,96.9 115.63,96.9 119.57,92.97 123.9,92.97 127.65,89.21 134,89.21 134.69,89.89 141.24,89.89 141.65,89.49 141.65,88.8 141.75,88.7 142.79,88.7 143.45,89.36 144.04,89.36 144.7,88.7 145.59,88.7 146.96,90.07 148.61,90.07 148.79,89.89 v1(148.79,89.13)
  BOTTOM w0.102: v1(151.02,84.36) 150.44,84.36 149.83,84.97 C8631.1 148.56,84.97 147.87,85.66 PU8603.7 ; Q8607.2 156.81,97.87 157.37,97.31 157.37,96.65 156.81,96.09 156.81,94.97 156.2,94.36 156.2,93.02 155.98,92.79 155.57,92.79 155.34,93.02 155.34,93.65 155.11,93.88 153.44,93.88 v2(153.16,93.6) 153.16,93.48 151.85,92.18 149.29,92.18 148.37,91.26 148.37,89.67 148.79,89.26 v1(148.79,89.13) 148.79,88.6 149.14,88.24 R8652.2
1V_VGA_EN_Y: length 4.1
  BOTTOM w0.102: U8604.4 151.13,91.31 150.88,91.57 150.18,91.57 149.96,91.34 v2(149.96,89.99) 149.45,89.49 R8652.1
1V_VGA_S0: length 44.5
  L3 w0.635: v1(155.92,94.77) 156.23,95.07 v3(158.21,95.07)
  L3 w1.016: v1(184.3,104.75) 183.69,105.36 181.01,105.36 180.3,104.65 173.18,104.65 169.97,101.44 169.97,98.68 168.35,97.06 160.19,97.06 v3(158.21,95.07)
  BOTTOM w0.508: v1(155.92,94.77) 155.87,94.82 R8641.1
  BOTTOM w1.016: 157.17,86.74 157.73,87.3 157.73,90.13 158.57,90.97 158.57,94.72 v3(158.21,95.07)
  vias: v2(157.09,85.12)
1V_VGA_S0_DISCHG: length 3.3
  BOTTOM w0.102: R8641.2 156.1,96.65 156.79,96.65 156.97,96.83 v2(156.97,97.18) 156.69,97.46 156.38,97.46 156.16,97.68 Q8607.3
1V_VGA_S0_PG: length 110.9
  TOP w0.102: v1(108.72,100.19) 108.72,100.7 R8542.1
  L3 w0.102: v1(108.72,100.19) 109.04,99.88 109.04,99.04 v1(109.93,98.15) 109.8,98.02 109.8,97.26 112.01,95.05 113.2,95.05 114.12,95.96 121.74,95.96 123.79,93.91 125.41,93.91 128.82,90.5 132.71,90.5 134.36,92.15 146.2,92.15 146.63,91.72 152.73,91.72 157.71,86.74 158.97,86.74 159.65,86.06 159.65,85.43 v1(159.66,85.42) 160.09,85.42 162.43,83.09 162.43,83.07 170.79,74.71 170.79,73.52 173.91,70.4 v1(173.91,69.34)
  BOTTOM w0.102: PR8623.2 147.19,82.63 148.3,81.51 149.55,81.51 149.98,81.08 v2(150.79,81.08) 150.95,81.23 151.73,81.23 152.62,82.12 155.75,82.12 159.08,85.45 159.6,85.45 159.63,85.42 v1(159.66,85.42) ; D8601.2 178.61,62.36 176.6,64.37 176.6,65.28 175.66,66.22 174.77,66.22 174.34,66.65 174.34,66.88 173.3,67.92 173.3,68.86 173.78,69.34 v1(173.91,69.34) ; v1(109.93,98.15) 109.77,98 R8531.1
1V_VREF_CPU: length 4.4
  TOP w0.203: 30.7,37.34 31.07,37.71 U2401.95
  TOP w0.254: R2402.2 30.35,34.47 C2406.1 30.35,35.56 30.7,35.92 v2(30.7,35.99) 30.7,37.34
3.3V_WLAN_EN: length 2.3
  TOP w0.102: Q6102.G 28.72,54.76 v2(28.77,54.71) 29.08,54.71 R6136.1
3V3_AON_1D8V_VGA_S0: length 30.6
  TOP w0.508: C7616.1 176.02,85.13 v1(175.92,85.13)
  L3 w1.016: v1(175.92,85.13) 174.42,83.63 174.42,83.59 173.91,83.09 173.2,83.09 173.17,83.11 173.14,83.11 172.1,84.15 172.1,86.89 174.44,89.23 174.44,93.37 v1(175.94,94.87) 176.24,95.18 176.24,100.66 v1(173.53,103.38)
  BOTTOM w0.356: v1(175.92,85.13) 175.93,85.13 175.96,85.09 GPU1.AA8 177.03,85.65 GPU1.AA9
  BOTTOM w0.635: v1(173.53,103.38) 173.65,103.25 R8609.2
  vias: v2(175.76,94.24)
3V5V_CT1: length 2.3
  TOP w0.203: 210.92,49.28 211.2,48.99 U4001.12
  TOP w0.254: C4001.1 210.53,49.99 v2(210.76,49.76) 210.76,49.43 210.92,49.28
3V5V_CT2: length 3.5
  TOP w0.203: C4010.1 211.91,39.17 212.72,39.17 v2(212.95,39.4) ; 211.35,39.82 U4003.10
  TOP w0.254: C4010.1 211.35,38.76 211.35,39.82
3V5V_S0_ON: length 4.6
  TOP w0.127: U4001.3 211.2,46.36 211.02,46.18 R4010.2 211.02,43.79 C4014.1 211.2,43.61 211.2,42.83 211.35,42.67 U4003.5
3V_5V_DSW_OK: length 244.6
  TOP w0.102: D2503.3 211.17,26.42 211.06,26.31 209.48,26.31 R2514.2 R2513.2 208.4,25.91 v1(208.32,25.99) ; PR5305.1 94.98,13.59 96.84,15.46 101.48,15.46 102.29,16.27 v1(103.5,16.27) ; v1(162.4,45.57) 162.38,45.54 v2(162.38,45.01)
  L3 w0.102: v1(150.36,75.06) 150.76,74.66 153.14,74.66 158.67,69.13 158.67,61.34 161.67,58.35 161.67,56.97 v1(161.61,56.92) ; v1(208.32,25.99) 209.93,24.38 209.93,16.86 211.17,15.62 211.2,15.62 211.42,15.4 211.42,15.37 212.69,14.11 212.69,9.88 211.16,8.35 208.88,8.35 208.37,7.84 205.95,7.84 205.58,8.21 205.58,11.65 201.66,15.57 201.24,15.57 199.66,17.15 195.35,17.15 194.39,18.11 191.73,18.11 191.14,18.7 189.78,18.7 189.24,19.24 184.98,19.24 180.72,23.5 178.53,23.5 178.15,23.12 v1(177.69,23.12)
  L4 w0.102: v1(162.4,45.57) 162.4,44.38 162.63,44.15 162.63,43.79 167.38,39.04 168.09,39.04 168.19,38.94 170.94,38.94 171.06,38.81 171.06,38.81 176.55,33.32 176.55,32.03 176.17,31.65 176.17,29.31 178.33,27.16 178.33,23.35 178.1,23.12 v1(177.69,23.12)
  L6 w0.102: v1(103.45,18.46) 103.91,17.99 134.63,17.99 135.29,17.33 136.35,17.33 137.23,18.21 145.98,18.21 146.34,18.57 170.73,18.57 171.24,18.06 176.23,18.06 176.78,18.61 176.78,19.07 177.67,19.96 177.67,21.67 177.21,22.12 177.21,22.61 177.72,23.12 v1(177.69,23.12)
  BOTTOM w0.102: v1(162.4,45.57) 162.76,45.93 162.76,46.77 161.36,48.17 161.36,52.82 161.72,53.17 161.72,56.82 v1(161.61,56.92) 161.79,57.1 163.37,57.1 163.49,57.23 163.49,59.03 164.08,59.62 166.01,59.62 166.87,60.48 168.37,60.48 168.9,61.01 168.9,61.78 170.22,63.1 U2502.4 ; PR5207.1 149.12,74.02 150.16,75.06 v1(150.36,75.06) ; v1(103.5,16.27) 102.71,16.27 102.61,16.37 102.61,17.62 v1(103.45,18.46)
3V_5V_EN: length 25.7
  TOP w0.102: v1(195.75,56.59) 195.88,56.47 195.88,56.14 195.85,56.11 v2(195.85,56.04) 195.85,55.02 195.22,54.38 195.22,53.83 PR4515.1 196.36,53.85 197.38,53.85 197.56,53.67 PR4516.1 ; C4009.1 203.63,54.38 R4007.1 204.9,54.38 R4009.1 205.43,54.77 R4006.1 206.12,55.45 v1(207.18,55.45) 207.72,55.45 207.94,55.23 D4001.A
  BOTTOM w0.102: v1(207.18,55.45) 205.91,55.45 204.82,56.54 200.02,56.54 199.82,56.74 197.85,56.74 197.53,56.42 197.17,56.42 197.07,56.31 195.9,56.31 195.75,56.47 v1(195.75,56.59)
3V_5V_POK: length 325.6
  TOP w0.102: v1(59.68,5.24) 59.71,5.21 59.71,4.12 PG4529.1 ; R2513.1 208.97,25.06 D2503.1 v1(210.22,25.87) ; ED1703.1 118.23,41.05 117.8,40.62 v2(117.7,40.62) 117.62,40.54 117.47,40.54 117.09,40.92 115.82,40.92 115.26,41.48 115.26,42.14 C1710.1 114.79,42.61 v1(114.45,42.61) 114.01,42.18 R1728.2 ; PG4531.1 200.7,49.1 201.47,48.34 201.47,46 R4033.1 202.18,45.29 202.18,43.82 201.72,43.36 201.72,42.34 200.18,40.8 197.48,40.8 197.23,40.55 197.23,40.09 197,39.86 196.64,39.86 196.31,39.53 183.97,39.53 183.23,38.79 183.23,37.42 185.54,35.11 185.54,34.37 187.88,32.03 187.88,31.14 190.16,28.86 191,28.86 v1(191.05,28.81)
  L4 w0.102: v1(59.68,5.24) 59.76,5.31 59.76,8.42 57.56,10.62 57.4,10.62 57.37,10.65 55.52,10.65 55.42,10.75 55.33,10.75 52.75,13.33 52.75,14.23 48.15,18.83 48.15,28.95 48.35,29.16 48.35,33.41 48.1,33.66 48.1,34.27 47.82,34.55 v1(47.82,35.03) ; v1(162.12,41.68) 162.12,41.11 171.28,31.96 v1(172.89,31.96)
  L6 w0.102: v1(172.89,31.96) 173.53,32.59 175.46,32.59 175.58,32.72 176.19,32.72 176.47,32.44 177.01,32.44 178.07,31.37 182.61,31.37 184.44,29.54 188.11,29.54 188.34,29.31 190.54,29.31 v1(191.05,28.81) 192.96,26.9 199.82,26.9 202.09,24.63 206.2,24.63 207.05,25.48 209.82,25.48 v1(210.22,25.87)
  BOTTOM w0.102: v1(162.12,41.68) 162.12,41.33 160.78,39.98 145.26,39.98 143.96,38.69 122.09,38.69 122.07,38.71 118.26,38.71 115.4,41.57 115.4,42.33 115.12,42.61 v1(114.45,42.61) ; v1(172.89,31.96) 172.33,31.39 155.14,31.39 154.39,30.63 54.95,30.63 53.58,32.01 52.24,32.01 49.52,34.73 48.12,34.73 v1(47.82,35.03)
3V_5V_POK#: length 5.2
  TOP w0.127: R1726.1 112.85,44.07 v2(113.33,44.07) Q1701.5 116.17,44.07 116.3,43.94 116.3,43.61 116.11,43.42 Q1701.6
3V_5V_POK_C: length 7.8
  TOP w0.127: Q1701.2 116.76,44.07 116.61,43.92 116.61,43.47 116.19,43.05 114.22,43.05 113.96,42.8 113.72,42.26 113.35,41.89 R1727.2 113.18,41.86 112.52,41.86 112.24,41.58 v2(112.24,41.35) 112.59,41 R1728.1
5V_AUX_S5: length 4.9
  TOP w0.508: PG4528.2 53.66,4.27 54.27,4.88 56.86,4.88 v2(57.07,4.68) PR4510.2
5V_FAN_VCC:
  vias: v2(222.32,69.04) v3(217.85,66.29) v3(218.76,66.27)
5V_HDD_S0:
  vias: v3(186.73,14.18) v3(187.62,14.14)
5V_HDMI: length 1.8
  BOTTOM w0.508: HDMI1.18 11.44,71.6 ; HDMI1.18 10.86,72.18 ; HDMI1.18 10.28,71.6
  vias: v2(14.12,68.61)
5V_S0: length 446.3
  TOP w0.508: R6512.1 181.86,17.07 181.13,17.8 181.13,19.73 180.65,20.22 v1(180.33,20.22) ; v1(65.55,98.15) 65.55,97.39 66.21,96.73 66.21,93.14 66.72,92.64 v1(66.82,92.64) ; EC8937.1 13.68,35.13 v1(13.66,35.11) ; EC8934.1 v1(30.78,11.03) ; v1(106.9,10.87) 106.98,10.8 EC8936.1 ; R2612.1 219.81,64.27 v1(219.74,64.2) ; PR8502.1 124.48,98 v1(124.56,97.92)
  L3 w0.508: v1(213.28,108.46) 213.28,107.7 214.75,106.23 217.39,106.23 223.9,99.72 223.9,69.95 223.54,69.6 223.54,69.52 219.78,65.76 219.78,64.24 v1(219.74,64.2) ; v1(180.33,20.22) 180.05,19.94 180.05,19.92 179.67,19.54 177.46,19.54 176.85,20.14 176.8,20.14 v1(176.59,20.36)
  L4 w0.508: v1(124.56,97.92) 123.87,98.61 121.81,98.61 120.92,99.49 118.84,99.49 118.49,99.85 118.49,100.84 118.87,101.22 118.87,104.5 117.8,105.57 v1(117.8,107.32) ; v1(15.97,67.85) 15.97,69.37 15.51,69.83 15.51,73.09 16.01,73.59 18.08,73.59 18.51,73.16 20.79,73.16 22.45,74.82 22.45,79.19 22.32,79.33 22.32,82.22 25.01,84.91 26.11,84.91 27.27,86.08 27.27,92.75 28.12,93.6 31.26,93.6 32.68,95.02 33.95,95.02 36.01,97.08 44.29,97.08 44.44,96.93 49.78,96.93 50.62,97.77 63.72,97.77 64.13,98.17 65.02,98.17 65.04,98.15 v1(65.55,98.15)
  L6 w0.508: 223.74,43.06 223.74,58.75 222.78,59.72 222.78,61.14 223.62,61.98 223.62,64.04 223.26,64.4 222.1,64.4 221.9,64.2 v1(219.74,64.2) ; v1(103.06,20.69) 103.19,20.69 104.78,19.1 145.65,19.1 146.23,19.69 174.6,19.69 175.28,20.36 v1(176.59,20.36) ; v1(117.8,107.32) 117.8,106.58 118.6,105.78 119.54,105.78 119.73,105.97 120.26,106.5 121.03,106.5 121.04,106.51 122.07,106.51 122.34,106.25 122.37,106.25 122.4,106.23 127.07,106.23 128.87,108.03 153.82,108.03 153.92,107.93 166.19,107.93 166.34,107.77 166.36,107.77 166.61,107.52 167.68,107.52 171.75,103.46 ; v1(15.97,67.16) 14.68,65.86 14.68,60.76 13.1,59.18 13.1,56.44 12.74,56.09 12.74,54.18 14.01,52.91 14.01,43.64 14.88,42.78 14.88,41.63 13.66,40.41 v1(13.66,35.11) 13.56,35 13.56,31.12 15.16,29.52 15.16,25.68 v1(16.48,24.36) ; v1(171.75,100.18) 171.75,103.46 ; 171.75,103.46 172.49,104.19 175.48,104.19 178.38,107.09 185.97,107.09 187.4,108.51 195.09,108.51 196.84,106.76 201.21,106.76 202.91,108.46 v1(213.28,108.46)
  BOTTOM w0.203: U8601.4 171.9,100.03 v1(171.75,100.18)
  BOTTOM w0.508: 17.53,67.37 18.84,67.37 18.94,67.26 19.65,67.26 19.88,67.03 EC8933.1 EC8939.1 21.61,66.58 21.61,66.04 22.63,65.03 D5701.3 ; 183.92,16.64 183.92,17.69 181.38,20.22 v1(180.33,20.22) ; v1(103.06,20.69) 102.53,20.16 102.53,19.18 99.28,15.93 F6502.1 98.8,15.45 98.5,15.14 R6504.1 96.78,15.14 Q6502.E ; C5542.1 66.82,91.75 v1(66.82,92.64) 66.14,93.32 C5550.1 65.96,92.76 U5502.3 65.04,91.85 65.04,91.04 64.66,90.66 63.72,90.66 63.15,91.23 U5502.1 63.15,93.03 R5558.1
  vias: v1(17.19,24.34) v1(203.47,10.8) v1(203.47,10.09) v2(30.86,9.45) v3(33.6,11.03) v3(33.65,10.14) v3(184.47,13.19) v3(184.47,12.35) v3(184.5,11.46) v3(207.26,48.26) v3(208.12,48.39) v3(209.7,49.13)
5V_S5: length 308.6
  TOP w0.203: U4003.4 211.75,42.9 v1(211.65,43) ; U4001.4 211.6,46.15 211.5,46.05 v1(211.5,46.03)
  TOP w0.254: U7204.H10 75.09,100.27 75.15,100.33 75.2,100.33 75.61,100.74 v1(75.62,100.74)
  TOP w0.305: PU4701.29 52.76,65.45 52.6,65.61 v1(52.6,65.63) ; v1(52.9,86.18) 53.4,85.69 PU4802.29 ; v1(51.4,75.72) 51.68,75.72 52.08,75.33 PU4801.29
  TOP w0.406: PR4813.2 53.05,87.38 PC4866.1 53.13,86.87 52.9,86.64 v1(52.9,86.18)
  TOP w0.508: v1(161.06,72.06) 161.26,72.26 161.26,72.98 160.57,73.67 159.85,73.67 159.22,73.05 157.9,73.05 157.88,73.03 156.56,73.03 156.13,72.6 v2(155.14,72.6) 152.17,72.6 149.27,69.7 v1(147.57,69.7) ; v1(170.9,47.86) 171.9,48.86 171.9,57.11 167.99,61.01 167.99,63.68 168.35,64.04 168.35,65.19 166.5,67.03 v1(165.68,67.03) 165.53,67.03 165.02,66.53 165.02,62.61 C4041.1 165.88,62.44 v1(165.93,62.39) ; v1(92.98,14.81) 92.88,14.81 92.59,15.1 PC5305.1 ; v1(84.47,7.04) 84.47,9.98 83.71,10.75 83.71,11.65 v1(83.15,12.22) ; v1(35.96,74.96) 35.96,72.46 37.98,70.44 38.84,70.44 39.21,70.07 39.21,69.52 33.93,64.24 33.93,63.01 32.47,61.55 31.52,61.55 30.37,60.4 29.25,60.4 28.75,59.9 23.81,59.9 23.29,60.42 23.29,61.24 22.7,61.83 22.7,62.47 22.18,62.99 21.94,62.99 21.45,63.49 20.37,63.76 19.87,63.76 19.82,63.71 19.63,63.71 v1(19.6,63.68)
  L3 w0.508: v1(51.4,75.72) 50.84,75.16 50.84,70.79 52.19,69.45 52.19,66.04 v1(52.6,65.63) 51.02,64.06 51.02,62.98 49.7,61.66 43.95,61.66 42.26,59.97 v1(41.8,59.97) ; v1(17.95,34.19) 18.94,34.19 19.25,33.89 20.24,33.89 21.42,32.7 v1(21.42,30.87)
  L4 w0.508: v1(170.9,47.86) 171.03,47.86 179.67,39.22 195.69,39.22 196.3,38.61 197.81,38.61 198.33,38.09 201.65,38.09 202.2,38.65 202.2,42.33 202.58,42.7 203.5,42.7 204.01,43.21 204.01,43.83 206.11,45.93 v3(209.42,45.93) ; v1(161.52,66.98) 165.63,66.98 v1(165.68,67.03) 165.68,67.53 163.96,69.24 163.24,69.24 161.06,71.43 v1(161.06,72.06) ; v1(51.4,75.72) 51.1,76.02 51.1,80.83 51.99,81.71 51.99,84.41 52.9,85.32 v1(52.9,86.18) ; 92.42,104.12 91.92,103.61 91.02,103.61 90.67,103.96 88.11,103.96 85.92,106.15 75.79,106.15 74.06,104.42 v1(74.06,102.06) ; 92.15,106.02 92.65,106.53 101.47,106.53 101.59,106.4 101.62,106.4 102.15,105.87 102.15,105.84 102.78,105.22 110.28,105.22 111.02,104.47 v1(112.67,104.47)
  L6 w0.508: v1(35.96,74.96) 37.26,73.66 38.98,73.66 39.03,73.61 39.16,73.61 39.49,73.28 48.43,73.28 48.81,73.66 48.86,73.66 50.92,75.72 v1(51.4,75.72)
  BOTTOM w0.254: v1(91.71,105.16) 91.59,105.16 91.56,105.13 PU5001.6 ; PR4635.1 36.04,74.88 v1(35.96,74.96)
  BOTTOM w0.305: PR4610.1 41.55,59.72 v1(41.8,59.97) ; v1(147.57,69.7) 147.78,69.49 PU5201.21 ; U3601.1 v1(21.42,30.87)
  BOTTOM w0.406: U4006.3 113.3,103.69 C4031.1 ; U4004.3 165.85,62.39 165.86,62.39 v1(165.93,62.39) ; U4002.3 160.29,64.9 160.67,65.28 160.67,65.51
  BOTTOM w0.508: C4031.1 113.35,103.67 113.35,103.96 112.85,104.47 v1(112.67,104.47) ; PU5301.6 92.86,14.84 92.88,14.81 v1(92.98,14.81) ; 160.67,65.51 160.7,65.53 C4032.1 161.03,66.04 161.52,66.54 v1(161.52,66.98) ; v1(15.03,30.76) 15.77,30.76 16.4,30.13 R3605.1 ; v1(17.9,98.15) 17.85,98.2 R4303.1 ; PR4704.2 52.83,64.62 FC8906.1 ; FC8906.1 52.6,65.2 v1(52.6,65.63) ; FC8906.1 PC4766.1 ; PC4877.1 52.55,75.19 52.27,74.91 PR4803.2 51.94,75.19 v1(51.4,75.72) ; PC5202.1 147.02,69.75 147.52,69.75 v1(147.57,69.7) ; v1(83.15,12.22) 81.53,10.59 72.74,10.59 72.71,10.62 62.11,10.62 61.46,9.97 59.85,9.97 58.97,10.85 PC5112.1 57.83,10.72 58.29,10.26 PR5108.1 ; PU5102.6 71.57,14.94 71.95,15.32 72.49,15.32 v1(72.84,15.67) ; v1(35.96,74.96) EC8947.1
  vias: v1(15.64,92.79) v1(15.97,33.07) v1(16.22,93.14) v1(16.22,92.51) v1(17.37,34.6) v1(71.16,95.74) v1(71.42,96.34) v1(71.8,95.74) v1(187.88,16.06) v1(188.59,15.85) v1(189.16,16.14) v1(189.45,16.87) v2(16.66,55.4) v2(37.1,6.63) v2(67.41,100.49) v2(67.99,97.23) v2(74.26,100.89) v3(15.16,55.7) v3(15.18,54.87) v3(16,55.68) v3(16.1,54.79) v3(34.03,99.52) v3(34.87,99.52) v3(35.71,99.52) v3(37.09,8.52) v3(37.7,7.95) v3(37.69,7.04) v3(37.69,6.2) v3(37.66,5.36) v3(37.66,4.52) v3(37.66,3.69) v3(37.66,2.85) v3(66.36,99.56) v3(67.21,99.55) v3(68.04,99.57) v3(209.42,45.06) v3(210.26,45.9) v3(210.26,45.04) v3(213.38,16.87) v3(213.38,15.95) v3(214.24,16.84) v3(214.24,15.93)
5V_USB2_S0:
  vias: v2(220.11,40.85) v3(191.6,16.77) v3(191.6,15.88) v3(211.47,13.85) v3(211.98,13.16) v3(218.99,39.96) v3(219.37,40.8)
5V_USB30_VCCA: length 4.2
  TOP w0.508: USB4.1 12.99,48.65 ; USB4.1 12.15,47.81 ; USB4.1 12.15,49.49
  BOTTOM w0.508: 12.15,49.49 USB4.1 12.99,48.65
  vias: v1(14.7,49.48) v1(14.7,48.85) v1(14.7,48.16) v2(18.97,49.73)
5V_USB30_VCCB: length 2.7
  TOP w0.508: 12.15,29.49 USB3.1 12.99,28.65
  BOTTOM w0.508: ED3502.5 17.8,38.19 v1(17.45,38.53)
  vias: v1(21.56,34.62) v1(21.71,33.99) v2(21.13,35.49) v2(23.36,48.21) v2(25.85,29.09) v3(14.24,28.45) v3(14.27,29.34) v3(23.67,49.61) v3(23.74,48.77) v3(25.29,29.44) v3(25.39,28.6)
20V_DCBATOUT: length 2.6
  BOTTOM w0.254: PR4401.2 150.16,11.85 150.44,12.12 151.34,12.12 151.35,12.12 151.51,12.12 PG4402.1
  vias: v2(148.91,8.03) v3(148.25,7.44) v3(151.1,7.44) v3(151.94,7.39) v3(152.78,7.39)
20V_VCCPD_VBUS: length 20.4
  TOP w0.508: 6.42,90.3 USB1.B4 5.91,90.81 ; v3(19.08,84.99) 19.24,85.14 R7425.1 ; 6.42,87.7 USB1.B9 5.91,87.19
  L4 w0.508: 5.91,90.81 USB1.B4 6.42,90.3 ; 6.42,87.7 USB1.B9 6.44,87.94
  L6 w0.508: 6.42,87.7 USB1.B9 6.33,87.29
  BOTTOM w0.178: USB1.A4 7.27,87.75 7.87,87.15 8.25,87.15 v1(8.45,86.95) ; v1(8.17,90.6) 7.61,90.6 7.26,90.25 USB1.A9
  BOTTOM w0.254: 18.89,81.49 19.27,81.1 R7423.1 21.03,80.6 22.17,80.6 22.35,80.42 R7426.1
  BOTTOM w0.305: USB1.B9 5.96,87.75 USB1.A4 ; USB1.A9 5.96,90.25 USB1.B4
  BOTTOM w0.508: v3(18.08,84.94) 17.87,84.74 17.85,84.74 17.34,84.23 17.34,83.04 18.89,81.49
  vias: v1(9.04,86.67) v1(11.14,92.1) v1(11.68,91.52) v1(31.62,97.89) v1(32.28,97.89) v1(32.91,97.89) v2(12.29,92.05) v3(17.9,85.8) v3(18.74,85.78)
20V_VCCPD_VBUS_L: length 8.1
  TOP w0.305: v1(70.48,92.36) 70.53,92.41 72.87,92.41 ; 72.87,92.41 v2(72.87,92.33) ; 72.87,92.41 73.02,92.41 73.53,92.92 R7235.1 R7234.1
  BOTTOM w0.356: v1(70.48,92.36) 70.48,95.38 69.89,95.96
  vias: v1(72.84,101.78) v1(73.35,102.21) v1(73.48,101.58) v2(70.62,100.55) v2(73.17,102.75)
+3V_1D8V_AVDD: length 6.2
  TOP w0.203: U2701.33 22.97,13.15 22.9,13.08 22.9,13.07 22.15,12.32 v2(21.84,12.32) 20.8,12.32 20.62,12.14 v1(20.49,12.14)
  TOP w0.254: C2710.1 19.12,11.41 19.86,12.14 v1(20.49,12.14)
  BOTTOM w0.254: v1(20.49,12.14) 19.84,12.8 19.83,13.05 R2719.2
+3V_1D8V_DVDD: length 11
  TOP w0.203: U2701.8 27.36,17 27.4,17.05 v1(27.63,17.05) ; v1(27.12,14.33) 27,14.2 U2701.1
  L6 w0.254: v1(28.04,17.6) 28.04,19.89 26.51,21.41 26.51,21.57 25.88,22.2 24.02,22.2 v1(23.29,22.94)
  BOTTOM w0.254: R2710.1 v1(23.29,22.94)
  vias: v2(27.5,16.03)
+5V_AVDD:
  vias: v2(20.77,19.43)
+5V_KB_BL: length 2.4
  TOP w0.508: C6501.1 97.61,13.06 v1(97.58,13.03) 98.34,13.03 AFTP6605.1
+5V_PVDD:
  vias: v2(26.92,11.05)
+5V_PVDD1: length 2.5
  TOP w0.203: U2701.39 25.37,13.21 25.6,12.98 26.41,12.98 v3(26.46,13.03) ; U2701.34 23.37,12.56
  vias: v2(22.6,9.93) v2(27.27,13.08) v3(23.21,12.43) v3(23.49,10.32) v3(23.54,9.45)
DVSS: length 2.5
  TOP w0.102: R2716.2 27.81,18.87 v2(27.49,18.56) 26.74,17.8 U2701.10
GND: length 2436.1
  TOP w0.102: 135.4,81.03 136.75,81.03 137.05,80.72 v1(137.05,80.62) 137.05,80.22 136.8,79.96 135.68,79.96 135.22,80.42 v1(135.22,80.85) 135.4,81.03 ; 131.1,84.5 131.24,84.64 v1(131.24,84.99) 131.24,85.27 131.11,85.4 129.58,85.4 129.36,85.17 129.36,84.81 129.67,84.5 131.1,84.5
  TOP w0.127: v1(211.29,80.15) 211.29,79.2 v1(211.66,78.83)
  TOP w0.203: U2401.51 38.38,48.32 v1(38.27,48.21) ; C1804.2 110.08,52.61 110.08,50.4 ; U2401.64 33.18,52.07 v1(33.69,52.58) ; v1(211.8,49.41) 211.6,49.2 U4001.11 ; v1(44.29,36.99) 43.98,36.67 U2401.124 ; v1(111.8,49.99) 111.91,50.09 114.18,50.09 114.33,50.24 114.33,52.57 C1803.2 ; U2401.84 32.66,42.11 32.84,42.29 v1(32.84,42.67) ; v1(211.88,39.68) 211.75,39.8 U4003.11 ; v1(110.1,54.05) 111.2,54.05 v1(112.87,55.73) ; C2428.2 42.59,32.72 42.59,30.86 43.02,30.43 46.98,30.43 47.26,30.71 47.26,30.99 47.29,31.02 47.29,32.3 47.44,32.44 C2424.1 ; v1(45.33,43.95) 45.67,43.61 46.21,43.61 46.32,43.71 U2401.17 ; v1(34.08,36.96) 34.13,36.91 34.16,36.91 34.38,36.69 U2401.100
  TOP w0.229: U7204.A6 U7204.A7 U7204.A8
  TOP w0.254: C7226.1 80.31,93.45 80.31,94.59 80.03,94.87 80.03,95.02 79.51,95.55 U7204.A1 ; v1(76.12,95.82) 76.12,95.84 76.14,95.86 76.14,96.03 76.51,96.39 U7204.A7 U7204.B7 76.47,97.23 76.04,97.23 U7204.B8 ; R2002.1 127.38,47.4 G1801.1 ; ED502.3 145.77,44.76 147.9,44.76 v1(148.71,45.57) ; C2219.2 128.25,80.34 R1603.2 127.95,80.09 127.95,79.75 v1(127.45,79.25) ; C1803.2 114.22,54.23 115.08,55.1 115.08,57.05 114.62,57.51 v1(114.59,57.51) ; v1(119.6,42.73) 120.2,43.33 Q1702.4 119.7,43.68 119.32,44.06 119.32,44.72 119.07,44.98 Q1702.1 ; PQ4418.1 99.24,9.13 99.61,9.5 100.27,9.5 100.53,9.76 100.53,10.24 PQ4418.4 ; U7204.L1 79.51,102.32 79.7,102.52 79.7,103.1 80,103.41 v1(80,103.66) ; PC4432.2 154.88,15.14 154.71,15.32 154.71,16.97 154.96,17.22 v1(156.28,17.22) ; Q2001.4 v1(130.16,46.15)
  TOP w0.305: v1(51.02,86.19) 50.67,86.54 PR4818.2 ; v1(89.96,5.51) 89.7,5.51 DBG3.8 ; ED3501.3 ED3501.8 v1(16.48,26.27) ; v3(123.9,11.76) AFTP4306.1 ; v1(69.33,19.96) 70.02,20.65 C1229.2 72.33,20.68 RN1201.2 ; ED7306.3 10.15,85.12 v1(10.54,84.74) ; PU4802.28 53.9,85.93 53.66,86.16 v1(53.66,86.21) ; 28.25,80.85 Q7404.4 28.25,82.19 28.53,82.47 Q7406.4 ; 28.25,80.85 27.26,80.85 26.95,80.55 Q7404.1 ; 28.25,80.85 28.48,80.85 28.72,80.61 28.72,80.22 28.72,80.22 28.72,79.89 v1(29.23,79.38) ; EC1901.1 EC1903.2 112.08,46.84 v1(111.86,46.61) ; v1(126.95,77.88) 126.95,77.96 127.4,78.41 R2009.2 ; v1(91.36,6.81) 91.36,6.81 DBG3.4 ; v1(32.25,81.81) 32.25,81.66 31.76,81.17 Q7406.1 ; ED7302.8 ED7302.3 13.28,81.41 13.15,81.28 12.49,81.28 v1(12.36,81.41) ; C1806.2 127.86,44.66 128.11,44.4 128.11,42.83 C1805.2 ; Q8509.4 107.47,103.31 v1(107.06,102.9) ; U9101.32 v1(205.61,32.75) ; U9101.23 200.22,33.88 199.92,33.58 199.92,33.52 v1(199.77,33.37) ; EC3513.2 18.38,28.07 v1(18.69,28.37) ; v1(13.3,65.51) 13.81,65 ED5703.3 ED5703.8 ; v1(29.53,76.43) 32.56,76.43 33.31,75.67 ED7303.3 33.31,74.3 R7309.2 ; v1(53.44,65.66) 53.26,65.48 PU4701.28 ; PU4801.28 52.58,74.46 v1(51.64,73.53) ; C2423.2 40.05,54.36 v1(40.12,54.43) ; C8136.2 R8103.2 ; v1(14.41,85.42) 14.17,85.42 14.14,85.45 13.77,85.45 ED7301.8 ED7301.3 ; v1(208.4,96.52) 208.4,95.96 R8110.1 ; U7001.7 168.19,54.34 C7004.2 ; Q2001.1 128.76,48.43 128.09,49.1 v1(128.09,49.18) ; v1(208.7,44.26) 208.78,44.35 FC8901.2 209.82,44.35 210.2,43.97 C4014.2 ; U7001.5 168.83,52.18 v1(169.03,52.38) 168.73,52.68 U7001.6 ; C7003.2 167.89,54.64 C7004.2 ; v1(19.48,88.06) 19.37,88.06 19.2,88.24 R7430.2 18.84,88.22 18.02,87.4 ED7304.3 ; C7004.2 167.63,53.97 U7001.8 ; Q401.4 101.15,94.25 v1(101.52,93.88) ; v1(212.96,44.7) Q4001.1 ; R8112.1 210.31,82.71 v1(210.1,82.91) ; v1(201.31,39.12) 201.37,39.07 U9101.16 ; v1(13.63,88.67) 13.63,88.82 ED7305.3 13.22,90.01 R7308.2 ; v1(182.32,92.72) 182.1,92.5 C7630.2 C7622.2 ; DBG3.7 93.41,4.73 93.31,4.73 v1(93.24,4.65) ; Q8509.1 108.77,105.52 110.31,107.06 v1(115.13,107.06) ; PQ4418.1 99.24,8.52 98.42,7.7 v1(98.42,7.39) ; v1(46.83,75.14) 47.53,75.14 PR4817.2 ; C6401.2 53.41,54.05 52.73,53.38 D4302.1 53.41,53.22 v1(53.72,52.91) ; v1(79.78,91.87) 79.78,92.56 C7226.1
  TOP w0.356: U6402.3 29.77,59.25 29.48,58.96 v1(29.48,58.89) ; C803.1 111.93,69.58 112.18,69.83 112.74,69.83 v1(112.82,69.75) ; R1555.2 134.57,46.28 ED1701.3 ; v1(214.88,64.21) 215.37,63.72 Q7001.1 ; Q4001.4 216.28,43.4 216.65,43.77 v1(216.91,43.77) ; v1(147.36,18.11) 147.36,18.54 148.3,19.48 R1309.2 148.49,19.57 RN1301.2 ; v1(97.17,93.27) 97.17,94.03 98.99,95.85 Q401.1 ; PC4422.2 162.25,6.71 v1(162.25,7.67) ; v1(216.76,60.49) 216.76,60.58 217.02,60.85 Q7001.4
  TOP w0.381: C1232.2 C1212.2 C1211.2 ; Q1701.4 115.63,45.26 115.55,45.34 115.55,45.43 EC1712.2 114.83,45.29 114.83,44.76 v1(114.73,44.66) ; C1226.2 98.09,21.85 C1225.2 96.54,22.38 96.31,22.15 v1(96.15,22.15) ; R7806.2 197.15,82.45 197,82.6 v1(196.89,82.6) ; v1(49.7,38.05) 49.09,38.05 C2411.2 ; C1213.2 103.42,27.82 v1(102.79,27.18) C1207.2 101.54,26.88 C1231.2
  TOP w0.406: v1(151.28,22.23) 152.24,21.26 152.24,19.43 151.63,18.82 C1301.2 ; v1(213.35,23.98) 213.35,23.42 212.67,22.74 R2503.2 ; v1(133.5,51.71) 133.5,52.17 R1901.2 ; v1(211.66,99.8) 211.36,99.49 R8106.2 210.79,99.57 C8140.2 ; C8037.2 187.17,76.35 186.81,76.71 186.81,77.16 v1(187.07,77.42) ; C7244.2 83.76,101.22 C7225.2 ; R1719.2 112.64,94.08 C1711.2 111.86,94.08 111.35,93.58 v1(111.35,93.53) ; PC4435.2 139.47,5.46 v1(139.16,5.16) ; FC8902.2 54.86,32.62 54.88,32.59 54.89,32.59 55.07,32.41 v1(55.42,32.41) ; FC8929.2 152.78,16.87 C1329.2 ; R7231.2 75.33,92.79 R7230.2 76.17,92.79 76.42,93.04 76.42,95.2 76.12,95.51 v1(76.12,95.82) ; EC2401.2 56.64,49.71 56.17,49.71 55.82,50.05 55.82,50.98 56.27,51.42 Q2705.S ; v1(40.12,54.43) 40.25,54.56 40.99,54.56 C6402.2 ; v1(180.9,14.44) 180.9,14.43 EC6502.2
  TOP w0.457: C2425.1 43.38,33.02 42.79,33.02 C2428.2 ; C2412.2 50.13,44.17 C2418.2 ; C2410.2 v1(51.15,47.2)
  TOP w0.508: v1(172.66,5.64) PR4426.2 172.66,6.71 EC8950.2 ; v1(57.5,49.32) 57.18,49.63 EC2401.2 ; C1317.2 153.84,22.18 v1(153.09,22.18) ; R6513.2 v1(181.76,7.9) ; v1(102.2,14.48) 101.72,14.96 R6507.2 101.39,14.91 C6502.2 ; v1(34.74,59.85) 34.77,59.82 35.27,59.82 35.71,60.25 PC4604.1 35.71,61.88 PR4672.1 PR4608.1 ; R7926.2 176.8,68.23 v1(176.8,68.58) ; v1(95.55,21.21) 94.94,21.21 94.87,21.14 94.81,21.14 94.38,20.7 R1205.1 ; v1(122.27,77.64) 122.4,77.78 C2216.2 ; v1(122.92,69.24) 123.31,69.24 123.59,69.52 R305.2 ; v1(76.05,22.07) 76.37,22.07 76.76,21.67 76.76,21.15 76.47,20.86 R1212.1 ; v1(216.05,53.05) 215.51,53.58 C6101.2 ; v1(36.19,13.9) EC2709.2 EC2710.2 ; 6.19,33 USB3.11 4.45,33.89 ; PR4551.2 54.15,1.17 v1(54.15,0.84) ; v1(13.25,94.69) 12.9,94.34 EC6404.2 12.47,93.58 EC6402.2 ; R2611.2 60.55,45.29 61.06,45.8 v1(62.15,45.8) ; v1(219.4,58.75) 219.65,59.01 AFTP2604.1 ; C2709.1 17.06,14.91 17.82,14.15 17.82,14.13 v1(17.85,14.1) ; v1(118.89,51.72) FC1801.1 119.58,52.43 R1723.2 ; C2503.2 208.22,17.17 v1(207.94,17.45) ; v1(22.88,98.53) 23.01,98.53 23.06,98.58 R4302.2 ; C7244.2 84.02,100.36 C7228.2 C7230.1 84.42,98.86 85.16,98.12 85.16,98 85.39,97.77 v1(85.39,96.85) 85.39,96.78 84.78,96.17 R7243.2 ; v1(62.2,64.21) 64.21,64.21 65.02,63.4 PC4706.2 ; PR4436.2 167.13,17.12 165.42,17.12 PR4475.2 165.7,17.45 v1(165.7,17.91) ; v1(98.94,26.51) 99.08,26.65 C1211.2 ; EC4310.2 115.82,10.16 v1(116.12,9.86) ; v1(49.45,91.14) 49.17,91.42 EC5503.2 ; FC8918.2 47.9,94.26 C5514.2 47.77,96.11 46.83,97.05 46.83,97.28 46.78,97.34 v1(46.78,97.56) ; C1233.2 102.05,22.35 v1(102.31,22.61) ; C1233.2 C1224.2 C1230.2 ; C1233.2 101.67,21.59 C1227.2 101.92,20.3 R1210.1 ; v1(47.45,65.67) 48.03,66.25 PR4712.2 ; C1214.2 82.72,24.89 82.83,25.01 82.97,25.01 v1(83.08,25.12) ; R5709.2 19.44,68.61 v1(19.55,68.72) 19.59,68.68 R7322.2 ; 2.81,57.46 HDMI1.20 ; HDMI1.20 4.14,58.45 ; HDMI1.20 1.48,58.45 ; 6.36,84.53 USB1.15 ; USB1.15 7.45,83.74 ; USB1.15 8.54,84.53 ; v1(95.14,79.87) 95.52,79.48 R316.2 R601.2 ; v1(181.86,59.06) 182.34,58.58 PR8626.2 PR8632.1 PC8616.2 180.82,58.35 R8604.2 ; v1(140.76,46.15) 141.68,46.15 142.11,46.59 EC1804.2 141.37,47.04 R1816.2 ; R7602.2 174.77,90.07 175.03,90.33 175.33,90.33 v1(175.36,90.35) ; v1(208.28,72.7) 208.73,72.24 R8109.1 ; v1(86.63,22.13) 86.68,22.18 C1217.2 ; v1(24.76,3.71) EC2903.2 EC2901.2 ; R1521.2 146.3,47.08 Q1802.S ; v1(118.25,26.24) 118.64,26.63 C1308.2 ; v1(182.34,95.02) 182.79,94.58 C7938.2 ; PR4485.2 158.64,6.23 v1(158.21,5.79) ; v1(93.54,26.26) 93.79,26.26 C1228.2 94.13,26.83 93.49,27.46 C1223.2 ; C9106.2 209.49,32.82 v1(210.05,32.82) 210.51,32.82 211.02,33.33 C9108.2 ; C6501.2 97.22,14.68 v1(96.47,13.93) ; v1(193.34,53.16) 193.47,53.16 193.57,53.27 PR4530.1 ; R9142.2 205.96,40.26 v1(206.19,40.49) 206.19,40.44 206.9,39.73 C9112.2 207.87,39.6 C9109.2 ; v1(101.69,66.95) 101.75,67.01 PC1006.2 ; C7004.2 168.45,54.43 v1(168.88,54.87) ; AFTP6537.1 60.37,4.52 v3(60.37,5.92) ; R4048.2 213.99,46.59 214.27,46.87 v1(214.85,46.87) ; v1(128.67,41.48) 128.67,41.96 128.01,42.62 C1805.2 ; v1(47.62,34.09) 47.52,33.99 47.52,33.1 C2424.1 ; USB1.14 6.45,82.93 ; USB1.14 3.78,82.93 ; USB1.14 5.12,82.09 ; v1(69.56,18.37) R1209.2 ; C2203.2 121.1,73.56 v1(120.98,73.43) ; R720.2 103.03,78.58 v1(102.69,78.24) ; v1(166.01,5.87) 165.8,6.09 165.79,6.09 165.6,6.28 165.6,6.28 165.4,6.48 PC4419.2 ; PQ4417.S 97.9,5.6 v1(97.91,5.62) ; v1(188.39,14.18) 188.51,14.05 188.51,14.04 188.77,13.79 C6007.2 ; HDMI1.22 11.59,60.35 ; HDMI1.22 10.26,61.34 ; HDMI1.22 10.26,59.36 ; EC8938.2 185.41,15.67 v1(185.44,15.7) 184.98,15.7 184.47,15.19 C6001.2 ; PC4524.2 52.47,6.2 v1(52.98,5.69) ; v1(126.88,26.37) 127.95,27.43 C1305.2 ; v1(145.94,48.59) 145.93,48.58 Q1802.S ; v1(110.1,54.05) 110.15,54 C1804.2 ; C7906.2 183.29,79.55 v1(182.6,79.55) ; 10.26,75.84 HDMI1.23 10.26,73.86 ; v1(173.46,8.61) 173.38,8.61 172.87,9.12 172.87,9.43 173.27,9.84 EC6505.2 EC6504.2 ; USB1.21 5.12,95.91 ; USB1.21 3.78,95.07 ; USB1.21 6.45,95.07 ; HDMI1.21 4.14,76.75 ; HDMI1.21 2.81,77.74 ; HDMI1.21 1.48,76.75 ; C6308.2 v1(217.6,23.47) ; C4041.2 164.28,62.03 164.79,61.52 164.79,60.5 v1(164.84,60.45) ; PC4812.2 PC4866.2 53.36,88.22 53.97,87.62 53.97,86.51 v1(53.66,86.21) ; v1(116.63,75.29) 116.81,75.29 116.99,75.11 C2214.2 ; C2517.2 210.61,22.79 v1(210.84,22.56) ; C2409.2 51.99,48.19 R2448.2 51.33,48.21 v1(51.28,48.16) ; v1(143.95,68.04) 144.24,67.74 C1122.2 ; 5.28,85.8 USB1.B12 5.91,84.76 ; U4003.15 213.4,41.35 v1(213.43,41.32) 213.54,41.43 R4019.2 ; R6134.2 146.12,63.99 v1(146.35,63.76) ; v1(59.15,13.87) EC8917.2 ; EC8917.2 FC8928.2 ; EC8917.2 57.53,13.16 EC8925.2 ; v1(39.38,25.96) 39.45,26.04 EC1202.2 ; v1(13.51,14.43) EC2704.2 ED2907.2 14.37,13.79 ED2909.2 ; USB1.20 7.45,94.26 ; USB1.20 6.36,93.48 ; USB1.20 8.54,93.48 ; C1320.2 132.6,20.81 v1(133.2,21.41) ; 212.69,64.8 212.69,65.26 211.91,66.04 R8107.2 ; 212.69,64.8 v1(212.69,64.14) ; 212.69,64.8 212.64,64.85 C8142.2 ; C8048.2 184,78.19 v1(183.66,77.85) ; v1(213.35,23.98) C2525.2 ; v1(214.65,38.59) 214.67,38.61 214.67,38.67 214.65,38.71 EC6401.2 ; C1303.2 112.91,21.43 v1(111.88,21.43) ; v1(212.77,8.59) 211.64,8.59 211.64,8.59 211.11,8.59 211.11,8.59 Q2501.S ; PR4617.2 49.19,68.3 v1(49.7,68.3) ; Q6102.S 28.72,58.13 v1(29.48,58.89) ; R7324.2 v1(27.5,62.84) ; ED301.3 108.18,93.37 107.1,93.37 106.57,93.9 v1(106.57,93.98) ; C2739.2 24.82,22.72 25.51,22.72 v1(25.52,22.71) 25.55,22.71 25.57,22.68 25.95,22.68 26.56,22.08 R2735.2 ; R1511.2 129.81,51.72 v1(129.76,51.77) ; 5.28,92.2 USB1.B1 5.91,93.24 ; C1329.2 152.47,17.07 151.63,17.91 C1301.2 ; v1(214.17,57.48) 214.35,57.3 PQ4402.S ; PC8526.1 v1(119.5,103.25) ; v1(168.73,72.09) 168.45,72.37 165.02,72.37 FC8920.2 ; 11.79,40.81 USB4.4 12.15,40.81 ; PC1004.2 v1(104.54,69.83) ; PC8508.2 v1(135.5,106.5) 134.69,107.32 FC8925.2 ; v1(180.88,68.85) 180.65,68.85 180.33,69.17 R7818.2 ; v1(117.19,103.43) 116.96,103.66 PC8522.1 116.99,104.09 116.99,104.7 PR8517.2 ; C6103.2 23.16,58.32 v1(22.73,57.89) ; EC8913.2 41.8,23.55 v1(41.06,23.55) ; PR5101.2 54.53,14.3 54.55,14.33 54.55,14.81 v1(54.58,14.84) 54.53,14.84 54.15,15.22 EC4534.2 ; v1(128.09,49.18) 127.98,49.08 R2002.1 ; FC8905.2 v1(209.06,29.26) ; v1(99.31,107.88) 99.31,105.96 Q8605.S ; v1(52.67,90.48) 52.67,89.89 52.3,89.51 R5531.2 ; v1(119.65,69.22) 119.65,68.89 119.17,68.4 C2213.2 118.99,68.36 C2224.2 ; C1315.2 134.97,21.41 v1(134.13,21.41) ; C1209.2 C1205.2 67.96,18.47 v1(67.74,18.24) ; C2405.2 27.06,36.38 26.92,36.53 v1(26.89,36.53) 26.64,36.27 26.61,36.27 26.51,36.17 25.72,36.17 25.09,36.81 R2436.2 ; Q8504.S 106.18,105.21 v3(106.18,104.4) ; v1(50.13,33.15) 50.84,33.86 C2426.2 ; EC1301.2 158.17,23.07 v1(158.3,23.19) ; C2429.2 v1(27.45,42.88) ; C5539.2 54.1,91.87 v1(53.36,91.14) ; v1(145.64,38.92) 145.64,38.18 Q502.S 146.41,38.1 Q501.S ; R2445.1 39.24,32.79 40.11,31.92 v1(40.15,31.92) ; PR4447.2 154.27,7.6 v1(154.65,7.98) ; v1(29.33,35.85) 29.43,35.74 C2406.2 ; v1(197.3,32.52) 197.58,32.79 C9113.2 ; v1(185.06,36.32) 184.93,36.45 C2502.2 ; 157.75,2.95 PC4420.1 157.8,4.24 PR4406.2 ; ED4001.3 208.43,49.38 v1(208.97,49.93) ; v1(206.35,8.31) 206.75,7.9 AFTP2501.1 ; PR4514.2 197.56,51.69 PC4532.2 v1(197.61,50.98) ; C806.1 117.98,79.7 v1(118.19,79.91) ; v1(198.95,51.05) 198.95,51.32 199.03,51.39 PR4508.2 PC4508.2 ; v1(181.62,71.39) 180.4,71.39 R7907.1 ; 2.58,82.93 USB1.13 1.25,82.09 ; v1(57.47,46.64) 57.34,46.51 R2426.1 ; 11.25,19.64 USB3.12 11.25,17.86 ; PR4474.1 167.79,14.46 v1(167.94,14.3) 168.52,13.72 PR4492.2 ; PC1045.2 81.12,79.02 v1(81.35,79.25) 82.21,80.11 PC1069.2 82.42,80.09 C1104.2 C1102.2 ; R7308.2 14.01,90.81 C7328.2 C7327.2 ; v1(131.97,43.49) 131.97,43.84 132.12,43.99 R1715.2 132.05,44.25 C1701.2 132.56,45.47 R1911.2 R1507.2 134.36,46.48 R1555.2 ; U4001.15 v1(213.28,47.7) ; 6.19,37.3 USB4.10 4.45,36.41 ; R9137.1 v1(210.94,35.13) ; PC4431.2 154.83,9.83 v1(154.6,9.83) ; v3(19.63,83.62) 19.85,83.84 R7407.2 ; PR4453.1 159.86,16.94 PC4439.1 158.92,17.33 v1(159.51,17.91) ; v1(95.5,11.28) 96.39,12.17 PR4465.1 ; C4001.2 211.45,49.76 v1(211.8,49.41) ; R7401.2 19.5,88.04 v1(19.48,88.06) ; R8103.2 206.62,107.09 205.45,105.92 v1(205.45,105.62) 205.4,105.57 205.01,105.57 204.75,105.82 204.04,105.82 203.68,105.46 R7910.2 203.68,103.24 Q8101.S 207.17,102.13 207.59,102.54 C8141.2 208.3,102.11 R8108.2 ; v1(169.72,49.18) R7007.1 ; R2504.2 205.86,12.91 v1(206.37,13.41) ; C2222.2 C2221.2 117.53,73.21 v1(117.72,73.4) ; v1(56.43,1.78) 56.08,1.78 55.82,2.03 PC4530.2 PC4531.2 ; C2418.2 50.87,44.15 v1(51.02,44.3) ; H17.1 10.9,79.4 ; H17.1 7.71,82.59 ; H17.1 4.52,79.4 ; C2425.1 43.43,33.66 43.57,33.8 v1(43.57,33.84) ; 11.91,32.44 USB3.13 11.25,32.44 ; C4010.2 212.64,38.38 212.64,38.27 212.68,38.24 v1(212.68,38.06) ; C6304.2 v1(216.83,23.47) ; 6.19,17.3 USB3.10 4.45,16.41 ; v1(84.69,80.52) 84.73,80.52 84.93,80.32 85.1,80.32 R808.2 ; v1(214.88,64.21) 214.85,64.24 214.85,65 214.32,65.53 C2603.2 C2605.2 214.12,66.6 213.89,66.37 C8118.2 ; R5711.2 16.3,72.98 v1(16.35,72.93) ; C7220.2 71.85,104.57 C7221.2 71.7,105.41 71.71,105.43 v1(71.71,105.51) ; v1(131.14,74.99) 131.12,75.01 130.22,75.01 129.86,75.36 R2108.2 128.72,75.31 C2210.2 128.72,74.02 R2008.2 ; v1(31.26,69.75) 31.44,69.75 31.62,69.93 31.83,69.93 32.3,70.41 R7302.1 ; PC8520.2 v1(137.13,93.78) 135.66,93.78 135.38,94.06 FC8919.2 ; 11.79,20.81 USB3.4 12.15,20.81 ; Q1802.S 145.9,47.42 145.51,47.42 145.05,46.97 R1524.2 ; R5547.2 58.82,87.68 58.41,88.09 v1(58.29,88.09) ; EC6501.2 181.5,12.3 v1(182.21,13.01) ; EC1707.2 120.52,40.72 ED1703.3 119.92,40.57 119.41,41.07 119.41,42.53 119.55,42.67 119.55,42.68 v1(119.6,42.73) ; v1(35.57,22.18) 35.57,22.18 35.86,22.18 35.88,22.2 C1219.2 ; v1(117.37,41.43) 117.22,41.43 116.55,42.09 C1710.2 116.55,42.7 Q1701.1 ; PC1030.2 109.8,69.18 v1(110.47,69.85) ; C7229.2 86.25,94.74 86.91,95.41 v1(86.91,96.4) ; v1(212.68,37.37) 212.64,37.37 212.59,37.42 212.26,37.42 212.11,37.57 C4006.2 211.88,37.54 EC8951.2 ; C7809.2 197.35,73.5 197.35,72.27 v1(197.26,72.18) ; PC4602.2 41.73,60.68 v1(41.8,60.61) ; H11.1 31.33,4.83 EC2904.2 ; v1(33.99,32.59) 34.31,32.91 C2420.2 ; v1(56.46,26.29) 55.92,26.29 C1202.2 C1203.2 C1210.2 ; v1(122.87,21.42) 122.92,21.36 C1318.2 ; R4006.2 205.89,56.49 v1(206.17,56.77) ; v1(107.61,69.83) 107.61,69.52 107.26,69.17 PC1026.2 ; C6321.2 v1(214.78,19.18) ; v1(116.1,92.05) 116.1,92.66 116.53,93.1 ED1704.3 ; v1(31.24,16.51) 30.65,16.51 C2723.2 C2720.2 ; FC8926.2 177.9,60.48 v1(178.25,60.84) ; R7915.2 179,65.09 v1(179.06,65.09) 179.38,65.09 R7929.2 ; 2.58,95.07 USB1.22 1.25,95.91 ; R2518.2 v1(207.84,20.42) ; R2455.2 41.07,29.72 v1(40.2,29.72) ; v1(23.97,43.23) 24.2,43.23 24.35,43.08 C2610.2 ; v1(133.5,51.71) R1509.2 ; v1(177.13,17.53) 176.65,17.05 AFTP6565.1 ; R5707.1 22.7,55.45 22.7,56.44 23.03,56.77 v1(23.03,56.82) ; v1(119.68,77.64) 119.68,78.41 C805.1 ; BS2.1 10.9,98.5 ; BS2.1 7.71,95.31 ; BS2.1 4.52,98.5 ; v1(215.64,7.62) 216.1,8.08 C6322.2 217.06,8.36 216.55,8.87 ED7307.2 ; C1321.2 131.54,21.38 v1(131.57,21.41) ; v1(196.82,66.14) 196.82,66.2 197,66.37 R7901.2 R7902.2 ; PC4416.1 166.75,9.73 PC4417.1 167.43,10.04 v1(167.84,9.63) ; R7340.2 20.34,75.27 H10.1 18.05,74.44 C7317.2 ; 6.19,53 USB4.11 4.45,53.89 ; PC8507.1 116.43,102.24 v1(116.55,102.36) ; R7807.2 197.25,80.85 197.25,80.14 v1(197.13,80.02) ; C4009.2 204.25,55.37 v1(204.26,55.39) ; R2101.2 R1527.2 132.46,66.2 132.94,66.68 v1(132.94,66.96) ; v1(78.41,26.26) 79.05,26.9 C1204.2 C1208.2 ; EC8937.2 v1(15.28,35.82) ; v1(80.49,17) EC8909.2 EC8908.2 C804.2 ; EC6503.2 v1(179.17,12.25) ; v1(112.11,101.83) 112.14,101.87 112.27,101.87 112.29,101.88 112.85,101.88 113.13,101.6 C8630.2 ; v1(33.37,14.68) 33.17,14.48 C2722.2 ; 11.25,52.44 USB4.13 11.91,52.44 ; EC8953.2 v1(223.36,23.62) ; C6504.2 v1(177.84,5.87) ; EC4311.2 v1(25.7,94.39) ; R2417.2 25.44,44.99 25.8,45.34 v1(25.82,45.34) ; R403.1 104.64,95.63 v1(104.85,95.43) ; C6305.2 218.99,22.89 219,22.88 v1(219.02,22.88) ; AFTP6531.1 v1(86.13,5.44) ; USB4.12 12.57,38.75 ; USB4.12 11.25,37.86 ; USB4.12 11.25,39.64 ; C2608.2 164.44,103.91 C2609.2 164.41,104.19 v1(164.13,104.47) ; Q4302.E v1(31.37,95.38)
  L3 w0.102: v1(137.05,80.62) 136.72,80.95 135.33,80.95 v1(135.22,80.85) 135.22,80.39 135.66,79.96 136.85,79.96 137.05,80.17 v1(137.05,80.62)
  L3 w0.508: 6.19,17.3 USB3.10 4.45,16.41 ; 5.91,84.76 USB1.B12 5.28,85.8 ; H17.1 9.4,79.4 ; H17.1 7.71,77.71 ; H17.1 6.02,79.4 ; H17.1 7.71,81.09 ; 4.45,53.89 USB4.11 6.19,53 ; 7.71,96.68 BS2.1 ; BS2.1 9.53,98.5 ; BS2.1 5.89,98.5 ; BS2.1 7.71,100.32 ; HDMI1.22 11.59,60.35 ; HDMI1.22 10.26,59.36 ; HDMI1.22 10.26,61.34 ; 4.45,33.89 USB3.11 6.19,33 ; 7.45,83.74 USB1.15 6.36,84.53 ; 11.25,52.44 USB4.13 11.91,52.44 ; 5.28,92.2 USB1.B1 5.91,93.24 ; USB3.12 11.25,19.64 ; USB3.12 11.25,17.86 ; USB3.12 12.57,18.75 ; 2.81,57.46 HDMI1.20 ; HDMI1.20 4.14,58.45 ; HDMI1.20 1.48,58.45 ; 11.25,39.64 USB4.12 11.25,37.86 ; USB1.20 7.45,94.26 ; USB1.20 6.36,93.48 ; USB1.20 8.54,93.48 ; 10.86,63.02 HDMI1.2 11.44,63.6 ; 4.45,36.41 USB4.10 6.19,37.3 ; 11.25,32.44 USB3.13 12.57,32.44 ; 10.26,75.84 HDMI1.23 10.26,73.86 ; 12.79,21.01 USB3.4 12.15,20.81 ; 2.58,95.07 USB1.22 1.25,95.91 ; 1.25,82.09 USB1.13 2.58,82.93 ; 12.15,40.81 USB4.4 11.79,40.81 ; USB1.14 6.45,82.93 ; USB1.14 3.78,82.93 ; USB1.14 5.12,82.09 ; HDMI1.21 2.81,77.74 ; HDMI1.21 1.48,76.75 ; HDMI1.21 4.14,76.75 ; 3.78,95.07 USB1.21 ; USB1.21 6.45,95.07 ; USB1.21 5.12,95.91
  L4 w0.102: 137.05,80.34 v1(137.05,80.62) 136.72,80.95 135.33,80.95 v1(135.22,80.85) 135.22,80.24 135.48,79.99 136.7,79.99 137.05,80.34 ; 131.24,84.69 131.11,84.56 129.53,84.56 129.25,84.84 129.25,85.17 129.58,85.5 131.13,85.5 131.24,85.4 v1(131.24,84.99) 131.24,84.69
  L4 w0.508: USB1.21 6.45,95.07 ; USB1.21 3.78,95.07 ; USB1.21 5.12,95.91 ; 7.45,83.74 USB1.15 ; USB1.15 6.36,84.53 ; USB1.15 8.54,84.53 ; 1.25,95.91 USB1.22 2.58,95.07 ; 6.36,93.48 USB1.20 ; USB1.20 7.45,94.26 ; USB1.20 8.54,93.48 ; 4.45,33.89 USB3.11 6.19,33 ; USB3.12 11.25,19.64 ; USB3.12 12.57,18.75 ; USB3.12 11.25,17.86 ; 5.91,84.76 USB1.B12 5.28,85.8 ; 6.19,37.3 USB4.10 4.45,36.41 ; 12.15,40.81 USB4.4 12.99,41.65 ; 12.15,20.81 USB3.4 12.79,21.01 ; USB4.12 11.25,39.64 ; USB4.12 12.57,38.75 ; USB4.12 11.25,37.86 ; HDMI1.21 2.81,77.74 ; HDMI1.21 4.14,76.75 ; HDMI1.21 1.48,76.75 ; 12.57,32.44 USB3.13 11.25,32.44 ; H17.1 9.4,79.4 ; H17.1 6.02,79.4 ; H17.1 7.71,77.71 ; H17.1 7.71,81.09 ; 11.91,52.44 USB4.13 11.25,52.44 ; BS2.1 9.53,98.5 ; BS2.1 7.71,96.68 ; BS2.1 5.89,98.5 ; BS2.1 7.71,100.32 ; HDMI1.20 4.14,58.45 ; HDMI1.20 2.81,57.46 ; HDMI1.20 1.48,58.45 ; 1.25,82.09 USB1.13 2.58,82.93 ; 10.93,75.84 HDMI1.23 10.26,75.84 ; 5.91,93.24 USB1.B1 5.28,92.2 ; 6.19,17.3 USB3.10 4.45,16.41 ; 4.45,53.89 USB4.11 6.19,53 ; 10.26,61.34 HDMI1.22 10.26,59.36 ; 10.86,63.02 HDMI1.2 10.4,63.14 ; 5.12,82.09 USB1.14 ; USB1.14 3.78,82.93 ; USB1.14 6.45,82.93
  L6 w0.102: 133.32,84.64 131.59,84.64 v1(131.24,84.99) 131.24,85.4 130.96,85.68 129.81,85.68 129.36,85.22 129.36,84.81 130.11,84.06 132.57,84.06 135.22,81.41 v1(135.22,80.85) 135.22,80.42 135.63,80.01 136.6,80.01 137.05,80.47 v1(137.05,80.62) 137.05,80.9 133.32,84.64
  L6 w0.508: 6.36,84.53 USB1.15 7.45,83.74 ; H17.1 9.4,79.4 ; H17.1 7.71,81.09 ; H17.1 6.02,79.4 ; H17.1 7.71,77.71 ; 12.79,41.01 USB4.4 12.15,40.81 ; USB1.21 6.45,95.07 ; USB1.21 5.12,95.91 ; USB1.21 3.78,95.07 ; 5.12,82.09 USB1.14 ; USB1.14 6.45,82.93 ; USB1.14 3.78,82.93 ; 11.25,17.86 USB3.12 ; USB3.12 11.25,19.64 ; USB3.12 12.57,18.75 ; 12.15,20.81 USB3.4 12.79,21.01 ; USB4.12 12.57,38.75 ; USB4.12 11.25,37.86 ; USB4.12 11.25,39.64 ; 5.91,93.24 USB1.B1 5.28,92.2 ; HDMI1.21 2.81,77.74 ; HDMI1.21 1.48,76.75 ; HDMI1.21 4.14,76.75 ; 1.25,95.91 USB1.22 2.58,95.07 ; 10.26,59.36 HDMI1.22 10.26,61.34 ; USB3.13 11.25,32.44 ; USB3.13 12.57,31.55 ; USB3.13 11.25,30.66 ; 10.26,73.86 HDMI1.23 10.26,75.84 ; HDMI1.20 4.14,58.45 ; HDMI1.20 2.81,57.46 ; HDMI1.20 1.48,58.45 ; 4.45,33.89 USB3.11 6.19,33 ; 11.25,50.66 USB4.13 11.25,52.44 ; 6.19,17.3 USB3.10 4.45,16.41 ; 6.19,53 USB4.11 4.45,53.89 ; 6.36,93.48 USB1.20 7.45,94.26 ; 2.58,82.93 USB1.13 1.25,82.09 ; 4.45,36.41 USB4.10 6.19,37.3 ; 5.28,85.8 USB1.B12 5.91,84.76
  BOTTOM w0.076: CPU1.B23 84.99,70.42 84.6,70.47 84.4,70.47 84.36,70.47 84.28,70.48 83.51,70.48 83.46,70.53 83.28,70.63 ; v1(95.97,58.63) 95.97,58.66 96.27,59.16 96.72,59.64 96.72,59.65 97.54,60.47 CPU1.AB36 ; v1(92.16,55.05) 93.05,55.94 93.05,58.52 95.02,60.49 CPU1.V36 ; v1(112.85,60.17) 112.84,60.17 112.64,60.36 CPU1.BF36 ; 118.94,62.05 118.93,62.05 118.93,61.04 v1(118.76,60.87) ; CPU1.CP11 130.56,77.99 130.7,77.85 130.78,77.85 v1(130.78,77.86) ; CPU1.BB36 110.09,61.93 v1(110.09,59.92) ; CPU1.AD35 v1(98.8,63.31) CPU1.AD33 ; v1(83.05,63.45) 83.05,63.8 83.33,64.09 84.35,64.09 84.86,64.6 85.17,64.6 CPU1.A32 ; v1(86.95,57.97) 87.14,57.97 87.31,58.14 87.5,58.14 87.73,58.37 87.73,58.56 89.99,60.81 CPU1.J36 ; CPU1.B25 84.76,69.16 84.68,69.15 v1(84.64,69.1) ; CPU1.P36 92.51,60.47 90.43,58.39 90.43,58.1 v1(90.42,58.1) ; v1(83.73,67.93) 83.79,67.87 85.59,67.87 CPU1.B27 ; CPU1.AH35 101.32,63.09 v1(101.45,63.22) 101.32,63.36 CPU1.AH33 ; CPU1.B31 84.74,65.38 84.64,65.34 84.27,64.97 v1(83.91,64.97) ; v1(93.77,61.04) CPU1.T35 v1(93.77,63.31) CPU1.T33 ; v1(91.25,61) CPU1.L35 v1(91.25,63.31) CPU1.L33 ; CPU1.AF36 100.06,60.54 99.99,60.47 99.99,60.25 99.38,59.64 99.38,59.17 98.71,58.5 v1(98.71,58.42) ; 111.39,62.05 v1(111.39,61.01) ; CPU1.Y33 v1(96.28,63.31) CPU1.Y35
  BOTTOM w0.083: v1(121.52,60.91) 121.52,60.92 121.45,60.99 121.45,62.05 ; 123.97,62.05 v1(123.97,60.99)
  BOTTOM w0.089: CPU1.Y30 97.04,66.3 v1(97.14,66.3) ; v1(110.84,81.14) CPU1.BD6
  BOTTOM w0.102: 87.34,62.23 87.5,62.39 ; v1(105.06,60.08) 105.07,60.09 105.07,61.74 105.06,61.78 105.06,61.93 CPU1.AP36 ; v1(142.18,78.82) 142.18,79.86 141.93,80.11 139.34,80.11 v1(139.03,79.81) 137.74,81.1 135.48,81.1 v1(135.22,80.85) ; 126.87,83.09 127.25,83.09 127.48,83.31 127.48,83.65 CPU1.CL2
  BOTTOM w0.114: CPU1.AV36 107.61,60.27 107.65,60.23 v1(107.65,60.15) ; v1(106.35,61.04) 106.35,62.05 ; v1(102.59,60.06) 102.59,60.37 102.58,60.38 102.58,61.54 CPU1.AK36
  BOTTOM w0.127: DM1.192 81.64,21.6 82.85,22.81 v1(82.92,22.81) ; C1807.1 137.08,77.83 136.93,77.98 135.71,77.98 134.87,78.82 134.87,80.5 v1(135.22,80.85) ; v1(138.35,77.96) 138.81,77.5 141.75,77.5 142.18,77.93 v1(142.18,78.82) ; CPU1.AB30 97.21,66.3 v1(97.14,66.3) ; CPU1.CP27 130.03,67.91 130.12,67.82 v1(130.13,67.82) ; v1(188.61,96.07) 188.61,95.91 187.71,95.01 GPU1.Y26 ; 192.28,89.18 192.25,89.21 v1(191.73,89.21) ; GPU1.Y23 185.89,92.72 v1(185.9,92.71) ; DM1.168 75.63,21.22 75.6,21.25 75.6,21.42 75.38,21.64 75.38,22.86 75.86,23.34 v1(76.05,23.34) ; v1(194.58,87.43) GPU1.H25 ; v1(77.98,23.08) 77.4,22.5 77.4,21.02 77.63,20.78 DM1.176 ; v1(172.01,89.54) 172.03,89.54 173.57,87.99 GPU1.AF8 ; v1(192.34,86.29) 192.9,86.29 GPU1.H23 ; GPU1.U26 190.12,94.04 v1(190.35,94.04) ; DM1.217 87.89,24.53 v1(88.61,23.8) ; DM1.214 87.13,21.11 87.24,21.21 87.24,22.38 v1(86.61,23.02) ; CPU1.AF30 100.11,65.93 v1(99.86,65.68) ; v1(191.84,92.41) 191.09,91.66 GPU1.P26 ; DM1.172 76.63,21.53 76.1,22.07 v1(76.05,22.07) ; GPU1.B11 189.15,75.93 189.15,76.49 v1(188.77,76.87) ; GPU1.U23 187.05,91.56 v1(187.01,91.52) ; v1(88.14,23.08) 87.83,22.77 87.83,21.26 88.13,20.95 DM1.218 ; v1(117.22,60.3) 117.49,60.58 117.49,61.78 CPU1.BP36 ; CPU1.AF33 99.6,63.91 99.46,64.05 98.94,64.05 CPU1.AD33 ; v1(185.29,94.49) GPU1.AB24 ; v1(93.49,23.65) 93.49,23.09 93.13,22.74 DM1.238 ; GPU1.L23 191.15,87.51 v1(191.11,87.48) ; GPU1.AC26 186.58,97.53 186.58,97.74 v1(186.72,97.88) ; v1(80,24.08) 79.42,24.66 79.42,26.17 79.89,26.64 DM1.185 ; 82.03,24.63 82.03,24.72 82.52,25.21 ; v1(195.54,79.85) 195.54,79.9 194.6,80.84 194.6,81.01 ; v1(82.94,70.88) 83.28,70.63
  BOTTOM w0.152: v1(54.93,86.29) 54.93,86.69 55.19,86.95 55.19,87.4 EC5505.8 ; v1(88.02,67.57) 87.57,67.12 CPU1.E29 ; v1(8.22,85.32) 8.22,85.32 USB1.16 7.74,86.03 7.49,86.29 7.03,86.29 USB1.A1 ; VRAM4.K14 209.66,99.97 209.65,99.95 209.65,99.41 VRAM4.K13 ; v1(131.98,63.2) 131.98,63.2 131.53,62.74 130.47,62.74 130.22,62.99 130.22,63.1 CPU1.CR34 ; CPU1.BK4 CPU1.BK3 CPU1.BK2 ; 82.52,25.21 82.52,26.58 82.89,26.95 DM1.197 ; CPU1.BP3 CPU1.BP4 ; v1(84.67,66.59) 85.67,66.59 CPU1.B29 CPU1.C29 CPU1.E29 ; CPU1.E29 CPU1.E31 ; v1(88.01,60.69) 88.56,61.25 88.56,61.89 88.73,62.05 CPU1.G35 87.88,62.7 CPU1.E35 ; PU5101.4 54.25,13.08 53.56,13.78 v1(53.43,13.78) ; CPU1.BV4 CPU1.BV3 ; v1(174.11,85.72) 174.13,85.72 174.71,86.3 GPU1.AC8 ; CPU1.E33 87.52,64.12 CPU1.C33 86.36,63.89 CPU1.B34 ; CPU1.BF33 113.44,63.91 113.47,63.88 113.88,63.88 CPU1.BH33 ; v1(126.46,86.11) 126.41,86.06 126.03,86.06 124.71,84.74 124.71,83.95 CPU1.CF2 CPU1.CF3 ; v1(125.37,67.52) 125.4,67.55 126.43,67.55 CPU1.CJ28 ; CPU1.AB33 CPU1.AD33 ; CPU1.BV33 CPU1.BY33 ; CPU1.CD20 CPU1.CC20 ; CPU1.AP33 CPU1.AM33 ; CPU1.V33 CPU1.Y33 ; CPU1.CB2 CPU1.CB3 CPU1.CB4 ; CPU1.R31 CPU1.R30
  BOTTOM w0.178: v1(8.35,87.64) 8.1,87.64 USB1.17
  BOTTOM w0.2: CPU1.P3 92.97,82.93 v1(92.82,82.78) 92.82,82.42 CPU1.P4 ; CPU1.BE29 112.26,66.53 v1(112.62,66.32) ; CPU1.AL7 v1(102.53,80.5) ; CPU1.BG28 v1(112.62,66.95) 112.26,67.17 CPU1.BE28 ; CPU1.AM5 103.52,81.75 103.46,81.81 v1(103.45,81.81) ; CPU1.AW29 v1(108.98,66.32) ; CPU1.AU28 v1(107.15,66.95) ; CPU1.AC30 v1(98.04,65.68) ; CPU1.AV6 107.25,81.09 v1(107.15,81.14) ; CPU1.BA28 v1(109.89,66.95) ; CPU1.CJ35 126.49,62.05 ; v1(106.24,66.99) 106.2,66.98 CPU1.AR28 ; CPU1.BH32 114.41,64.39 v1(114.45,64.39) ; CPU1.AM28 v1(104.42,66.95) ; CPU1.AC27 v1(98.04,67.59) ; CPU1.K4 90.66,82.41 v1(90.66,82.78) 90.66,83.15 CPU1.K3 ; CPU1.AL28 v1(103.51,66.95) ; CPU1.U7 v1(94.21,80.5) ; v1(125.37,67.52) 125.21,67.52 CPU1.CF28 ; CPU1.V3 CPU1.V4 ; CPU1.AU29 v1(107.15,66.32) ; CPU1.AB3 97.85,82.78 ; v1(95.14,79.87) CPU1.W7 ; CPU1.BD28 v1(111.71,66.95) ; CPU1.AV28 v1(108.07,66.95) ; v1(113.9,63.31) CPU1.BH33 ; CPU1.AE30 v1(99.86,65.68) ; CPU1.BH29 v1(114.45,66.32) ; CPU1.AW28 v1(108.98,66.95) ; v1(110.8,66.32) CPU1.BC29
  BOTTOM w0.203: 130.32,84.46 130.7,84.46 v1(131.24,84.99) 131.24,85.27 131.03,85.47 129.76,85.47 ; CPU1.CP15 129.73,75.34 129.84,75.34 129.95,75.33 130.18,75.33 130.34,75.17 130.96,75.17 v1(131.14,74.99) ; USB1.19 8.2,92.2 v1(8.5,91.9) 8.3,91.7 7.04,91.7 USB1.A12 ; 129.76,85.47 129.76,85.88 129.46,86.18 129.46,87.86 129.81,88.22 R1803.2 ; 129.76,85.47 128.54,85.47 128.11,85.04 127.86,85.04 127.17,84.36 CPU1.CK1 ; v1(186.66,62.79) 187.32,62.13 187.32,61.27 186.33,60.28 182.52,60.28 182.32,60.48 v1(182.32,60.79) ; CPU1.BC8 110.38,79.63 110.18,79.84 v1(109.92,79.84) ; CPU1.BY18 121.3,73.76 121,73.47 121,73.46 v1(120.98,73.43) ; v1(117.72,74.27) 117.73,74.28 117.73,74.37 CPU1.BR16 ; CPU1.V4 95.41,82.11 95.14,81.84 v1(95.14,81.81) ; CPU1.CB7 122.14,80.02 122.01,80.02 v1(121.93,79.94) ; v1(116.95,71.71) 116.99,71.67 116.99,71.25 117.25,70.98 117.61,70.98 117.95,71.32 CPU1.BR22 ; CPU1.CM13 CPU1.CN13 CPU1.CP13 129.92,76.73 130.31,76.56 130.86,76.3 v1(131.03,76.3) ; v1(127.34,66.32) 127.32,66.31 127.32,66.09 128,65.42 CPU1.CM31 ; v1(115.44,81.82) 115.42,81.84 115.41,81.84 114.98,82.28 CPU1.BK4 ; CPU1.CP9 CPU1.CN9 ; CPU1.R31 92.51,64.76 CPU1.P33 ; PU5101.32 53.97,15.04 54.27,15.34 54.78,15.34 54.99,15.14 56.64,15.14 PC5113.2 ; CPU1.BY22 121.3,71.24 120.98,70.92 120.98,70.92 v1(120.96,70.9) ; CPU1.BJ7 114.08,80.28 113.87,80.49 v1(113.61,80.49) ; CPU1.CB33 122.22,63.91 122.2,63.93 121.92,63.93 121.85,63.86 121.5,63.86 CPU1.BY33 ; v1(119.68,77.64) 119.68,77.73 CPU1.BV11 ; CPU1.CK7 126.75,80.53 v1(126.53,80.53) ; v1(119.03,71.76) 119.35,72.07 CPU1.BU20 ; U8601.11 v1(175.18,100.03) ; CPU1.CN17 CPU1.CM17 127.48,73.72 127.23,73.72 CPU1.CJ19 ; CPU1.CC7 123.31,80.28 123.11,80.49 v1(122.85,80.49) ; CPU1.BW7 120.83,79.98 v1(120.97,79.98) ; v1(172.96,85.72) 172.94,85.72 172.45,86.21 171.84,86.21 GPU1.AF5 ; v1(116.22,61.27) 116.16,61.33 116.16,61.79 116.42,62.05 ; v1(53.43,13.78) 53.17,14.04 PU5101.30 ; v1(111.77,79.84) 112.03,79.84 112.23,79.63 CPU1.BE8 ; CPU1.BK7 115,80.28 114.8,80.49 v1(114.54,80.49) ; v1(9.06,89.77) 8.68,90.15 7.88,90.15 7.74,90 USB1.18 ; Q4349.4 32.09,79.72 31.52,79.15 31.52,78.79 31.14,78.42 Q4349.1 ; CPU1.CJ11 126.67,78.16 v1(126.95,77.88) ; CPU1.CB19 122.6,72.92 122.3,72.63 122.3,72.62 v1(122.27,72.59) ; CPU1.CC14 122.93,76.05 122.93,75.97 v1(122.93,75.97) ; v1(119.03,74.28) 119.05,74.3 119.05,74.31 119.35,74.6 CPU1.BU16 ; v1(110.84,80.49) 111.1,80.49 111.31,80.28 CPU1.BD7 ; v1(119.03,77.64) 119.03,77.73 CPU1.BU11 ; CPU1.CA22 121.95,71.24 121.63,70.92 121.63,70.92 v1(121.61,70.9) ; v1(118.36,74.27) 118.36,74.35 CPU1.BT16 ; CPU1.BY19 121.3,72.92 121,72.63 121,72.62 120.99,72.61 120.99,72.59 v1(120.97,72.57) ; CPU1.BL32 115.87,64.57 115.97,64.57 116.42,64.12 CPU1.BM33 ; v1(104.38,80.49) 104.64,80.49 104.84,80.28 CPU1.AN7 ; CPU1.CP19 v1(130.32,72.95) ; CPU1.AV8 107.61,79.63 107.41,79.84 v1(107.15,79.84) ; CPU1.BU7 119.87,80.52 120.06,80.52 v1(120.07,80.51) ; CPU1.K30 CPU1.K31 ; 97.85,82.78 CPU1.AB4 ; v1(121.63,77.64) 121.63,77.73 CPU1.CA11 ; v1(179.95,90.35) 179.93,90.35 179.38,89.8 GPU1.AB14
  BOTTOM w0.254: v1(206.07,96.57) 206.07,96.61 VRAM4.P10 ; CPU1.AJ7 102.3,80.27 v1(102.53,80.5) ; C5540.2 53.31,86.57 v1(53.66,86.21) ; 121.45,62.05 CPU1.BY35 v1(121.45,63.31) CPU1.BY33 ; VRAM1.B10 204.88,72 v1(205.26,71.62) 205.66,71.22 VRAM1.C11 205.29,70.83 v1(205.26,70.83) 205.66,70.43 VRAM1.C12 ; ED3502.2 17.8,40.69 17.48,41.01 v1(17.48,41.17) ; v1(121.74,66.95) 121.61,67.08 121.54,67.08 121.4,67.23 CPU1.BY28 ; CPU1.CJ19 126.67,73.14 126.34,72.81 v1(126.34,72.71) ; v1(205.91,72.57) 206.46,72.02 VRAM1.D10 ; v1(216.46,93.46) 216.46,93.4 VRAM4.B5 ; CPU1.BT28 119.04,67.73 119.04,68.48 ; CPU1.BP32 117.68,64.59 117.68,64.58 CPU1.BP33 ; VRAM1.U12 216.88,70.4 v1(217.29,70.82) ; VRAM1.U14 216.86,68.29 v1(216.8,68.23) ; v1(205.65,89.24) 205.65,89.79 VRAM4.R1 ; VRAM1.N14 v1(213.66,67.85) ; VRAM1.M5 212.86,75.83 v1(213.2,75.49) ; VRAM4.U3 203.66,91.8 v1(203.44,91.8) ; CPU1.CN25 CPU1.CM25 127.61,69.53 v1(127.34,69.53) 127.2,69.53 CPU1.CJ23 ; VRAM4.B10 215.67,97.39 v1(215.67,97.41) ; CPU1.BK28 v1(114.45,66.95) CPU1.BH28 ; VRAM4.N3 206.86,91.8 v1(206.86,91.8) ; VRAM4.G5 212.06,93.25 212.31,93.5 v1(212.31,93.86) ; v1(213.26,71.62) 212.88,72 VRAM1.M10 ; v1(204.33,89.23) 204.33,89.53 VRAM4.U1 ; v1(192.87,82.13) 192.87,82.67 GPU1.E20 ; v1(213.26,92.6) 213.26,92.6 VRAM4.F5 ; v1(124.35,75.8) 124.35,75.91 CPU1.CF14 ; CPU1.BH35 v1(113.9,63.31) ; CPU1.CP35 129.44,62.91 CPU1.CR34 ; v1(205.25,91.82) 205.25,91.81 VRAM4.R3 ; CPU1.CM33 127.88,64.21 127.27,64.21 127.25,64.19 126.72,64.19 CPU1.CJ33 ; VRAM1.T5 216.06,76.04 v1(215.67,76.43) ; v1(187.07,77.42) 187.09,77.44 GPU1.E11 ; CPU1.CA15 121.89,75.47 121.35,75.47 CPU1.BY15 120.97,75.2 120.97,75.14 ; v1(217.37,77.31) 217.07,77.6 VRAM1.U3 ; v1(88.23,69.35) 87.89,69.68 CPU1.F24 87.57,70.09 CPU1.E23 ; CPU1.BP15 117.16,75.29 v1(116.63,75.29) ; v1(88.17,84.89) 88.17,84.76 88.08,84.68 CPU1.F2 CPU1.F3 88.08,82.73 CPU1.F4 ; v1(213.45,96.43) 213.43,96.43 VRAM4.F10 ; v1(193.46,83.93) 194,83.93 GPU1.E22 ; v1(104.54,69.83) 104.54,69.67 104.88,69.34 CPU1.AN25 ; VRAM4.R14 205.12,100.74 v1(205.08,100.74) ; v1(213.6,100.77) 213.6,100.26 VRAM4.E14 ; CPU1.CC11 CPU1.CB11 122.27,77.72 v1(122.27,77.64) ; CPU1.BT33 v1(118.94,63.31) CPU1.BT35 118.94,62.05 ; VRAM1.C4 205.66,76.81 v1(206.07,77.22) 205.68,77.6 VRAM1.C3 ; GPU1.E17 190.6,80.95 v1(190.56,80.99) ; VRAM4.G10 212.06,96.46 v1(212.21,96.31) ; VRAM4.M10 208.06,96.9 v1(207.68,96.52) ; CPU1.AB27 97.75,67.88 v1(98.04,67.59) ; PC4631.2 47.11,74.86 v1(46.83,75.14) ; VRAM1.U1 216.86,79.63 v1(216.73,79.76) ; 106.35,62.05 CPU1.AT35 v1(106.35,63.31) CPU1.AT33 106.35,64.34 106.64,64.63 CPU1.AU32 107.42,63.91 CPU1.AV33 ; CPU1.BN7 116.39,79.81 CPU1.BM9 ; v1(109.47,99.57) 109.94,100.04 U8502.3 ; v1(120.83,65.05) 120.6,65.05 CPU1.BV31 ; CPU1.AN29 v1(105.33,66.32) ; v1(214.32,72.65) 214.46,72.51 VRAM1.P10 214.49,72 v1(214.86,71.62) 215.26,71.23 VRAM1.R11 215.33,71.13 215.33,70.47 VRAM1.R12 ; VRAM1.A3 204.07,77.6 v1(204.46,77.21) ; GPU1.B14 191.09,76.94 v1(191.09,76.94) ; CPU1.BV4 119.77,82.28 119.06,81.57 CPU1.BT5 118.42,81.84 v1(118.22,81.84) 118.12,81.94 117.71,81.94 CPU1.BP4 ; CPU1.AW30 v1(108.98,65.68) CPU1.AW31 ; CPU1.CG7 125.16,80.33 124.7,80.8 ; v1(205.17,79.76) 205.17,79.69 VRAM1.C1 ; VRAM1.L5 212.06,75.84 v1(212.36,75.54) ; CPU1.N6 92.56,80.27 CPU1.P7 ; v1(204.75,96.47) 204.75,96.88 VRAM4.T10 ; v1(205.25,92.57) 205.62,92.2 VRAM4.R4 ; CPU1.CK37 126.56,62.05 126.49,62.05 ; VRAM1.R14 215.26,68.41 v1(215.49,68.18) ; VRAM4.H1 v1(211.66,90.2) 211.26,90.6 VRAM4.H2 ; CPU1.CC28 123.2,67.23 123.35,67.08 123.36,67.08 v1(123.51,66.93) ; v1(207.66,98.2) 207.66,98.2 VRAM4.N12 ; v1(205.63,68.2) 205.66,68.23 VRAM1.C14 ; v1(204.44,93.47) 204.44,93.35 204.78,93 VRAM4.T5 ; VRAM1.N12 213.67,70.4 v1(214.08,70.81) ; GPU1.B27 198.91,85.32 v1(198.91,85.58) ; v1(208.48,75.49) 208.86,75.87 VRAM1.G5 ; VRAM1.K2 211.26,78.43 v1(211.66,78.83) ; VRAM1.E3 207.28,77.6 v1(207.66,77.22) ; U4007.3 164.45,74.22 167.56,74.22 167.71,74.37 v1(168.19,74.37) ; CPU1.BB33 110.1,63.88 109.71,63.88 109.63,63.96 108.92,63.96 CPU1.AY33 v1(108.87,63.31) CPU1.AY35 ; VRAM4.C4 215.64,91.82 v1(215.66,91.82) 215.66,91.8 VRAM4.C3 ; v1(209.11,68.2) 209.66,68.75 VRAM1.H14 209.57,68.89 209.57,69.51 VRAM1.H13 ; CPU1.CH31 125.84,65.36 126.09,65.61 v1(126.31,65.61) ; v1(214.09,96.51) 214.46,96.89 VRAM4.D10 ; CPU1.AF3 CPU1.AF4 100.44,82.28 CPU1.AG5 ; CPU1.C1 86.21,84.26 CPU1.B2 ; CPU1.C1 v1(86.21,84.89) ; CPU1.C1 CPU1.D1 ; CPU1.BM35 116.42,62.05 ; CPU1.BD35 111.39,63.21 v1(111.38,63.22) 111.39,63.22 CPU1.BD33 111.06,63.91 CPU1.BC32 ; VRAM4.C1 215.26,89.35 v1(215.41,89.19) ; CPU1.BE31 112.17,65.36 112.47,65.66 112.59,65.66 ; VRAM4.K1 v1(209.26,90.2) 209.66,90.59 VRAM4.K2 ; v1(193.22,78.8) 193.21,78.81 193.21,78.89 GPU1.B17 ; v1(210.07,78.01) 209.68,78.4 VRAM1.H2 209.66,78.56 209.72,78.62 209.72,79.14 VRAM1.H1 ; VRAM1.K1 211.26,80.12 v1(211.29,80.15) ; VRAM4.A1 v1(216.46,90.2) ; CPU1.AW1 108.27,84.65 107.67,85.25 v1(107.6,85.25) ; PC4620.2 49.47,68.07 v1(49.7,68.3) ; C7223.1 75.19,98.52 v1(75.53,98.52) ; v1(207.69,75.49) 208.06,75.86 VRAM1.F5 ; VRAM4.A14 217.01,100.35 217.01,100.64 217.46,101.08 v1(217.46,101.12) ; CPU1.BT15 118.41,75.81 118.41,75.94 v1(118.4,75.95) 118.4,76.07 CPU1.BT14 ; 124.7,80.8 CPU1.CF4 ; 124.7,80.8 124.7,80.72 CPU1.CE7 124.11,80.27 123.93,80.45 123.49,80.45 CPU1.CC7 ; CPU1.AE7 99.57,80.55 v1(99.79,80.55) 99.94,80.55 CPU1.AF7 ; CPU1.CM21 CPU1.CN21 CPU1.CP21 130.13,71.69 131.21,72.77 v1(131.21,72.85) ; CPU1.BL29 116.07,66.32 v1(116.27,66.32) 115.88,65.93 CPU1.BL30 ; VRAM1.L10 212.06,72.56 v1(212.03,72.59) ; CPU1.CC20 123.17,72.24 122.67,72.24 CPU1.CB20 122.6,72.07 122.29,71.77 v1(122.28,71.76) ; CPU1.AM35 103.84,62.93 v1(103.84,63.32) CPU1.AM33 ; VRAM1.N3 213.68,77.6 v1(214.05,77.23) ; v1(198.66,83.34) 198.66,83.93 GPU1.A26 ; VRAM4.L10 208.86,96.98 v1(208.4,96.52) ; VRAM1.T10 216.06,72.41 v1(215.87,72.59) ; CPU1.CE33 v1(123.97,63.31) CPU1.CE35 123.97,62.05 ; CPU1.BE30 112.31,65.93 112.43,65.81 112.44,65.81 112.59,65.66 ; v1(213.53,88.56) 213.66,88.68 VRAM4.E1 ; CPU1.AN28 104.6,66.95 v1(104.42,66.95) ; v1(203.66,100.66) 203.66,100.6 VRAM4.U14 ; v1(203.63,70.87) 204.06,70.44 VRAM1.A12 ; VRAM4.H14 211.66,99.8 v1(211.66,99.8) 211.26,99.4 VRAM4.H13 ; v1(33.88,67.08) 34.46,67.08 PC4622.2 34.74,67.36 PR4639.2 ; VRAM1.E1 206.83,79.63 v1(206.83,79.76) ; v1(116.27,66.95) 116.09,66.95 CPU1.BL28 ; VRAM4.N1 v1(207.26,89.27) ; CPU1.AN30 v1(105.33,65.68) CPU1.AN31 ; VRAM1.N1 213.66,79.77 v1(213.65,79.78) ; v1(215.24,100.84) 215.26,100.82 VRAM4.C14 ; VRAM4.A3 v1(217.42,91.4) ; v1(107.61,69.83) CPU1.AV25 ; GPU1.E14 189.35,79.24 v1(188.78,79.24) ; CPU1.BG25 113.08,69.5 112.82,69.75 v1(112.82,69.75) ; CPU1.AN8 104.88,79.66 104.88,80.22 CPU1.AN7 ; v1(215.27,79.83) 215.26,79.83 VRAM1.R1 ; v1(206.99,67.46) 207.26,67.73 VRAM1.E14 ; v1(217.42,98.78) 217.24,98.6 VRAM4.A12 ; CPU1.N25 v1(92.12,69.55) ; v1(102.69,78.24) 102.73,78.29 103.5,78.29 CPU1.AM10 ; v1(114.45,64.39) 114.46,64.39 114.46,64.35 114.9,63.91 CPU1.BK33 ; v1(118.19,79.91) 118.13,79.91 CPU1.BP7 ; CPU1.B25 CPU1.C25 CPU1.D25 ; CPU1.G27 88.33,67.88 v1(88.02,67.57) 87.68,67.9 CPU1.E27 ; VRAM1.A1 204.04,79.2 v1(203.56,79.68) ; v1(203.58,68.32) VRAM1.A14 ; 112.59,65.66 v1(112.61,65.66) ; VRAM4.N14 207.26,100.26 v1(206.75,100.77) ; CPU1.BL32 115.85,64.67 115.85,65.24 CPU1.BL31 116.07,65.28 CPU1.BN30 ; VRAM1.K13 211.24,69.6 v1(210.86,69.22) 211.26,68.82 VRAM1.K14 ; v1(204.84,75.43) 204.84,75.98 VRAM1.B5 ; v1(121.19,82) 121.19,81.85 CPU1.BY5 121.78,81.88 121.86,81.88 CPU1.CB4 ; VRAM4.U12 204.46,98.2 v1(204.46,98.18) ; VRAM4.E3 213.66,91.4 v1(213.26,91.8) ; VRAM4.C12 215.36,98.5 215.36,98.47 v1(215.66,98.18) 215.64,98.18 VRAM4.C11 ; v1(124.43,73.66) 124.48,73.61 124.48,73.41 CPU1.CF19 ; CPU1.AK33 102.63,63.96 103.12,63.96 v1(103.3,64.14) 103.05,64.38 CPU1.AL32 ; GPU1.E25 v1(196.34,85.67) ; VRAM4.E12 213.29,98.23 v1(213.29,98.2) ; VRAM1.R4 215.26,76.8 v1(215.66,77.2) 215.26,77.59 VRAM1.R3 ; v1(206.86,70.82) 207.26,70.42 VRAM1.E12 ; v1(110.47,69.85) 110.34,69.73 CPU1.BC25 ; CPU1.J33 89.99,64.33 90.29,64.63 CPU1.K32 CPU1.K31 ; CPU1.BR19 117.73,73.32 117.73,73.39 v1(117.72,73.4) 117.72,73.33 CPU1.BP19 ; v1(126.83,76.79) 126.67,76.63 CPU1.CJ14 ; CPU1.CC16 122.93,74.37 122.93,74.18 CPU1.CB18 CPU1.CB19 ; GPU1.B23 196.65,82.77 196.82,82.6 v1(196.89,82.6) ; CPU1.AL29 v1(103.51,66.32) ; VRAM4.R11 205.69,97.8 206.07,98.17 v1(206.07,98.2) 205.66,98.6 VRAM4.R12 ; CPU1.AK3 102.59,83.15 102.59,82.76 102.6,82.76 102.6,82.41 CPU1.AK4 103.06,81.94 103.32,81.94 v1(103.45,81.81) ; CPU1.CN9 CPU1.CM9 ; VRAM4.L5 208.86,93.17 208.5,93.53 v1(208.47,93.53) 208.06,93.12 VRAM4.M5 ; CPU1.CN29 CPU1.CM29 ; VRAM1.G10 208.86,72.15 208.32,72.7 v1(208.28,72.7) 208.28,72.36 208.06,72.14 VRAM1.F10
  BOTTOM w0.279: DM1.48 43.63,20.93 43.67,20.96 43.67,21.43 v1(43.76,21.52) ; v1(163.41,25.38) 163.48,25.45 163.56,25.45 163.92,25.81 163.92,26.24 163.89,26.28 DM2.213 ; v1(94.13,24.54) 94.2,24.54 94.67,25.01 94.67,26.36 94.5,26.53 94.5,26.66 94.38,26.78 DM1.243 ; v1(173.21,26.29) 173.38,26.46 DM2.251 ; v1(86.63,22.13) 86.44,22.13 86.13,21.82 86.13,21.66 86.11,21.63 86.11,21.2 86.13,21.18 DM1.210 ; DM2.196 159.64,21.27 159.72,21.36 v1(159.72,21.52) ; DM2.85 129.88,27.95 129.88,26.41 v1(129.75,26.27) ; DM2.19 113.39,24.37 v1(112.58,23.56) ; v1(168.22,22.71) 168.34,22.71 169.14,21.92 DM2.234 ; DM1.65 47.88,26.75 47.99,26.64 47.99,25.86 47.54,25.4 v1(47.43,25.4) ; DM2.90 131.13,19.75 131.13,20.98 v1(131.57,21.41) 132.14,20.85 DM2.94 ; DM1.82 52.14,21.61 52.63,22.1 v1(52.73,22.1) ; DM1.226 90.14,19.75 90.14,22 89.55,22.58 v1(89.17,22.58) ; DM1.180 78.63,21.14 v1(78.41,21.37) ; v1(39.38,25.96) 39.38,25.97 39.38,26.39 39.38,26.4 DM1.31 ; DM1.19 36.38,26.79 36.36,26.76 36.36,26.01 36.72,25.65 v1(36.89,25.65) 37.01,25.65 37.43,26.07 37.43,26.63 37.38,26.68 DM1.23 ; DM2.10 111.14,20.69 110.67,21.15 110.67,22.03 110.35,22.35 v1(110.35,23.07) ; DM1.18 36.13,19.75 36.13,21.62 36.13,21.62 36.13,21.65 35.82,21.96 35.79,21.96 v1(35.57,22.18) 35.06,21.67 35.06,21.02 35.13,20.95 35.13,19.75 DM1.14 ; DM1.77 50.89,26.39 v1(51.05,26.22) ; v1(165.67,22.39) 165.6,22.39 165.14,21.92 DM2.218 ; v1(52.75,25.91) 52.88,26.05 52.88,27.95 DM1.85 ; DM2.2 109.14,20.82 108.95,21.01 108.95,22.96 109.44,23.45 v1(109.5,23.45) ; DM2.82 129.14,21.68 v1(129.76,22.3) ; DM2.252 173.64,20.85 173.75,20.97 173.75,22.85 v1(173.23,23.37) ; v1(129.75,23.71) 129.95,23.52 129.96,23.52 130.34,23.15 130.34,21.08 130.14,20.88 DM2.86 ; DM2.56 122.64,21.23 122.82,21.42 v1(122.87,21.42) ; v1(81.28,25.32) 81.89,25.93 DM1.193 ; v1(91.18,22.83) 91.41,22.83 92.13,22.11 DM1.234 ; v1(161.86,24.11) 161.68,24.11 160.88,24.9 160.88,27.95 DM2.201 ; DM2.172 153.63,21.64 v1(153.09,22.18) ; DM2.47 120.39,26.67 120.58,26.47 120.58,26.04 120.15,25.61 120.11,25.61 120.01,25.51 v1(119.98,25.51) ; v1(93.54,24.99) 93.39,24.99 92.39,25.99 92.39,27.95 DM1.235 ; v1(118.25,26.24) 118.39,26.38 DM2.39 ; DM1.99 56.39,27.95 56.39,26.36 v1(56.46,26.29) 55.29,26.29 54.89,26.69 DM1.93 ; DM1.10 34.13,19.75 34.13,21.3 v1(34.02,21.42) ; DM1.47 43.38,26.89 43.8,26.48 43.8,25.8 43.48,25.49 43.25,25.49 42.86,25.1 v1(42.79,25.1) ; v1(77.82,23.75) 77.64,23.93 77.53,23.93 77.22,24.24 77.22,26.77 77.38,26.94 DM1.175 ; DM1.64 47.63,22.43 48.4,23.19 v1(48.58,23.19) ; DM1.239 93.38,26.41 v1(93.54,26.26) ; v1(86.83,26.29) 86.89,26.34 DM1.213 ; DM2.189 157.89,28.94 158.08,29.14 158.69,29.14 158.89,28.94 158.89,27.96 DM2.193 158.89,26.01 158.28,25.4 v1(158.07,25.4) ; v1(80.64,21.42) 80.63,21.41 DM1.188 ; DM2.40 118.64,20.67 118.62,20.68 118.62,21.6 118.17,22.05 v1(118.04,22.05) ; v1(34.15,26.42) 33.89,26.68 33.89,27.95 DM1.9 ; DM1.167 75.38,25.68 v1(76.07,25) 76.57,25.5 76.57,26.23 76.38,26.42 DM1.171 ; DM1.181 78.89,26.9 78.41,26.42 v1(78.41,26.26) ; v1(173.15,22.05) 173.05,21.95 172.97,21.95 172.64,21.61 DM2.248 ; DM1.209 85.89,27.03 85.86,27 85.86,25.71 86.6,24.97 v1(86.86,24.97) ; DM2.68 125.64,21.93 124.9,22.67 124.85,22.67 v1(124.68,22.85) ; v1(118.21,24.97) 118.08,24.97 117.39,25.66 DM2.35 ; v1(91.18,21.44) 91.14,21.39 91.14,19.75 DM1.230 ; DM1.98 56.14,21.01 56.41,21.29 v1(57.14,21.29) ; v1(84.37,23.98) 84.19,24.16 84.15,24.16 83.79,24.51 83.79,24.52 83.79,26.84 83.89,26.93 DM1.201 ; v1(45.85,22.71) 45.6,22.71 44.63,21.74 DM1.52 ; DM2.217 164.89,27 164.63,26.74 164.63,25.03 165.48,24.17 v1(166.06,24.17) ; v1(47.46,24.11) 47.26,24.11 46.88,24.48 46.88,26.03 46.88,26.03 46.88,26.45 46.88,26.46 DM1.61 ; DM1.57 45.89,27.95 45.89,24.12 v1(45.84,24.07) ; DM2.43 119.39,25.35 119.86,24.87 v1(119.93,24.87) ; DM1.103 57.39,27.95 57.39,26.28 56.76,25.65 v1(56.46,25.65) ; v1(170.49,25.45) 170.14,25.81 170.14,26.76 170.38,27 DM2.239 ; DM2.214 164.14,22.39 163.81,22.71 163.53,22.71 v1(163.48,22.76) ; v1(50.01,21.38) 49.63,21.01 DM1.72 ; v1(127.82,21.58) 128.14,21.26 DM2.78 ; DM1.223 89.38,26.47 v1(89.17,26.26) ; v1(111.06,26.24) 110.88,26.41 DM2.9 ; DM1.244 94.64,21.74 v1(94.6,21.77) ; DM1.248 95.64,21.13 v1(95.55,21.21) ; DM1.27 38.38,25.09 36.92,23.63 v1(36.84,23.63) ; DM2.52 121.64,21.2 121.58,21.25 121.58,21.71 122.58,22.71 v1(122.87,22.71) 123.07,22.71 123.64,22.15 123.64,21.9 123.65,21.88 123.65,20.93 123.64,20.92 DM2.60 ; v1(44.74,26.15) 44.56,26.33 44.56,26.8 44.38,26.98 DM1.51 ; DM2.192 158.64,21.67 v1(158.48,21.82) ; DM2.103 134.39,27 v1(133.27,25.89) 134.23,25.89 135.39,27.04 DM2.107 ; DM1.252 96.64,20.85 96.75,20.97 96.75,23.12 96.43,23.45 v1(96.23,23.45) ; DM2.5 109.88,26.61 v1(109.51,26.24) ; v1(166.11,26.23) 166.38,26.5 DM2.223 ; DM1.251 96.38,27.95 96.38,26.29 v1(96.37,26.28) ; DM2.230 168.14,21.34 v1(168.22,21.43) ; v1(39.45,23.38) 39.55,23.28 39.68,23.28 40.37,22.59 40.37,22.59 40.54,22.42 40.54,21 40.63,20.9 DM1.36 ; DM1.69 48.88,26.72 48.71,26.55 48.71,24.75 v1(50.05,23.41) ; DM1.35 40.38,25.48 40.5,25.37 41.02,24.85 v1(41.07,24.85) ; DM2.36 117.64,20.97 117.31,21.29 117.31,22.56 116.43,23.45 v1(116.14,23.45) ; v1(158.3,23.19) 157.95,23.19 157.63,22.87 DM2.188 ; DM2.209 162.89,26.35 162.71,26.17 162.71,25.17 163.21,24.67 v1(163.41,24.67) ; DM2.243 171.38,24.93 v1(170.48,24.03) ; DM1.26 38.14,20.63 38.56,21.06 38.56,21.54 38.06,22.03 v1(38.04,22.03) 37.71,22.03 37.14,21.46 DM1.22 ; DM2.73 126.88,27.95 v1(126.88,26.37) ; v1(89.2,21.31) 89.13,21.25 DM1.222 ; DM1.189 80.89,26.11 80.12,25.35 v1(80,25.35) ; DM1.73 49.89,26.4 v1(49.68,26.19) ; v1(91.41,26.29) 91.39,26.31 91.39,27.95 DM1.231 ; DM2.167 152.39,26.2 153.41,25.17 v1(153.59,25.17) ; DM2.51 121.39,26.92 121.62,26.68 121.62,26.05 v1(121.62,26.04) ; v1(96.23,24.79) 96.06,24.97 96.01,24.97 95.39,25.6 95.39,27.95 DM1.247 ; v1(41.19,26.18) 41.19,26.31 41.38,26.5 DM1.39 ; 53.36,22.92 54.14,22.14 DM1.90 ; 53.36,22.92 53.36,21.04 53.14,20.81 DM1.86 ; 53.36,22.92 52.9,23.37 v1(52.73,23.37) 52.73,23.37 52.52,23.37 51.14,21.98 DM1.78 ; DM2.102 134.14,21.37 134.13,21.38 v1(134.13,21.41) ; v1(163.51,22.13) 163.41,22.13 162.98,21.69 162.98,20.98 163.14,20.82 DM2.210 ; v1(113.97,25.62) 114.09,25.74 114.16,25.74 114.48,26.05 114.48,26.62 114.39,26.71 DM2.23 ; DM2.15 112.39,25.38 111.34,24.34 v1(111.06,24.34) ; DM2.69 125.88,27.04 126.04,26.88 126.04,25.23 126.81,24.46 v1(126.93,24.46) 127.19,24.46 127.89,25.16 DM2.77 ; DM1.43 42.38,27 42.21,26.82 42.21,24.03 41.72,23.54 41.25,23.54 41.24,23.55 v1(41.06,23.55) ; v1(43.73,22.91) 43.7,22.91 43.09,22.3 42.63,21.85 DM1.44 ; v1(32.51,22.13) 32.61,22.13 33.13,21.6 33.13,19.75 DM1.6 ; DM2.18 113.13,19.75 113.13,22.09 112.41,22.81 v1(111.88,22.81) ; DM2.238 170.14,22.44 171.04,23.35 171.31,23.35 v1(171.36,23.4) ; DM2.176 154.63,22.47 155.62,23.45 v1(155.63,23.45) ; DM2.30 v1(116.14,21.42) ; v1(161.6,22.2) 161.73,22.2 162.27,21.66 162.27,20.84 162.14,20.7 DM2.206 ; DM2.181 155.89,26.54 156.14,26.28 156.14,24.89 155.44,24.18 v1(154.73,24.18) ; v1(161.87,26.07) 161.89,26.09 DM2.205 ; DM2.231 168.38,25.41 169.21,24.59 v1(169.35,24.59) ; DM2.244 171.59,19.79 171.59,21.24 v1(171.42,21.41) ; DM2.99 133.39,27.01 132.65,26.28 v1(131.91,26.28) 131.89,26.3 DM2.93 ; DM2.235 169.38,27.95 v1(169.38,25.99) ; DM2.44 119.64,20.71 119.25,21.1 119.25,22.29 118.12,23.42 v1(118.07,23.42) ; v1(129.72,24.98) 129.72,24.99 129.58,24.99 128.8,25.77 128.8,26.66 128.86,26.73 128.86,27.93 DM2.81 ; v1(159.79,23.52) 160.13,23.52 160.97,22.69 160.97,21.11 161.14,20.95 DM2.202 ; v1(39.34,21.42) 39.34,20.96 39.14,20.75 DM1.30 ; 85.13,19.75 85.13,21.44 v1(85.13,21.44) ; v1(153.59,23.9) 153.38,23.9 152.54,23.06 152.54,20.96 152.63,20.86 DM2.168 ; DM1.184 79.63,21.84 80.49,22.69 v1(80.64,22.69) ; v1(124.7,25.61) 124.81,25.61 125.23,26.03 125.23,26.51 124.88,26.85 DM2.65 ; DM2.247 172.38,25.45 172.86,24.97 v1(173.16,24.97) ; DM1.15 35.38,26.94 35.62,26.7 35.62,25.12 34.92,24.41 v1(34.12,24.41) ; DM2.89 130.89,26.01 v1(130.95,25.95) ; DM1.2 32.14,20.82 31.85,21.11 31.85,22.93 32.29,23.37 32.34,23.37 v1(32.51,23.55) ; v1(85.13,22.74) 84.91,22.74 84.13,21.97 DM1.202 ; v1(57.14,21.29) 57.6,21.29 58.14,20.75 DM1.106 ; v1(57.14,21.29) DM1.102 ; v1(111.88,21.43) 112.13,21.17 112.13,19.75 DM2.14 ; DM2.48 120.64,21.33 v1(120.04,21.92) ; DM2.227 167.38,26.53 167.24,26.38 167.24,25.73 167.61,25.35 v1(167.83,25.35) ; v1(153.59,26.44) 153.59,26.49 153.39,26.7 DM2.171 ; DM2.184 v1(156.63,21.78) ; DM2.222 166.14,21.23 166.31,21.41 166.31,22.56 v1(165.7,23.17) ; DM1.1 31.88,27.19 31.67,26.97 31.66,26.97 31.35,26.66 31.35,26.22 31.66,25.91 31.75,25.91 31.85,25.8 v1(31.92,25.8) 32.15,25.8 32.89,26.55 32.89,27.49 32.88,27.49 DM1.5 ; v1(167.21,21.41) 167.21,21.39 167.14,21.31 DM2.226 ; DM2.57 122.89,27.95 122.89,24.7 122.04,23.85 v1(121.68,23.85) ; DM1.196 82.64,21.13 v1(82.92,21.42) ; DM2.1 108.89,27.12 108.75,26.98 108.75,25.53 109.42,24.86 v1(109.47,24.86) ; DM2.64 124.67,19.79 124.67,21.2 124.68,21.21 v1(124.68,21.42) ; DM2.72 126.61,19.77 126.61,22.57 127.68,23.64 v1(127.72,23.64) ; DM2.61 123.88,25.02 124.63,24.27 v1(124.68,24.27) ; DM2.22 114.14,21.42 v1(114.14,21.42) ; v1(154.79,26.12) 154.79,26.63 154.39,27.04 DM2.175 ; DM1.89 53.89,25.59 52.94,24.64 v1(52.75,24.64) 52.54,24.64 51.82,25.37 51.82,26.34 51.88,26.41 51.88,27.95 DM1.81 ; v1(159.88,26.28) 159.88,26.48 159.89,26.48 DM2.197 ; DM2.106 135.14,20.76 134.81,21.08 134.81,21.69 134.39,22.12 v1(134.16,22.12) ; v1(133.2,21.41) 133.2,21.28 133.14,21.22 DM2.98 ; v1(41.08,22.05) 41.18,22.05 41.28,21.95 41.3,21.95 41.61,21.64 41.61,21.62 41.63,21.59 DM1.40 ; v1(84.37,25.4) 84.43,25.4 84.89,25.85 DM1.205 ; DM1.68 v1(48.63,21.82) ; DM1.107 58.39,27.95 58.39,26.95 57.98,26.55 v1(57.98,26.52) ; DM1.227 90.38,25.84 91.21,25.02 v1(91.36,25.02) ; v1(156.66,25.86) 156.72,25.86 157.16,26.3 157.16,26.73 156.89,27.01 DM2.185 ; DM2.27 115.39,25.69 116.21,24.86 v1(116.26,24.86) ; v1(109.51,22.13) 109.54,22.13 110.04,21.63 110.04,20.78 110.14,20.68 DM2.6 ; DM2.26 115.14,21.82 v1(114.14,22.81) ; DM2.180 v1(155.63,21.42) ; v1(116.32,26.22) 116.39,26.29 DM2.31
  BOTTOM w0.305: v1(168.98,81.16) 168.87,81.16 168.34,80.63 C7903.2 ; v1(87.56,73.1) 87.56,73.23 CPU1.F18 ; v1(189.36,89.24) 189.36,89.77 GPU1.P23 ; Q8606.1 170.85,94.63 v1(170.9,94.58) ; v1(188.39,14.18) 188.36,14.15 HDD1.7 ; CPU1.W10 95.94,78.37 v1(95.98,78.37) ; SSD1.45 210.69,11.45 v1(210.77,11.37) ; v1(114.47,78.11) 114.47,78.17 CPU1.BK10 ; v1(158.19,98.48) 158.05,98.34 Q8607.1 ; v1(211.5,4.6) 211.15,4.95 SSD1.71 ; CPU1.B15 85.66,75.16 85.66,75.04 v1(85.61,74.98) ; v1(87.56,76.87) 87.64,76.95 87.64,77.08 CPU1.F12 ; 198.19,60.18 198.21,60.19 WLAN1.63 ; 198.19,60.18 199.4,60.18 199.45,60.22 199.48,60.22 199.64,60.38 199.64,60.41 199.71,60.48 WLAN1.57 ; 198.19,60.18 198.09,60.18 197.47,59.56 v1(197.35,59.56) 197.35,59.74 196.71,60.38 WLAN1.69 ; CPU1.T7 93.52,80.5 v1(93.29,80.5) ; v1(184.66,69.29) GPU1.A2 ; v1(10.54,84.74) 10.38,84.89 C7325.2 ; CPU1.F15 87.64,75.19 87.64,75.07 v1(87.56,74.98) ; ED3504.8 ED3504.3 v1(15.78,44.25) ; CPU1.B7 v1(84.69,80.52) ; ED5702.8 ED5702.3 v1(13.91,61.24) ; CPU1.BP12 116.63,76.44 v1(116.63,75.29) ; SSD1.33 210.25,14.45 v1(210.99,15.19) 210.99,15.41 210.45,15.95 SSD1.27 ; DM1.60 46.63,18.86 v1(46.27,18.49) ; v1(203.96,59.44) 203.68,59.44 202.71,60.41 WLAN1.45 ; v1(86.63,81.68) 86.68,81.73 CPU1.D5 ; v1(86.63,81.68) 86.06,81.68 CPU1.B5 ; v1(86.63,81.68) 86.63,82.01 CPU1.C4 ; v1(201.42,58.98) 201.42,60.25 201.21,60.45 WLAN1.51 ; 205.71,60.2 WLAN1.33 ; v1(20.14,32.36) 20.39,32.61 U3601.14 ; v1(99.76,81.82) 100.21,82.28 CPU1.AF4 ; PU5201.19 147.9,68.49 147.84,68.42 147.83,68.42 147.49,68.08 v1(147.49,67.95) ; v1(209.24,100.61) 209.65,100.2 VRAM4.K14 ; CPU1.AU10 106.93,78.46 107.13,78.46 v1(107.13,78.46) ; v1(109.94,78.36) 109.83,78.46 109.7,78.46 CPU1.BA10 ; v1(89.51,76.87) 89.84,77.2 CPU1.J12 ; v1(218.82,44.27) 218.74,44.35 218.74,44.95 218.43,45.25 IOBD1.16 ; v1(151.35,73.08) 151.35,72.6 150.45,71.69 PU5201.4 ; v1(207.84,20.42) 207.87,20.45 SSD1.9 ; LCD1.32 53.56,91.49 53.36,91.29 v1(53.36,91.14) 53.49,91.27 53.84,91.27 54.06,91.48 LCD1.33 ; HDD1.4 v1(189.86,14.05) ; CPU1.J5 89.91,81.57 v1(89.61,81.26) 89.95,80.92 CPU1.J6 ; Q7907.1 179.72,64.62 R7927.2 179.23,64.93 v1(179.06,65.09) ; v1(126.49,61.06) 126.98,61.56 CPU1.CK37 ; v1(31.26,69.75) 31.54,69.47 32.63,69.47 PC4633.2 ; Q7407.1 29.37,84.37 30.4,85.4 R4308.2 ; v1(127.34,66.32) 127.66,66.65 CPU1.CM29 ; GPU1.AC22 GPU1.AD22 182.35,95.04 v1(182.34,95.02) 182.32,95.01 GPU1.AD21 ; v1(172.33,11.94) 172.17,12.1 TPAD1.10 ; CPU1.AG10 100.88,78.44 v1(100.88,78.21) ; SSD1.51 v1(207.99,9.95) ; Q8608.1 165.29,101.14 v1(165.3,101.15) ; CPU1.BL25 v1(115.81,69.52) ; v1(98.72,78.13) 98.72,78.35 CPU1.AC10 ; v1(216.91,43.77) 216.93,43.75 IOBD1.19 ; CPU1.N6 91.63,81.2 91.51,81.2 91.5,81.21 v1(91.48,81.21) 91.48,81.21 91.27,81.21 CPU1.L6 ; v1(109.01,81.17) 109.27,80.92 CPU1.BA6 ; WLAN1.39 204.21,60.05 v1(204.79,59.46) ; SSD1.57 v1(209.23,7.92) ; CPU1.D6 87.24,80.91 v1(87.67,80.47) 87.62,80.47 87.24,80.09 CPU1.D8 ; PU5001.4 89.01,105.71 88.51,106.2 v1(88.41,106.2) ; CPU1.BW11 120.65,78 120.82,77.83 120.82,77.8 v1(120.98,77.64) 121.12,77.79 121.12,77.86 121.3,78.03 CPU1.BY11 ; IOBD1.22 v1(218.87,42.25) ; CPU1.B9 85.1,79.25 v1(85,79.15) ; v1(210.81,4.27) 210.63,4.45 SSD1.73 ; v1(13.79,57.74) ED5701.3 ED5701.8 ; v1(207.92,4.25) 208.21,3.95 SSD1.75 ; v1(111.71,78.36) 112.06,78.7 CPU1.BE10 ; CPU1.W7 95.7,80.37 95.81,80.37 95.83,80.39 96.25,80.39 96.27,80.37 96.42,80.37 CPU1.Y7 CPU1.AB7 ; RN5502.8 v1(42.82,83.34) ; EC1706.2 EC6801.2 139.89,74.66 v1(139.89,74.03) 139.89,73.7 140.33,73.26 R1523.2 ; SSD1.21 v1(207.94,17.45) ; RN5502.2 45.06,82.75 v1(45.23,82.58) ; SSD1.3 207.87,21.95 v1(207.64,22.18) 207.91,22.45 SSD1.1 ; WLAN1.1 213.71,60.45 213.28,60.02 v1(213.28,59.72) ; v1(135.86,75.54) 135.85,75.56 135.41,75.56 R2120.2 ; U8604.3 150.39,89.21 v1(150.24,89.06) ; SSD1.39 210.78,12.95 v1(210.86,13.03) ; DM1.94 55.14,18.8 55.42,18.52 v1(55.42,18.47) ; CPU1.CG33 125.45,63.91 125.65,64.11 v1(125.85,64.11) 126.24,64.11 CPU1.CJ33 ; CPU1.AB4 97.85,82.09 CPU1.AC5 98.72,81.92 v1(98.84,81.92) ; WLAN1.13 210.71,59.8 v1(210.92,59.59) 210.88,59.56 209.43,59.56 209.21,59.77 WLAN1.19 ; v1(58.29,88.09) 58.01,87.81 58.01,87.56 R5553.1 ; PQ4405.1 169.86,12.51 169.41,12.96 168.9,12.96 168.56,13.3 PQ4405.4 ; LCD1.9 42.06,91.65 41.6,91.19 41.6,90.73 40.81,89.94 R5528.2 40.81,87.56 v1(41.37,87) ; EC5505.3 EC5505.8 ; RN5502.6 43.11,82.25 42.96,82.4 v1(42.82,82.4) ; v1(58.48,90.59) 59.07,89.99 C5503.2 ; CPU1.J15 89.84,75.32 v1(89.51,74.98) ; v1(86.24,78.76) 86.24,79.13 CPU1.C9 ; PC4624.2 46.78,68.94 v1(47.16,69.32) 46.78,69.7 PC4601.2 ; v1(168.4,96.17) 168.51,96.28 Q8606.4 ; v1(166.24,100.15) 166.35,100.04 Q8602.S ; CPU1.BN7 116.54,80.57 v1(116.44,80.57) 116.23,80.57 CPU1.BL7 ; CPU1.E9 88.11,78.8 v1(88.2,78.8) 88.31,78.8 CPU1.G9 ; CPU1.P10 92.83,78.7 93.07,78.46 v1(93.3,78.46) ; v1(85.61,76.87) 85.71,76.97 85.71,77.1 CPU1.B12 ; v1(43.86,91.16) 43.63,91.39 43.63,91.46 43.56,91.53 LCD1.12 ; CPU1.H9 89.69,79.16 v1(90.03,78.82) 90.18,78.82 CPU1.K9 ; CPU1.CM9 127.58,79.25 127.58,79.25 v1(127.45,79.25) ; EC8949.2 19.3,55.7 v1(19.3,56.54) ; R2706.2 21.63,11.05 v1(21.63,11) ; U4006.5 109.1,102.79 109.37,102.52 109.37,102.42 v1(109.47,102.31) 109.87,101.91 C4034.2 ; v1(193.36,16.21) ED6001.3 ED6001.8 ; v1(86.91,78.77) 87.1,78.97 CPU1.D9 ; TPAD1.5 176.21,14.9 v1(176.63,14.48) ; v1(89.51,73.1) 89.51,73.23 89.84,73.56 CPU1.J18 ; v1(212.29,59.74) 212.29,59.95 212.21,60.02 WLAN1.7 ; IOBD1.41 216.65,53.65 v1(216.05,53.05) ; CPU1.B18 85.64,73.25 85.64,73.13 v1(85.61,73.1) ; HDD1.1 v1(191.36,14.05) ; v1(206.37,13.41) 206.19,13.59 ED6301.3 ED6301.8 ; WLAN1.18 209.46,52.58 209.24,52.36 209.24,52.25 v1(209.21,52.23) ; v1(207.89,18.95) SSD1.15 ; C8602.2 169.23,100.03 v1(168.75,100.51) 169.03,100.79 C8603.2 ; Q8608.4 v1(162.36,99.27) ; IOBD1.38 217.05,34.25 v1(217.04,34.24) ; GPU1.AB11 v1(177.08,87.46) ; CPU1.A4 85.08,82.7 v1(84.79,82.98) 85.15,83.35 CPU1.A3 ; LCD1.18 46.56,91.28 46.63,91.21 v1(46.63,91.16) ; CPU1.CF11 124.45,78.04 CPU1.CD11 CPU1.CD12 123.77,77.08 123.77,76.49 CPU1.CD14 123.9,76.25 v1(124.35,75.8) ; 82.03,24.63 v1(81.19,23.8) ; v1(123.56,65.64) 123.51,65.59 123.41,65.59 CPU1.CC31 ; LCD1.15 v1(45.06,91.35) ; v1(171.92,96.2) 172.33,96.61 C8601.2 ; DM1.56 v1(45.63,18.49) ; CPU1.BT33 118.86,63.99 117.75,63.99 CPU1.BP33 117.27,63.91 117.19,63.99 116.76,63.99 116.68,63.91 CPU1.BM33
  BOTTOM w0.356: Q7405.4 22.67,81.75 R7408.2 ; v1(173.02,81.01) 173.58,81.01 ; v1(181.76,97.36) 182.35,96.77 GPU1.AF23 ; v1(173.55,65.61) 174.03,65.13 Q8609.4 ; PQ4415.1 167.26,7.99 v1(167.86,7.39) 167.86,7.29 168.03,7.12 Q6505.S ; PQ4416.1 167.49,9.79 167.66,9.63 v1(167.84,9.63) ; v1(165.1,10.81) 165.1,10.93 165.62,11.45 PQ4416.4 ; v1(21.84,29.37) 22.63,28.58 C3510.2 ; v1(167.94,14.3) 168.14,14.3 168.56,13.89 PQ4405.4 ; PQ4415.4 164.27,6.19 164.58,5.87 v1(166.01,5.87) ; PR4410.1 155.06,7.57 v1(154.65,7.98) 155.09,8.41 PC4441.2 ; v1(182.34,61.43) 182.34,61.43 182.08,61.43 181.72,61.78 Q7907.4 ; GPU1.AC5 v1(173.55,83.95) ; GPU1.T15 v1(182.57,86.62) GPU1.U14 GPU1.V13 ; GPU1.AF11 175.34,90.28 175.36,90.3 v1(175.36,90.35) ; THM261.5 164.48,105.22 164.13,104.87 v1(164.13,104.47) ; Q8609.1 175.93,62.44 177.16,62.44 v1(177.53,62.8) ; CPU1.BW15 120.65,75.46 120.97,75.14 v1(120.97,75.12) ; GPU1.AB7 175.28,84.97 175.75,84.5 GPU1.AA7 176.3,84.09 v1(176.3,84.03) ; v1(156.47,88.94) 156.45,88.96 U8605.3 ; 177.63,89.78 177.63,89.23 v1(177.61,89.21) 177.57,89.21 177.57,89.21 GPU1.AD12
  BOTTOM w0.381: GPU1.U2 v1(174.79,79.25) ; GPU1.AB17 v1(180.59,90.96) ; v1(186.43,71.65) 186.43,71.66 186.24,71.66 185.82,72.07 GPU1.B5 ; GPU1.L2 v1(178.3,75.75) ; GPU1.E8 v1(185.89,75.14) ; GPU1.E5 v1(183.54,73.96) ; GPU1.E2 182.36,72.12 v1(181.62,71.39) ; GPU1.P2 v1(177.09,76.91) ; GPU1.Y5 v1(175.83,82.7) ; GPU1.AB20 v1(182.32,92.72) ; GPU1.P5 v1(178.79,78.65) ; GPU1.AF11 175.9,89.18 ; GPU1.B8 v1(187.04,73.99) ; GPU1.L5 v1(179.99,77.44) ; GPU1.H2 180.08,73.99 180.03,74.04 v1(180.01,74.04) ; GPU1.AC2 v1(171.82,82.2) ; 177.03,80.95 v1(176.49,80.95) ; GPU1.H5 v1(181.75,75.69)
  BOTTOM w0.406: R2404.2 29.61,51.97 C2430.2 30.04,51.31 30.32,51.59 v1(30.45,51.59) ; GPU1.AG26 v1(182.9,99.69) ; GPU1.N12 GPU1.P11 ; C2736.2 18.21,13.74 v1(17.85,14.1) ; v1(46.25,76.74) 45.71,77.28 FC8922.2 ; v1(166.02,66.17) 165.84,66.35 C4043.2 165.32,65.43 C4008.2 ; U4002.5 160.94,61.33 161.39,60.89 C4007.2 161.84,60.48 162.36,61 U4004.5 ; EC2703.2 17.29,15.29 18.08,16.08 C2704.2 ; GPU1.K11 GPU1.L10 ; GPU1.L16 GPU1.K15
  BOTTOM w0.432: GPU1.AG2 GPU1.AF1 v1(169.08,83.49) ; GPU1.B1 183.08,69.49 v1(183.08,69.47)
  BOTTOM w0.457: GPU1.N10 181.97,80.11 182.53,79.55 v1(182.6,79.55) GPU1.L10 ; v1(183.96,86.73) 184.68,86.73 GPU1.R16 GPU1.P17 ; GPU1.M11 GPU1.L12 184.89,81.05 185.43,81.05 185.46,81.09 v1(185.51,81.09) 185.54,81.05 186.12,81.05 GPU1.K13 ; v1(179.14,85.85) GPU1.V11 GPU1.U12 ; GPU1.P11 v1(181.17,82.38) GPU1.R10 ; GPU1.M13 GPU1.L14 v1(186.89,82.38) GPU1.K15 ; GPU1.P15 GPU1.R14 v1(182.6,85.21) GPU1.T13 ; GPU1.V15 GPU1.U16 v1(183.99,88.04) GPU1.T17 ; v1(188.48,87.47) 187.63,86.62 GPU1.N18 ; v1(189.76,83.79) GPU1.K17 GPU1.L16 v1(186.95,83.79) GPU1.M15 ; v1(185.49,89.39) 185.42,89.39 185.35,89.45 GPU1.U18 GPU1.V17 ; GPU1.U10 GPU1.T11 v1(181.25,83.79) GPU1.R12 ; GPU1.R18 186.95,88.04 v1(187.11,87.88) ; GPU1.P13 v1(184.17,83.79) GPU1.N14 ; GPU1.N16 GPU1.M17 GPU1.L18 189.77,85.21 v1(189.89,85.09)
  BOTTOM w0.508: v1(182.87,63.45) C7908.1 ; USB4.12 11.25,39.64 ; USB4.12 11.25,37.86 ; USB4.12 12.57,38.75 ; v1(107.66,89.23) 106.85,88.42 R1714.2 ; 4.52,98.5 BS2.1 ; BS2.1 10.9,98.5 ; BS2.1 7.71,95.31 ; 6.19,53 USB4.11 4.45,53.89 ; v1(138.35,77.96) 138.22,77.83 C1807.1 ; Q5701.S 19.11,68.95 19.34,68.72 v1(19.55,68.72) ; v1(41.73,71.15) 41.93,71.35 PR4659.1 41.79,71.93 PC4637.2 ; FC8924.2 130.19,109.12 ; R1553.2 126.59,56.59 R1501.1 125.94,56.57 v1(125.65,56.28) ; Q8604.S 154.28,74.68 152.98,74.68 152.83,74.53 152.47,74.53 152.09,74.15 ; ED1702.3 v1(146.35,64.9) ; R1503.2 R2114.2 131.11,54.03 131.37,53.77 v1(131.39,53.77) ; 36.09,82.12 36.85,82.12 v1(37.03,81.94) 37.03,81.44 C4344.2 ; 6.36,84.53 USB1.15 ; USB1.15 7.45,83.74 ; USB1.15 8.54,84.53 ; Q8603.S 166.83,103.34 v1(166.41,102.92) ; v1(156.28,17.22) 156.28,17 156.53,16.74 PC4426.1 PC4424.1 ; C1808.1 137.46,80.22 v1(137.05,80.62) ; PC8510.1 115.54,103.81 115.36,103.81 115.25,103.71 v1(114.83,103.71) ; FC6101.2 219.3,57.28 IOBD1.43 220.73,54.86 v1(221.02,54.56) ; PC5130.2 72.1,16.39 v1(72.82,16.39) ; EC5504.2 48.67,90.33 48.79,90.45 48.79,90.48 v1(48.81,90.5) ; LCD1.43 34.96,95.03 34.21,95.79 31.78,95.79 v1(31.37,95.38) 32.11,94.64 DCIN1.10 ; R8534.2 113.15,101.91 112.19,101.91 v1(112.11,101.83) ; 3.78,82.93 USB1.14 ; USB1.14 5.12,82.09 ; USB1.14 6.45,82.93 ; 5.28,92.2 USB1.B1 5.91,93.24 ; 11.25,52.44 USB4.13 11.91,52.44 ; C6002.2 v1(185.44,15.7) ; R2037.2 142.77,69.61 142.07,70.31 v1(142.07,70.45) 142.28,70.67 R2116.2 ; LCD1.42 58.46,91.68 58.48,91.66 v1(58.48,90.59) ; v1(24.78,79.02) 26.05,79.02 R4379.2 26.37,79.34 Q4304.E ; C7329.2 13.52,84.53 v1(14.41,85.42) ; PR4451.2 160.83,4.78 v1(161.11,4.5) 161.11,4.65 161.59,5.13 PR4417.1 ; PC5112.2 55.59,10.82 PC5108.2 55.01,10.8 v1(54.81,10.59) ; USB1.20 8.54,93.48 ; USB1.20 6.36,93.48 ; USB1.20 7.45,94.26 ; USB3.12 11.25,19.64 ; USB3.12 12.57,18.75 ; USB3.12 11.25,17.86 ; SBD1.5 83.12,100.41 84.53,100.41 ; C3507.2 16.1,53.24 v1(15.79,52.94) ; v1(34.74,59.85) 34.31,59.85 34.15,60 PR4621.1 ; R7606.2 163.34,80.17 v1(163.81,79.7) ; IOBD1.42 v1(217.08,32.35) ; C7907.1 v1(186.33,63.45) ; 5.91,84.76 USB1.B12 5.28,85.8 ; v1(221.11,65.82) 220.11,66.82 FAN1.5 ; 11.91,32.44 USB3.13 11.25,32.44 ; R7932.2 197.25,71.71 197.25,72.16 v1(197.26,72.18) ; v1(116.33,100.18) 116.43,100.08 PR8577.2 PC8518.2 ; DM1.262 v1(29.33,35.85) ; v1(161.64,64.9) 162,65.26 C4011.2 ; R1519.2 131.77,72.29 v1(131.21,72.85) ; R7820.1 210,82.91 v1(210.1,82.91) ; C8044.2 166.17,88.99 v1(166.78,89.6) ; R1505.2 149.27,79.18 148.73,79.71 148.09,79.71 v1(148.09,79.71) ; v1(210.84,22.56) 210.69,22.71 210.69,22.94 210.08,23.55 SSD1.76 ; Q2510.S 202.17,25.46 HS1.1 ; R7939.2 176.57,67.4 R7926.2 176.8,68.23 v1(176.8,68.58) ; C8501.1 104.03,106.07 102.76,107.34 v1(102.76,108.31) ; 10.26,73.86 HDMI1.23 ; HDMI1.23 10.26,75.84 ; HDMI1.23 11.59,74.85 ; v1(40.12,54.43) 40.12,54.58 40.59,55.05 DBG1.3 ; FC8914.2 v1(114.83,103.71) ; v1(114.83,103.71) 114.77,103.65 C4031.2 ; v1(73.1,13.11) PR5115.2 72.36,13.21 PC5129.2 ; v1(63.14,16.84) 63.04,16.94 PC5128.2 ; v1(221.02,29.07) 221.02,29.16 220.73,29.46 IOBD1.44 ; U3403.2 190.05,15.9 v1(189.87,15.73) ; BATT1.8 v1(116.39,15.59) ; R6505.2 v1(104.77,14.73) ; v1(21.84,29.37) 21.84,29.67 22.68,30.51 C3605.2 ; C3601.2 C3603.2 20.95,36.55 v1(21.15,36.76) ; v1(168.85,62.36) 168.64,62.14 U2502.2 ; PC5117.2 55.54,17.15 54.25,17.15 PC5124.2 54.1,18.11 v1(54.25,18.27) ; PC4644.2 39.78,75.11 v1(39.52,75.36) 39.52,74.2 PC4641.2 ; USB1.21 5.12,95.91 ; USB1.21 6.45,95.07 ; USB1.21 3.78,95.07 ; v1(34.67,84.86) 34.06,85.47 R4308.2 ; v1(95.02,6.38) 94.69,6.05 KB_BL1.5 ; C802.2 88.44,93.73 v1(86.56,91.85) ; U5502.2 64.1,93.14 C5550.2 64.28,93.4 v1(65.17,94.29) ; v1(57.78,14.66) 57.65,14.53 PC5113.2 ; C4047.2 165.22,60.84 v1(164.84,60.45) ; v1(177.13,17.53) 177.11,17.53 177.01,17.43 EC6506.2 ; C2740.2 v1(31.24,16.51) ; v1(189.17,31.32) 189.17,30.96 188.14,29.92 186.96,29.92 186.28,29.24 C2501.2 ; SKT251.4 184.96,36.22 v1(185.06,36.32) ; 12.15,40.81 USB4.4 12.79,41.01 ; v1(180.88,68.85) 180.49,68.46 R7911.2 ; PC5213.2 R1552.2 145.71,70.14 PC5202.2 144.01,68.04 v1(143.95,68.04) ; 1.48,58.45 HDMI1.20 ; HDMI1.20 2.81,57.46 ; HDMI1.20 4.14,58.45 ; C8607.2 178.02,101.91 178.28,102.16 v1(179.22,102.16) 179.28,102.22 180,102.22 R7601.2 ; v1(218.83,61.9) 219.03,61.7 FAN1.6 ; PC4520.2 49.96,3.66 v1(49.96,4.02) ; PU5301.1 85.59,12.3 PR5302.2 84.44,12.17 v3(84.25,12.36) ; RTC1.3 207.36,7.3 v1(206.35,8.31) ; v1(142.26,82.55) 142.29,82.55 PC8629.2 ; PC5306.2 93.11,17.3 v1(94.02,16.39) ; C7330.2 12.67,90.63 12.39,90.35 11.04,90.35 C7326.2 10.23,89.79 v1(10.23,89.77) ; EC8954.2 17.14,23.7 v1(17.75,23.7) ; BATT1.9 v1(115.14,15.59) ; 1.25,82.09 USB1.13 2.58,82.93 ; X7901.4 185.91,62.04 186.18,61.78 186.25,61.78 v1(186.3,61.72) ; PC4603.1 47.37,62.28 PR4628.2 46.48,62.08 46.48,61.85 46.45,61.83 PR4629.2 46.45,61.04 v1(46.25,60.84) 47.03,60.84 47.16,60.96 EC8957.2 FC8921.2 ; v1(56.43,1.78) 56.08,1.78 PR4512.2 PR4513.2 ; 6.19,37.3 USB4.10 4.45,36.41 ; 12.15,20.81 USB3.4 12.99,21.65 ; EC5501.2 50.79,87 51.3,87 EC5502.2 51.38,86.54 v1(51.02,86.19) ; HDMI1.21 4.14,76.75 ; HDMI1.21 2.81,77.74 ; HDMI1.21 1.48,76.75 ; v1(35.5,77.55) 35.96,77.09 EC8947.2 ; EC8904.2 32.73,17.43 v1(31.79,17.43) ; v1(204.79,59.46) 204.97,59.46 205.71,60.2 ; v1(182.32,60.79) 182.75,60.79 183.01,61.05 X7901.2 ; 10.26,61.34 HDMI1.22 10.26,59.36 ; 4.45,33.89 USB3.11 6.19,33 ; PC4429.2 129.94,4.88 v1(130.04,4.78) ; v1(16.43,52.05) C3517.2 C3516.2 ; C8112.2 199.87,76.79 199.33,76.79 198.89,77.23 198.89,77.88 v1(199.01,78) ; 1.25,95.91 USB1.22 2.58,95.07 ; v1(75.36,16.39) 75,16.03 PC5125.2 ; FC8903.2 178.73,40.59 176.06,37.92 DM2.261 176.06,35.26 v1(178.23,33.1) ; C8039.2 166.08,79.13 v1(166.08,78.31) ; v1(13.51,14.43) 13.53,14.4 ED2912.2 ; C4007.2 161.39,59.97 v1(161.03,59.62) ; v1(75.53,98.52) 76.54,98.52 77.12,99.1 SBD1.12 77.9,99.96 80.19,99.96 SBD1.8 ; BATT1.10 v1(113.88,15.59) ; 4.45,16.41 USB3.10 6.19,17.3 ; v1(76.12,95.82) 76.12,95.35 74.47,93.7 U7205.9 74.47,91.77 75.1,91.14 U7205.4 ; KB1.1 v1(85.71,8.01) ; v1(19.04,52.71) 19.04,53.06 19.56,53.57 U3502.2 ; EC8933.2 EC8939.2 21.43,67.95 21.5,68.01 v1(22.41,68.01) ; C5505.2 45.36,80.11 45.87,80.62 45.87,80.64 PT4805.2 47.07,80.97 v1(47.8,80.24) ; v1(38.65,76.36) 38.65,75.92 PC4640.2 38.81,75.72 PC4638.2 37.95,75.68 PR4661.2 37.94,74.88 PC4639.2 37.84,74.07 PR4655.1 ; H17.1 7.71,82.59 ; H17.1 10.9,79.4 ; H17.1 4.52,79.4 ; WLAN1.76 214.81,60.03 214.45,59.67 213.33,59.67 v1(213.28,59.72) ; Q2408.S 25.35,41.86 v1(23.97,43.23) ; v1(158.21,5.79) 157.78,6.23 PC4430.2 ; BATT1.12 v1(109.93,12.05) ; v1(17.85,14.1) 17.29,14.66 EC2703.2 ; LCD1.41 37.16,92.01 36.09,90.93 v1(36.09,90.6) ; v1(39.91,78.65) 39.94,78.62 R5506.2 40.84,78.56 U5501.2 ; FAN1.2 215.59,65 214.88,64.29 v1(214.88,64.21) ; R1518.2 v1(87.99,91.61) ; v1(91.1,86.87) 90.98,87 R1517.2 ; C6008.2 v1(185.85,16.59) ; R2112.2 R1514.2 141.07,67.62 140.48,67.03 140.25,67.03 v1(139.69,66.47) ; KB1.31 v1(86.34,7.25) ; 158.62,69.78 158.64,69.75 159.61,69.75 160.6,68.76 C4033.2 160.6,67.06 C4032.2 ; PC4421.2 164.87,16.75 164.87,16.84 165.7,17.67 v1(165.7,17.91) ; v1(53.02,84.17) 53.5,84.66 C5541.2 ; v1(61.61,90.48) 61.51,90.58 61.51,92.92 60.66,93.77 LCD1.44 ; Q6501.S v1(105.8,14.71)
  vias: v1(0.78,96.12) v1(0.81,80.85) v1(0.76,79.23) v1(0.81,77.93) v1(1.28,58.79) v1(1.31,56.97) v1(1.47,97) v1(2.08,54.94) v1(2.84,35.77) v1(2.84,34.37) v1(2.89,80.32) v1(2.86,78.64) v1(2.86,15.22) v1(3.17,94.64) v1(3.22,83.37) v1(3.6,81.49) v1(3.88,100.69) v1(4.11,15.06) v1(4.49,55.2) v1(4.82,76.23) v1(4.87,35.26) v1(5.25,57.36) v1(5.63,93.7) v1(5.58,84.18) v1(6.17,58.99) v1(6.47,15.3) v1(6.78,34.62) v1(6.9,56.21) v1(7.26,17.12) v1(7.28,53.67) v1(7.54,37.16) v1(7.54,33.23) v1(7.66,58.75) v1(7.66,54.82) v1(7.92,52.91) v1(8.68,35.64) v1(8.81,57.23) v1(8.93,15.06) v1(9.09,73.21) v1(9.09,61.88) v1(9.54,94.77) v1(9.6,83.57) v1(9.67,53.29) v1(9.75,36.96) v1(9.7,33.45) v1(9.67,16.87) v1(9.82,58.75) v1(9.82,54.82) v1(10.41,88.04) v1(10.97,15.52) v1(11.27,82.63) v1(11.6,33.35) v1(11.74,100.74) v1(11.73,35) v1(11.86,37.04) v1(12.24,16.54) v1(12.34,97.46) v1(13.19,83.54) v1(13.18,62.23) v1(14.19,32.13) v1(14.19,31.4) v1(14.88,31.4) v1(15.74,100.71) v1(16.33,99.62) v1(16.39,9.91) v1(16.89,5.5) v1(17.32,2.97) v1(18.64,24.44) v1(18.66,83.47) v1(19.09,61.24) v1(19.09,59.49) v1(19.09,57.74) v1(19.07,41.86) v1(19.27,35.16) v1(19.54,86.52) v1(19.91,37.39) v1(20.08,63.13) v1(20.93,100.71) v1(21.03,29.44) v1(21.13,26.04) v1(21.13,24.95) v1(21.46,3.48) v1(21.48,47.37) v1(21.9,100.74) v1(21.99,64.42) v1(22.07,62.21) v1(22.45,16) v1(22.52,47.37) v1(22.65,60.61) v1(22.8,59.5) v1(22.96,66.09) v1(22.96,2.77) v1(23.21,63.6) v1(23.21,16) v1(23.69,46.94) v1(23.67,44.38) v1(23.69,24.19) v1(23.84,63.76) v1(23.97,16.77) v1(23.97,16) v1(23.97,15.24) v1(24.4,63.1) v1(24.58,0.82) v1(24.73,16) v1(25.5,16) v1(26.05,70.64) v1(25.98,69.95) v1(26.41,71.2) v1(26.72,70.65) v1(26.79,69.95) v1(27.12,71.28) v1(27.36,70.65) v1(27.5,69.98) v1(27.74,47.83) v1(28.34,56.72) v1(28.47,64.29) v1(28.62,62.99) v1(30.32,12.08) v1(30.88,25.22) v1(31.62,62.88) v1(31.77,9.07) v1(32.48,9.07) v1(33.24,9.02) v1(33.9,8.77) v1(34.03,39.91) v1(34.72,89.44) v1(35.4,89.46) v1(36.09,89.46) v1(37.28,90.48) v1(37.84,0.76) v1(38.63,66.36) v1(39.27,66.36) v1(39.9,67.63) v1(39.9,67) v1(39.9,66.36) v1(39.9,65.73) v1(39.9,65.09) v1(40.23,18.04) v1(40.54,66.36) v1(40.91,18.01) v1(41.17,66.36) v1(41.37,84.76) v1(41.55,18.01) v1(42.18,18.01) v1(42.84,18.01) v1(43.28,86.87) v1(43.48,17.96) v1(43.89,55.7) v1(44.69,23.81) v1(44.77,87.86) v1(45,86.52) v1(46.81,29.9) v1(48,0.76) v1(51.25,10.21) v1(51.99,10.19) v1(52.32,63.53) v1(52.67,10.16) v1(52.9,73) v1(52.9,72.37) v1(52.9,71.73) v1(52.9,71.1) v1(53.08,0.76) v1(53.54,73) v1(53.54,72.37) v1(53.54,71.73) v1(53.54,71.1) v1(53.58,63) v1(53.58,62.37) v1(53.58,61.73) v1(53.58,61.1) v1(54.07,73.79) v1(54.17,73) v1(54.17,72.37) v1(54.17,71.73) v1(54.17,71.1) v1(54.22,63) v1(54.22,62.37) v1(54.22,61.73) v1(54.22,61.1) v1(54.35,83.39) v1(54.35,82.76) v1(54.35,82.12) v1(54.35,81.49) v1(54.75,63.79) v1(54.85,63) v1(54.85,62.37) v1(54.85,61.73) v1(54.85,61.1) v1(54.99,83.39) v1(54.99,82.76) v1(54.99,82.12) v1(54.99,81.49) v1(55.16,5.79) v1(55.62,84.1) v1(55.62,83.39) v1(55.62,82.76) v1(55.62,82.12) v1(55.62,81.49) v1(57.15,90.59) v1(58.16,0.76) v1(58.34,18.49) v1(58.57,4.65) v1(59.25,18.49) v1(59.89,101.2) v1(61.64,18.39) v1(61.77,85.02) v1(61.77,84.38) v1(62.4,85.02) v1(62.4,84.38) v1(62.5,11.36) v1(62.84,18.53) v1(63.24,0.76) v1(66.36,109.22) v1(67.28,85.85) v1(67.91,92.2) v1(67.91,85.85) v1(68.12,108.36) v1(68.32,0.76) v1(68.55,92.23) v1(68.57,85.85) v1(69.18,92.18) v1(69.28,109.24) v1(69.74,46.28) v1(69.89,102.39) v1(71.01,108.38) v1(73.17,109.2) v1(73.27,41.56) v1(73.4,0.76) v1(73.6,108.36) v1(74.59,109.22) v1(75.28,108.41) v1(75.48,99.52) v1(76.32,109.22) v1(77.26,108) v1(78.48,0.76) v1(78.75,69.63) v1(79.36,66.63) v1(79.67,70.89) v1(79.92,67.93) v1(80.72,64.91) v1(80.89,83.01) v1(80.94,70.88) v1(81.05,83.67) v1(81.01,69.71) v1(81.33,84.24) v1(81.29,66.61) v1(81.83,67.93) v1(81.88,62.18) v1(81.99,64.93) v1(82.01,63.32) v1(82.27,69.57) v1(83.25,66.53) v1(83.56,0.76) v1(84.72,71.77) v1(86.42,59.01) v1(86.89,109.22) v1(87.01,56.62) v1(87.03,55.3) v1(88.64,0.76) v1(88.8,56.36) v1(88.83,55.09) v1(89.28,109.22) v1(89.35,101.65) v1(89.51,71.34) v1(89.84,67.59) v1(89.84,66.95) v1(89.84,66.32) v1(90.04,105.06) v1(90.04,101.69) v1(90.16,71.34) v1(90.43,56.15) v1(90.41,54.19) v1(90.76,67.62) v1(90.88,68.38) v1(91.69,101.11) v1(91.68,67.62) v1(92.57,67.59) v1(92.57,66.95) v1(92.57,66.32) v1(93.48,67.59) v1(93.72,0.76) v1(94.39,67.59) v1(94.39,65.68) v1(95.22,23.98) v1(95.3,66.3) v1(96.22,67.59) v1(97.15,89.97) v1(98.51,87.3) v1(98.65,24.39) v1(98.8,0.76) v1(98.9,109.22) v1(99.59,87.35) v1(100.09,90.15) v1(100.77,67.59) v1(101.18,25.48) v1(101.69,66.32) v1(102.04,89.77) v1(102.16,86.39) v1(102.43,35.77) v1(103.07,35.77) v1(103.37,86.97) v1(103.55,89.72) v1(103.7,35.77) v1(103.85,54.54) v1(104.01,58.37) v1(104.03,56.46) v1(104.29,109.22) v1(104.78,89.11) v1(105.29,82.78) v1(105.33,66.95) v1(105.3,57.18) v1(105.3,55.2) v1(106.7,95.33) v1(107.12,57.91) v1(107.09,56.64) v1(107.07,54.71) v1(108.44,57.15) v1(108.44,55.88) v1(108.91,108.71) v1(109.42,92.05) v1(109.45,91.01) v1(109.55,88.12) v1(109.62,108.66) v1(110.06,55.98) v1(110.31,88.67) v1(110.51,86.29) v1(110.85,88.24) v1(111.17,49.99) v1(111.44,59.18) v1(111.46,90) v1(111.5,7.72) v1(111.66,109.24) v1(112.16,97.38) v1(112.19,95.48) v1(112.62,87.71) v1(112.67,88.99) v1(112.87,58.27) v1(112.87,57) v1(113.2,85.88) v1(113.38,90.07) v1(113.54,67.64) v1(113.58,7.42) v1(113.9,6.01) v1(114.04,0.76) v1(114.73,87.66) v1(114.9,90.08) v1(115.11,106.43) v1(115.08,87.1) v1(115.46,51.46) v1(115.74,106.4) v1(115.77,107.03) v1(115.95,56.21) v1(116.45,90.07) v1(116.74,109.24) v1(117.52,11.38) v1(117.84,10.37) v1(117.95,90.07) v1(117.9,7.31) v1(117.98,5.49) v1(118.28,11.38) v1(118.94,57.49) v1(119.03,70.07) v1(119.12,100.13) v1(119.12,0.76) v1(119.3,109.2) v1(119.48,97.16) v1(119.48,90.07) v1(119.63,94.97) v1(119.76,100.76) v1(119.76,100.13) v1(120.07,23.47) v1(120.39,100.13) v1(121.48,46.15) v1(122.27,69.24) v1(123.04,88.36) v1(124.2,0.76) v1(124.8,88.78) v1(126.89,109.2) v1(127.65,0.84) v1(128.57,2.52) v1(129.98,61.32) v1(131.87,85.04) v1(132.13,67.65) v1(132.91,65.56) v1(133.09,24.56) v1(133.55,64.32) v1(134.05,67.56) v1(136.85,66.42) v1(137.69,71.4) v1(138.02,2.77) v1(138.93,66.45) v1(142.97,2.77) v1(143.39,51.1) v1(143.5,88.78) v1(143.86,50.68) v1(147.03,2.77) v1(150,75.78) v1(150.11,66.55) v1(150.77,66.55) v1(151.43,66.55) v1(152.11,66.55) v1(153.87,2.77) v1(156.15,100.92) v1(158.77,2.77) v1(159.38,11.74) v1(159.4,10.85) v1(159.38,9.93) v1(160.29,11.74) v1(160.29,10.85) v1(160.29,9.96) v1(161.21,11.76) v1(161.21,10.87) v1(161.18,9.98) v1(162.27,86.77) v1(163.21,109.2) v1(163.67,54.71) v1(165.56,83.83) v1(166.06,2.77) v1(167.94,76.66) v1(168.1,90.18) v1(168.12,86.31) v1(168.12,85.28) v1(168.45,76.15) v1(168.56,91.34) v1(168.95,108.16) v1(168.95,92.03) v1(168.95,75.64) v1(169.7,14.81) v1(170.53,109.22) v1(170.48,106.63) v1(170.66,91.96) v1(171.11,91.42) v1(171.67,91.85) v1(172.33,2.77) v1(173.53,100.03) v1(176.81,84.53) v1(177.03,86.31) v1(177,2.76) v1(177.11,90.91) v1(178.23,100.31) v1(178.99,55.07) v1(178.99,54.41) v1(179.11,53.72) v1(179.34,50.19) v1(179.41,20.17) v1(179.57,55.37) v1(179.57,54.71) v1(179.78,53.72) v1(180.47,50.2) v1(181.96,53.93) v1(182.06,109.24) v1(182.08,2.76) v1(183.56,108.36) v1(183.89,26.29) v1(184.6,108.36) v1(184.65,10) v1(185.13,27.28) v1(185.39,108.36) v1(185.75,99.91) v1(186.71,59.06) v1(187.14,109.24) v1(187.16,2.76) v1(187.33,99.85) v1(188.29,99.7) v1(188.92,98.2) v1(189.91,98.28) v1(190.65,5.97) v1(192.22,109.24) v1(192.24,2.76) v1(192.63,10) v1(192.83,27.94) v1(193.12,76.24) v1(193.64,47.3) v1(194.02,44.27) v1(194.06,75.31) v1(194.23,5.74) v1(194.53,44.83) v1(194.86,77.76) v1(194.81,27.54) v1(194.95,74.39) v1(195.17,90.35) v1(195.21,59.56) v1(195.71,76.82) v1(195.85,73.49) v1(195.9,47.15) v1(196.01,64.65) v1(196.44,109.2) v1(196.81,88.42) v1(196.77,64.62) v1(197.02,91.52) v1(197.2,20.4) v1(197.51,64.63) v1(197.95,93.93) v1(198,79.01) v1(198.06,46.79) v1(198.18,88.42) v1(198.29,91.54) v1(198.29,64.62) v1(198.39,95.67) v1(198.95,80.98) v1(199.04,64.63) v1(199.35,93.93) v1(199.56,21.11) v1(199.59,91.54) v1(199.57,88.45) v1(199.69,95.71) v1(199.92,80.11) v1(199.97,84.51) v1(200.01,82.37) v1(199.97,81.53) v1(200.07,100.51) v1(200.1,67.31) v1(200.51,87.9) v1(200.63,83.77) v1(200.73,23.5) v1(200.84,79.22) v1(200.88,91.54) v1(201.29,20.07) v1(201.75,109.2) v1(201.85,35.13) v1(201.95,64.16) v1(202.33,22.58) v1(202.38,20.07) v1(202.51,62.59) v1(202.48,35.13) v1(202.84,42.07) v1(202.88,46.56) v1(202.97,63.81) v1(203.12,36.4) v1(203.12,35.77) v1(203.12,35.13) v1(203.12,34.5) v1(203.12,33.86) v1(203.27,16.23) v1(203.55,23.55) v1(203.75,35.13) v1(203.83,19.66) v1(203.88,109.24) v1(203.95,14.84) v1(204.08,63.88) v1(204.33,72.55) v1(204.27,48.16) v1(204.39,35.13) v1(204.69,43.61) v1(204.82,22.46) v1(204.87,42.24) v1(204.87,6.45) v1(205.15,9.91) v1(205.26,97.41) v1(205.53,84.75) v1(205.49,47.98) v1(205.66,19.21) v1(205.67,20.43) v1(205.99,63.88) v1(206.4,84.75) v1(207.12,44.96) v1(207.26,84.75) v1(207.31,42.12) v1(207.77,47.3) v1(208,58.62) v1(208.12,84.75) v1(208.63,57.38) v1(208.96,109.24) v1(211.17,55.26) v1(211.55,67.47) v1(211.76,2.85) v1(211.96,15.47) v1(212.22,0.76) v1(212.29,84.64) v1(212.59,105.51) v1(213.15,84.64) v1(213.35,64.09) v1(214.04,109.24) v1(217.3,0.76) v1(218.54,73.15) v1(219.22,69.48) v1(219.73,106.2) v1(220.16,2.65) v1(220.74,4.17) v1(220.9,78.79) v1(221.56,7.78) v1(221.89,109.22) v1(221.88,70.72) v1(221.91,47.88) v1(221.94,47.22) v1(221.89,37.37) v1(221.91,36.73) v1(222.02,95.84) v1(222.19,92.1) v1(222.38,0.76) v1(222.65,101.93) v1(224.2,109.24) v1(224.53,105.46) v1(224.53,102.03) v1(224.53,97.77) v1(224.53,92.97) v1(224.53,89.28) v1(224.53,85.8) v1(224.53,82.07) v1(224.53,75.92) v1(224.53,70.39) v1(224.53,64.16) v1(224.53,58.55) v1(224.53,53.52) v1(224.5,47.2) v1(224.53,40.31) v1(224.53,35.72) v1(224.53,32.13) v1(224.53,26.42) v1(224.53,19.92) v1(224.53,14.71) v1(224.53,9.58) v1(224.53,4.35) v1(224.48,0.87) v2(19.12,47.25) v2(23.44,58.35) v2(27.83,62.21) v2(28.98,9.78) v2(36.04,87.2) v2(37.71,88.09) v2(38.3,90.4) v2(39.34,66.93) v2(44.83,17.22) v2(45.79,56.64) v2(52.37,73.48) v2(53.89,70.16) v2(55.29,80.37) v2(56.33,57.79) v2(57.66,3.42) v2(60.55,18.82) v2(62.86,67.59) v2(63.06,56.34) v2(63.75,92.41) v2(67.71,70.21) v2(70.48,87.38) v2(74.77,77.88) v2(96.62,44.27) v2(107.06,96.78) v2(108.86,47.58) v2(118.41,6.48) v2(124.63,100.76) v2(126.28,100.74) v2(126.92,98.63) v2(127.12,16.61) v2(135.2,8.31) v2(142.87,30.89) v2(146.12,87.81) v2(146.22,56.21) v2(150.57,83.54) v2(152.82,13.88) v2(154.63,95.41) v2(155.87,98.07) v2(161.97,84.56) v2(167.91,30.69) v2(172.69,19.76) v2(179.85,45.42) v2(187.62,98.17) v2(188.03,83.9) v2(191.61,49.89) v2(198.98,46.99) v2(203.5,64.42) v2(204.97,107.04) v2(211.3,53.6) v2(219.48,105.06) v2(220.16,103.69) v2(222.14,56.37) v2(222.17,73) v2(222.4,94.77) v2(222.78,72.27) v3(18.13,83.98) v3(18.96,84.16) v3(20.34,94.54) v3(20.34,93.7) v3(21.18,94.54) v3(21.18,93.7) v3(39.77,1.83) v3(39.92,10.11) v3(40.61,1.83) v3(40.81,10.11) v3(41.45,1.83) v3(41.83,10.11) v3(42.29,1.83) v3(42.72,9.98) v3(43.12,1.83) v3(43.86,9.96) v3(43.96,1.83) v3(44.8,1.83) v3(47.24,58.12) v3(48.08,58.12) v3(50.68,8.87) v3(50.68,8) v3(54.1,67.08) v3(54.43,69.07) v3(54.78,79.58) v3(54.96,67.08) v3(55.42,76.58) v3(55.67,79.33) v3(55.67,78.44) v3(55.72,58.98) v3(55.92,56.9) v3(58.41,6.23) v3(59.23,5.92) v3(61.23,68.58) v3(61.34,70.26) v3(61.31,69.42) v3(62.15,69.42) v3(62.07,68.58) v3(62.17,70.26) v3(63.04,69.42) v3(62.96,68.58) v3(63.09,70.26) v3(63.81,68.58) v3(63.93,70.26) v3(63.88,69.42) v3(63.93,55.43) v3(64.65,68.58) v3(64.72,69.42) v3(64.79,70.26) v3(64.76,55.43) v3(65.63,70.26) v3(65.56,69.42) v3(65.6,55.43) v3(66.44,55.43) v3(81.12,13.03) v3(82.11,13.03) v3(88.45,101.55) v3(88.4,100.69) v3(90.95,101.52) v3(92.46,75.4) v3(93.3,75.4) v3(94.14,75.4) v3(94.98,75.4) v3(95.81,75.4) v3(96.65,75.4) v3(97.49,75.4) v3(98.33,75.4) v3(99.19,73.64) v3(99.19,72.8) v3(99.19,71.96) v3(99.19,71.12) v3(100.32,69.8) v3(105.45,75.85) v3(105.45,75.01) v3(105.45,74.17) v3(105.45,73.33) v3(105.45,72.49) v3(105.45,71.66) v3(105.45,70.82) v3(108.12,97.01) v3(109.01,97.01) v3(111.7,75.69) v3(111.7,74.86) v3(111.7,74.02) v3(111.7,73.18) v3(122.83,101.86) v3(123.13,10.26) v3(123.18,11.1) v3(123.3,102.61) v3(123.59,9.53) v3(123.67,101.86) v3(124.14,102.61) v3(124.12,10.95) v3(124.2,10.11) v3(124.54,103.35) v3(124.51,101.86) v3(124.98,102.61) v3(125.34,101.86) v3(125.38,103.35) v3(125.44,97.69) v3(125.57,99.7) v3(125.82,102.61) v3(126.22,103.35) v3(126.18,101.86) v3(126.28,97.69) v3(126.46,99.7) v3(126.66,102.61) v3(127.06,103.35) v3(127.02,101.86) v3(127.12,97.69) v3(127.2,17.45) v3(127.4,99.7) v3(127.49,102.59) v3(127.86,101.84) v3(127.89,103.33) v3(127.96,97.69) v3(128.04,17.45) v3(128.87,17.45) v3(129.71,17.45) v3(130.55,17.45) v3(131.39,17.45) v3(132.23,17.45) v3(133.09,17.45) v3(133.93,17.45) v3(135.12,101.22) v3(135.12,100.38) v3(135.15,99.49) v3(135.1,5.77) v3(135.12,4.88) v3(135.17,6.94) v3(135.93,5.77) v3(135.96,101.22) v3(135.96,100.38) v3(135.99,99.49) v3(136.01,4.9) v3(136.8,101.22) v3(136.8,100.38) v3(136.82,99.49) v3(136.9,5.72) v3(136.98,4.85) v3(137.64,101.27) v3(137.69,100.33) v3(137.71,99.44) v3(138.47,101.27) v3(138.53,100.33) v3(138.55,99.44) v3(139.31,101.32) v3(139.36,100.33) v3(139.39,99.44) v3(145.74,9.07) v3(146.65,9.05) v3(146.94,61.11) v3(146.91,60.25) v3(146.91,59.39) v3(147.52,9.1) v3(147.75,60.89) v3(147.72,58.96) v3(148.34,103.84) v3(148.36,9.12) v3(148.41,103) v3(149.41,103.84) v3(149.47,103) v3(149.57,4.73) v3(150.41,4.75) v3(151.3,4.75) v3(152.17,4.7) v3(152.51,105.44) v3(152.52,104.04) v3(152.52,103.2) v3(153.16,94.9) v3(153.35,105.41) v3(153.36,104.07) v3(153.38,103.23) v3(153.45,100.66) v3(153.37,99.24) v3(153.46,101.81) v3(153.47,97.69) v3(153.47,96.42) v3(153.99,94.9) v3(154.25,99.22) v3(154.35,101.79) v3(154.32,100.65) v3(154.35,97.72) v3(154.35,96.4) v3(155.59,53.72) v3(155.59,52.81) v3(156.51,53.72) v3(156.51,52.81) v3(157.26,61.14) v3(157.3,62.89) v3(157.3,62.05) v3(179.42,47.9) v3(180.26,47.96) v3(180.23,47.12) v3(180.97,46.28) v3(181.15,47.96) v3(181.07,47.12) v3(187.57,59.15) v3(189.5,48.77) v3(190.39,48.75) v3(191.31,48.77) v3(192.3,48.69) v3(199.87,48.19) v3(199.89,47.32) v3(200.73,48.19) v3(200.76,47.3)
