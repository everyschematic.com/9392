# Allegro board 17859-1.0710WZS1337.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ESPI_CS#: length 163.7
  TOP w0.089: U2401.58 35.58,53.57 38.53,56.51 38.53,56.9 v1(38.6,56.97) ; v1(126.31,41.53) 126.31,38.89 122.07,34.65 74.71,34.65 71.95,37.41 v2(71.45,37.41) 63.96,37.41 v1(63.39,37.98)
  L3 w0.114: v1(36.24,40.74) 37.43,41.94 37.43,43.97 36.82,44.58 36.82,45.65 36.19,46.28 36.19,47.37 36.37,47.55 36.37,47.6 36.52,47.75 36.52,47.83 36.7,48.01 36.7,48.42 37.21,48.92 37.21,51.11 36.54,51.77 36.54,52.2 36.6,52.25 36.95,52.25 37.23,52.53 37.23,52.89 36.54,53.57 36.54,54.54 38.07,56.06 38.07,56.06 38.6,56.6 v1(38.6,56.97)
  L6 w0.089: v1(126.31,41.53) 126.31,41.84 125.93,42.22 125.93,50.09 125.52,50.5 125.52,51.67 125.14,52.05 125.14,52.86 122.22,55.78 121.51,55.78 120.57,56.72 120.57,58.19 116.76,62 116.76,67.13 117.06,67.44 117.47,67.44 118.05,68.02 121.89,68.02 122.14,67.77 122.14,67.43 v1(122.62,66.95)
  BOTTOM w0.089: v1(38.6,56.97) 38.6,56.89 38.59,56.87 DBG1.5 ; v1(36.24,40.74) 36.67,41.18 37.81,41.18 38.55,40.44 39.67,40.44 40.38,41.15 41.62,41.15 41.85,40.92 43.94,40.92 44.39,40.46 48.13,40.46 48.33,40.67 52.47,40.67 52.83,40.31 52.88,40.31 52.9,40.29 54.5,40.29 54.76,40.54 56.33,40.54 57.02,39.86 58.24,39.86 58.64,39.45 59.02,39.45 59.51,38.97 62.4,38.97 v1(63.39,37.98) ; v1(122.62,66.95) 122.34,67.23 CPU1.CA28
ESPI_IO0: length 141.6
  TOP w0.089: RN1806.8 126.41,47.7 125.9,47.2 125.9,42.12 125.6,41.81 125.6,38.94 121.86,35.21 74.95,35.21 70.36,39.8 v2(68.29,39.8) 66.83,39.8 66.73,39.69 66.73,38.81 66.63,38.71 66.48,38.71 66.38,38.81 66.38,39.69 66.27,39.8 66.12,39.8 66.02,39.69 66.02,38.74 65.92,38.63 65.77,38.63 65.66,38.74 65.66,39.69 65.56,39.8 65.31,39.8 65.21,39.7 65.21,39.11 65.12,39.02 v1(64.64,39.02) ; v1(37.68,57.1) 37.68,56.18 35.18,53.68 U2401.59
  L3 w0.114: v1(34.82,42.55) 35.12,42.25 36.45,42.25 36.93,42.73 36.93,43.86 36.8,43.99 36.8,44.07 36.44,44.43 36.44,45.49 35.81,46.13 35.81,47.53 35.99,47.7 35.99,47.75 36.14,47.91 36.14,47.98 36.32,48.16 36.32,48.57 36.82,49.08 36.82,50.96 36.16,51.62 36.16,54.69 37.68,56.21 v1(37.68,57.1)
  BOTTOM w0.089: DBG1.9 34.59,56.77 35.93,58.11 36.06,58.11 36.06,58.12 36.85,58.12 37.68,57.29 v1(37.68,57.1) ; v1(64.64,39.02) 63.81,39.85 59.78,39.85 58.93,40.69 57.35,40.69 56.66,41.38 54.45,41.38 54.2,41.13 53.21,41.13 52.59,41.74 49.93,41.74 49.15,42.52 44.22,42.52 44.06,42.67 40.48,42.67 39.88,42.07 38.98,42.07 38.65,42.4 34.97,42.4 v1(34.82,42.55)
ESPI_IO1: length 139.8
  TOP w0.089: RN1806.6 125.32,42.32 125.09,42.09 125.09,42.07 125.04,42.01 125.04,39.14 122.19,36.3 108.2,36.3 107.74,36.76 101.98,36.76 100.98,35.77 76.61,35.77 v2(73.78,38.6) 73.27,39.1 73.13,39.1 72.55,38.53 72.41,38.53 72.3,38.63 72.3,38.78 72.87,39.35 72.87,39.5 72.77,39.61 72.62,39.61 72.05,39.03 71.9,39.03 71.8,39.14 71.8,39.28 72.37,39.86 72.37,40 72.27,40.11 72.12,40.11 71.55,39.54 71.4,39.54 71.3,39.64 71.3,39.79 71.87,40.36 71.87,40.51 71.68,40.7 71.14,40.7 71.03,40.8 71.03,41.53 70.93,41.64 70.78,41.64 70.68,41.53 70.68,40.8 70.57,40.7 70.43,40.7 70.32,40.8 70.32,41.53 70.22,41.64 70.07,41.64 69.97,41.53 69.97,40.8 69.86,40.7 69.72,40.7 69.61,40.8 69.61,41.53 69.51,41.64 69.36,41.64 69.26,41.53 69.26,40.8 69.15,40.7 66.87,40.7 v1(65.95,41.61) ; v1(37.05,57.11) 37.05,55.95 34.78,53.69 U2401.60
  L3 w0.114: v1(37.05,57.11) 37.05,56.16 35.78,54.89 35.78,51.46 36.44,50.8 36.44,49.23 35.94,48.72 35.94,48.31 35.76,48.14 35.76,48.06 35.6,47.91 35.6,47.86 35.43,47.68 35.43,45.98 36.06,45.34 36.06,44.27 36.42,43.92 36.42,43.82 36.47,43.77 v1(36.47,43.34)
  BOTTOM w0.089: DBG1.8 35.59,57.24 36.19,57.85 36.74,57.85 37.05,57.53 37.05,57.11 v1(37.05,57.11) ; v1(36.47,43.34) 36.6,43.21 40.2,43.21 40.23,43.23 44.29,43.23 44.32,43.21 45.79,43.21 45.87,43.13 49.35,43.13 50.21,42.27 53.02,42.27 53.11,42.36 55.11,42.36 55.67,42.93 55.7,42.93 55.76,42.99 57.74,42.99 58.55,42.17 65.39,42.17 v1(65.95,41.61)
ESPI_IO2: length 135.2
  TOP w0.089: v1(36.06,56.82) 36.06,56.11 34.38,54.43 U2401.61 ; RN1806.7 125.82,47.5 125.62,47.3 125.62,42.24 125.37,41.99 125.37,41.96 125.32,41.91 125.32,39.04 122.3,36.02 108.1,36.02 107.64,36.48 102.08,36.48 101.09,35.49 75.07,35.49 70.19,40.37 v2(66.13,40.37) 64.98,40.37 64.88,40.27 64.88,39.65 64.77,39.54 64.63,39.54 64.52,39.65 64.52,40.27 64.42,40.37 64.18,40.37 64.08,40.27 64.08,39.22 63.99,39.13 63.81,39.13 63.72,39.22 63.72,41.11 63.81,41.2 v1(65.47,41.2)
  L3 w0.114: v1(36.06,56.82) 36.06,55.83 35.4,55.17 35.4,51.31 36.06,50.65 36.06,49.38 35.55,48.87 35.55,48.47 35.38,48.29 35.38,48.21 35.22,48.06 35.22,48.01 35.05,47.83 35.05,45.82 35.68,45.19 35.68,44.12 36.04,43.77 36.04,43.41 36.01,43.39 v1(36.01,42.83)
  BOTTOM w0.089: DBG1.7 36.59,56.3 v1(36.06,56.82) ; v1(36.01,42.83) 36.11,42.92 36.27,42.92 36.29,42.9 36.65,42.9 36.67,42.92 40.32,42.92 40.35,42.95 44.16,42.95 44.2,42.92 45.67,42.92 45.79,42.8 49.27,42.8 50.06,42.01 54.66,42.01 54.73,41.94 56.49,41.94 57.27,42.73 57.63,42.73 58.44,41.91 64.76,41.91 v1(65.47,41.2)
ESPI_IO3: length 135.8
  TOP w0.089: U2401.62 33.98,51.79 34.11,51.93 34.11,55.47 36.06,57.42 v1(36.49,57.42) ; RN1806.5 124.73,47.86 125.04,47.55 125.04,42.52 124.81,42.29 124.81,42.17 124.76,42.12 124.76,39.25 122.09,36.58 108.32,36.58 107.87,37.04 101.87,37.04 100.88,36.05 76.91,36.05 v2(73.21,39.74) 71.05,41.91 68.93,41.91 68.82,41.8 68.82,41.11 68.72,41 68.57,41 68.47,41.11 68.47,41.8 68.36,41.91 68.22,41.91 68.11,41.8 68.11,41.11 68.01,41 67.86,41 67.76,41.11 67.76,41.8 67.65,41.91 67.5,41.91 67.4,41.8 67.4,41.11 67.3,41 67.15,41 67.04,41.11 67.04,41.8 66.94,41.91 66.59,41.91 v1(66.35,42.14)
  L3 w0.114: v1(35.2,43.08) 35.25,43.13 35.25,43.28 35.12,43.41 35.12,43.77 35.25,43.89 35.25,44.63 35.17,44.71 35.17,45.09 35.16,45.1 35.16,45.18 34.67,45.67 34.67,47.98 34.84,48.16 34.84,48.21 35,48.36 35,48.44 35.17,48.62 35.17,49.02 35.68,49.53 35.68,50.5 35.02,51.16 35.02,55.4 35.5,55.88 35.5,57.1 35.82,57.42 v1(36.49,57.42)
  BOTTOM w0.089: v1(66.35,42.14) 66.05,42.44 58.67,42.44 58.01,43.1 58.01,43.11 57.86,43.26 55.62,43.26 55.15,42.79 53.52,42.79 53.18,43.13 52.03,43.13 51.65,42.75 50.13,42.75 49.47,43.41 45.97,43.41 45.89,43.49 44.42,43.49 44.39,43.51 40.13,43.51 40.1,43.49 39.47,43.49 39.2,43.76 36.29,43.76 36.01,43.48 36.01,43.43 35.66,43.08 v1(35.2,43.08) ; DBG1.6 37.59,56.33 37.25,56.67 36.87,56.67 36.49,57.05 v1(36.49,57.42)
ESPI_RESET#: length 163
  TOP w0.089: v1(63.95,38.43) 64.28,38.11 v2(64.8,38.11) 66.91,38.11 67.01,38.21 67.01,39.41 67.12,39.51 67.27,39.51 67.37,39.41 67.37,38.08 67.47,37.98 67.62,37.98 67.73,38.08 67.73,39.33 67.83,39.43 67.98,39.43 68.08,39.33 68.08,38.08 68.19,37.98 68.33,37.98 68.44,38.08 68.44,39.36 68.54,39.46 68.69,39.46 68.79,39.36 68.79,38.08 68.89,37.98 69.34,37.98 69.45,38.08 69.45,38.75 69.55,38.86 69.7,38.86 69.8,38.75 69.8,37.93 69.91,37.83 70.05,37.83 70.16,37.93 70.16,39.25 70.26,39.36 70.41,39.36 70.51,39.25 70.51,38.21 70.62,38.11 71.67,38.11 74.85,34.93 121.96,34.93 125.88,38.84 125.88,41.71 126.18,42.01 126.18,47.09 126.81,47.72 126.81,49.85 125.4,51.27 125.4,55.88 125.19,56.09 125.19,61.14 122.83,63.51 122.83,64.66 122.25,65.24 122.25,65.72 122.45,65.92 122.83,65.92 123.06,66.14 123.06,67.18 v1(122.65,67.59) ; U2401.53 37.58,51.76 37.76,51.95 38.45,51.95 39.57,53.06 40.89,53.06 41.86,54.03 v1(41.86,54.54) 42.29,54.97 42.29,56.44 42.44,56.59 42.44,57.13 v1(41.96,57.61)
  L3 w0.114: v1(41.86,54.54) 41.51,54.19 41.51,53.8 40.68,52.97 40.06,52.97 39.87,52.78 39.87,52.02 39.59,51.74 39.56,51.74 39.03,51.22 39.03,50.75 39.49,50.29 39.49,49.94 39.53,49.9 39.53,49.69 39.75,49.48 39.75,49.3 40.02,49.02 40.25,49.02 41.22,48.06 41.22,47.75 41.47,47.5 41.47,41.91 v1(42.03,41.35)
  BOTTOM w0.089: v1(63.95,38.43) 63.95,38.5 63.2,39.25 59.61,39.25 58.72,40.13 57.12,40.13 56.43,40.82 54.65,40.82 54.4,40.57 53,40.57 52.5,41.07 46.4,41.07 46.1,40.77 44.57,40.77 43.99,41.35 v1(42.03,41.35) ; DBG1.4 39.59,56.72 39.97,57.1 40.74,57.1 41.24,57.61 v1(41.96,57.61) ; CPU1.CA27 v1(122.65,67.59)
EXT_PWR_GATE#: length 103.6
  TOP w0.102: 144.82,64.82 144.67,64.67 143.02,64.67 141.7,63.35 141.7,61.87 v1(142.11,61.47)
  L3 w0.102: v1(142.11,61.47) 142.91,61.47 144.98,59.4 144.98,58.47 152.7,50.75 156.18,50.75 156.59,50.35 156.59,49.66 159.2,47.04 159.2,45.93 160.45,44.68 161.46,44.68 162.3,43.84 162.3,42.36 v1(167.3,37.35)
  L6 w0.102: v1(123.34,59.85) 123.46,59.85 123.75,59.55 123.75,57.36 127.18,53.93 127.18,53.92 127.41,53.69 127.41,53.45 127.96,52.9 127.96,51.56 128.19,51.34 128.57,51.34 135.33,44.58 135.33,44.3 135.58,44.05 135.58,43.1 136.1,42.58 136.1,41.16 140.36,36.9 166.85,36.9 v1(167.3,37.35)
  BOTTOM w0.076: v1(123.34,59.85) 123.34,59.86 123.33,59.88 123.33,60.31 123.23,60.4 123.23,61.37 123.36,61.5 CPU1.CC37
  BOTTOM w0.102: v1(142.11,61.47) 142.11,61.47 v2(142.11,60.63)
FALL_INT2: length 4.1
  TOP w0.102: v2(214.12,62.36) 214.12,61.57 R7018.2 214.61,61.05 Q7001.3 215.9,61.05 216.05,61.19 216.05,61.57 215.92,61.7 Q7001.2
FAN1_PWM: length 259.1
  TOP w0.102: v1(221.15,64.85) 221.07,64.76 RN2603.1 220.32,64.17 219.83,63.68 AFTP2602.1 ; v1(39.95,50.11) 39.98,50.14 U2401.47
  L3 w0.102: v1(39.95,50.11) 40.18,50.11 41.09,49.2 41.09,49.2 41.83,48.47 41.83,47.91 41.85,47.88 41.85,42.73 42.46,42.12 42.46,40.34 42.26,40.13 42.26,37.4 v1(41.85,36.99)
  L6 w0.102: v1(216.94,28.78) 216.88,28.83 206.91,28.83 205.58,30.16 202.47,30.16 201.85,29.54 194.59,29.54 193.22,30.91 191.26,30.91 190.32,31.85 185.06,31.85 183.69,33.23 179.65,33.23 178.73,34.14 177.39,34.14 176.15,35.38 172.76,35.38 172.2,34.81 172.2,34.57 v1(171.11,33.48)
  BOTTOM w0.102: v1(41.85,36.99) 42.48,37.62 44.62,37.62 45.13,37.11 45.13,37.11 45.26,36.99 48.97,36.99 49.14,36.81 50.49,36.81 51.61,35.69 57.82,35.69 58.43,35.08 65.17,35.08 68.4,31.85 153.88,31.85 154.64,32.61 170.25,32.61 v1(171.11,33.48) ; v1(221.15,64.85) 219.3,63 FAN1.4 216.24,62.4 218.15,60.48 220.31,60.48 221.48,59.31 221.48,58.88 222.37,57.99 222.37,53.17 222.98,52.56 222.98,26.52 220.77,24.31 217.56,24.31 216.66,25.21 216.66,28.5 v1(216.94,28.78)
FAN1_TACH: length 252.6
  TOP w0.203: v1(42.72,49.86) 42.72,49.89 42.78,49.95 U2401.40
  TOP w0.254: v1(221.07,62.89) RN2603.2 ; v1(218,64.11) 217.95,64.16 AFTP2601.1
  L3 w0.254: v1(43.43,36.95) 43.43,37.37 42.8,38 42.8,39.92 42.97,40.09 42.97,45.06 43.5,45.6 43.5,48.64 42.72,49.43 v1(42.72,49.86)
  L4 w0.254: v1(218,64.11) 219.23,62.89 v1(221.07,62.89)
  L6 w0.254: v1(172.62,32.81) 172.62,33.29 173.7,34.37 175.84,34.37 176.98,33.23 177.26,33.23 178.3,32.18 182.77,32.18 184.71,30.25 188.41,30.25 188.67,30 192.59,30 194.06,28.53 199.64,28.53 202.85,25.31 205.85,25.31 207.67,27.13 210.02,27.13 210.4,27.51 215.39,27.51 215.69,27.21 215.69,25.53 v1(217.11,24.11)
  BOTTOM w0.254: FAN1.3 217.89,64 v1(218,64.11) ; v1(172.62,32.81) 171.71,31.9 154.93,31.9 154.18,31.14 61.44,31.14 59.81,32.77 58.43,32.77 56.2,35 51.58,35 51.52,35.05 51.51,35.05 50.26,36.3 48.91,36.3 48.74,36.48 43.9,36.48 v1(43.43,36.95) ; v1(217.11,24.11) 217.21,24.01 220.9,24.01 223.29,26.4 223.29,52.68 222.68,53.29 222.68,62.39 222.18,62.89 v1(221.07,62.89)
FB_CAL_PD_VDDQ: length 7.1
  TOP w0.508: v1(195.17,83.3) 195.55,82.92 195.55,80.74 196.24,80.06 196.24,79.71 v2(197,78.94) 197.94,78.01 R7805.1
  BOTTOM w0.254: GPU1.D22 v1(195.17,83.3)
FB_CAL_PU_GND: length 2.9
  TOP w0.508: v1(196.36,83.33) 196.29,83.25 196.29,82.15 196.69,81.74 R7807.1
  BOTTOM w0.254: GPU1.C24 196.39,83.36 v1(196.36,83.33)
FB_CAL_TERM_GND: length 1.4
  TOP w0.508: v1(196.95,83.93) 196.95,83.87 R7806.1
  BOTTOM w0.203: v1(196.95,83.93) 196.96,83.93 GPU1.B25
FB_CLAM: length 5.4
  TOP w0.254: R7818.1 181.07,69.37 v2(181.53,69.37) 181.81,69.65 181.81,70.03 182.32,70.55 v1(182.32,72.85)
  BOTTOM w0.254: GPU1.F3 v1(182.32,72.85)
FB_VREF: length 8.6
  TOP w0.089: TP7801.1 195.14,79.23 195.14,82.61 194.61,83.14 v1(194.61,83.85)
  BOTTOM w0.089: 195.23,83.9 194.66,83.9 v1(194.61,83.85)
FBA0_MF: length 2.8
  TOP w0.102: R8112.2 210.31,80.63 v1(210.43,80.51)
  BOTTOM w0.102: v2(210.43,81.26) v1(210.43,80.51) 210.43,79.23 VRAM1.J1
FBA0_SEN: length 2.3
  TOP w0.102: v2(209.93,73.26) 210.49,72.7 v1(210.49,72.62) 210.1,72.24 R8109.2
  BOTTOM w0.102: VRAM1.J10 210.46,72.6 v1(210.49,72.62)
FBA0_VREFC: length 69.7
  TOP w0.305: R8103.1 207.79,107.04 C8136.1 207.79,105.77 v1(207.94,105.62) 207.72,105.39 v2(207.08,105.39)
  TOP w0.508: v1(207.94,105.62) 207.97,105.59 R8101.2 209.29,105.59 R8102.2 ; v1(210.21,67.49) 210.21,67.31 210.69,66.83 212.13,66.83 212.16,66.8 212.24,66.8 213.46,65.59 213.46,64.9 214.09,64.26 v1(214.09,63.66)
  L4 w0.508: v1(207.94,105.62) 208.83,104.73 216.07,104.73 222.96,97.84 222.96,69.42 218.69,65.15 217.72,65.15 216.14,63.57 214.17,63.57 v1(214.09,63.66)
  BOTTOM w0.305: v1(210.21,67.49) 210.21,68.05 210.46,68.3 VRAM1.J14
FBA0_ZQ1: length 4.2
  TOP w0.254: R8107.1 210.51,66.3 209.72,67.08 v2(209.72,68.4) 209.72,68.86 v1(210.08,69.22)
  BOTTOM w0.254: v1(210.08,69.22) VRAM1.J13
FBA1_MF: length 3.2
  TOP w0.102: v2(210.79,86.9) 210.79,87.81 R8111.1 210.76,88.5 v1(210.92,88.65)
  BOTTOM w0.102: v1(210.92,88.65) 210.89,88.65 210.46,89.08 VRAM4.J1
FBA1_SEN: length 2.2
  TOP w0.102: v1(210.47,96.37) 210.47,95.77 v2(210.48,95.76) 210.46,95.74 R8110.2
  BOTTOM w0.102: v1(210.47,96.37) 210.47,96.99 VRAM4.J10
FBA1_VREFC: length 5.1
  TOP w0.305: v2(212.16,101.91) 211.83,101.58 R8104.2
  TOP w0.356: R8106.1 210.2,100.36 C8140.1 210.08,100.87 v1(210.31,101.09) 210.38,101.17 R8105.2 211.2,101.17 211.35,101.02 R8104.2
  BOTTOM w0.305: VRAM4.J14 210.46,100.56 210.31,100.71 210.31,101.04 210.31,101.04 v1(210.31,101.09)
FBA1_ZQ3: length 4.5
  TOP w0.254: v1(209.14,101.32) 208.66,100.84 R8108.1 v2(208.3,99.93)
  BOTTOM w0.152: v1(209.14,101.32) 209.19,101.32 210.05,100.46 210.05,99.81 VRAM4.J13
FBA_CLK0_MIDPT: length 1.5
  TOP w0.114: C8142.1 210.31,64.82 R8113.2 R8114.2
FBA_CLK0N: length 38
  TOP w0.114: R8113.1 209.34,65.95 209.34,66.04 v1(209.65,66.35)
  L3 w0.112: v1(210.85,70.82) 210.64,70.82 210.41,71.05 210.41,71.46 210,71.86 210,73.12 210.11,73.23 211.96,73.23 212.2,73.48 212.2,74.46 211.83,74.83 208.48,74.83 208.17,74.52 208.17,74.12 207.98,73.94 207.73,73.94 207.55,74.12 207.55,74.52 207.23,74.83 201.52,74.83 195.83,80.52 195.83,83.89 v1(195.81,83.9)
  L6 w0.112: v1(209.65,66.35) 209.35,66.64 209.35,67.27 209.83,67.74 209.83,68.53 209.54,68.81 209.54,69.38 209.87,69.7 210.1,69.7 210.56,70.17 210.56,70.37 210.56,70.53 v1(210.85,70.82)
  BOTTOM w0.114: VRAM1.J11 210.47,71.2 v1(210.85,70.82) ; v1(195.81,83.9) 195.81,83.96 196.39,84.54 GPU1.D25
FBA_CLK0P: length 37.5
  TOP w0.114: R8114.1 208.83,66.3 v1(208.78,66.35)
  L3 w0.112: v1(210.05,70.82) 210.18,70.95 210.18,71.36 209.78,71.77 209.78,73.21 210.02,73.46 211.86,73.46 211.98,73.57 211.98,74.37 211.74,74.61 208.57,74.61 208.39,74.42 208.39,74.03 208.08,73.71 207.63,73.71 207.32,74.03 207.32,74.42 207.14,74.61 201.43,74.61 195.6,80.43 195.6,83.47 195.25,83.82 v1(195.25,84.45)
  L6 w0.112: v1(208.78,66.35) 209.13,66.69 209.13,67.37 209.6,67.84 209.6,68.44 209.32,68.72 209.32,69.47 209.77,69.93 210,69.93 210.34,70.26 210.34,70.37 210.34,70.53 v1(210.05,70.82)
  BOTTOM w0.114: VRAM1.J12 210.46,70.41 v1(210.05,70.82) ; v1(195.25,84.45) 195.26,84.45 195.31,84.5 GPU1.D24
FBA_CLK1_MIDPT: length 2.2
  TOP w0.114: R8115.2 R8116.2 207.92,103.51 C8141.1
FBA_CLK1N: length 40.4
  TOP w0.114: v1(210.16,101.98) 210.08,102.06 R8115.1
  L3 w0.112: v1(210.16,101.98) 209.89,101.72 209.89,100.55 210.78,99.66 210.78,98.75 210.55,98.51 210.38,98.5 210.35,98.5 v1(210.08,98.2) 209.6,98.63 208.69,98.63 208.4,98.92 208.4,101.54 208.18,101.76 197.49,101.76 191.43,95.7 191.43,93.04 188.34,89.95 188.34,89.35 189.06,88.63 v1(189.97,88.63)
  BOTTOM w0.114: v1(189.97,88.63) 190.17,88.43 190.17,88.16 190.06,88.05 GPU1.M22 ; VRAM4.J11 210.46,97.82 v1(210.08,98.2)
FBA_CLK1P: length 40.1
  TOP w0.114: v1(209.39,101.98) 209.32,102.06 R8116.1
  L3 w0.112: v1(189.41,88.05) 189.07,88.39 188.97,88.39 188.11,89.26 188.11,90.04 191.2,93.13 191.2,95.79 197.39,101.99 208.27,101.99 208.63,101.63 208.63,99.01 208.78,98.86 209.91,98.86 v1(210.04,99) 210.34,98.73 210.37,98.73 210.44,98.73 210.55,98.84 210.55,99.56 209.66,100.45 209.66,101.72 v1(209.39,101.98)
  BOTTOM w0.114: v1(189.41,88.05) 189.39,88.07 GPU1.N22 ; VRAM4.J12 210.06,99 v1(210.04,99)
FBA_CMD0: length 25
  TOP w0.114: v1(208.49,70.02) 208.48,70.03 203.42,70.03 202.91,70.54 202.91,71.91 200.03,74.8 200.03,78.19 199.06,79.16 199.06,79.28 197.75,80.59 197.75,81.96 198.12,82.32 198.12,83.8 196.95,84.97 v1(196.95,85.07)
  BOTTOM w0.114: GPU1.C27 197.96,85.5 197.38,85.5 v1(196.95,85.07) ; v1(208.49,70.02) 208.5,70.02 208.86,70.37 VRAM1.G12
FBA_CMD1: length 25.6
  TOP w0.114: v1(209.27,72.88) 208.86,72.88 208.57,73.17 202.18,73.17 200.39,74.95 200.39,78.42 197.96,80.85 197.96,81.82 198.64,82.49 v1(198.64,82.63)
  BOTTOM w0.102: 198.49,85.47 198.09,85.07 GPU1.C26
  BOTTOM w0.114: v1(198.64,82.63) 199.32,83.31 199.32,85.75 199.08,85.99 198.74,85.99 198.49,85.75 198.49,85.47 ; v1(209.27,72.88) 209.66,72.48 VRAM1.H10
FBA_CMD2: length 27
  TOP w0.114: v1(209.14,73.51) 209.11,73.54 202.33,73.54 200.76,75.11 200.76,78.58 198.19,81.15 198.19,81.7 198.55,82.06 198.65,82.06 199.07,82.48 199.07,83.51 198.83,83.75 198.47,83.75 197.37,84.86 197.37,85.24 197.12,85.48 196.78,85.48 196.37,85.08 v1(195.8,85.08)
  BOTTOM w0.114: v1(209.14,73.51) 209.34,73.51 210.05,72.8 210.05,71.61 209.66,71.21 VRAM1.H11 ; 195.23,85.1 195.78,85.1 v1(195.8,85.08)
FBA_CMD3: length 28.6
  TOP w0.114: v1(195.23,85.66) 195.66,86.08 196.51,86.08 196.89,85.7 197.21,85.7 197.58,85.33 197.58,84.95 198.56,83.97 198.96,83.97 199.34,83.59 199.34,81.57 199.8,81.11 200.16,81.11 201.37,79.91 201.37,79.68 201.73,79.32 201.73,78.46 201.13,77.86 201.13,75.26 202.45,73.94 209.85,73.94 210.9,72.89 210.9,71.61 v1(210.87,71.58)
  BOTTOM w0.114: v1(210.87,71.58) 210.88,71.58 VRAM1.K11 ; v1(195.23,85.66) 195.19,85.7 GPU1.F24
FBA_CMD4: length 27
  TOP w0.114: v1(211.38,72.63) 211.38,72.87 209.9,74.35 202.56,74.35 201.5,75.41 201.5,77.71 202.1,78.3 202.1,79.47 201.73,79.84 201.73,82.16 200.77,83.12 199.93,83.12 199.56,83.5 199.56,84.88 v1(199.95,85.27)
  BOTTOM w0.114: 197.53,86.2 197.79,86.46 199.22,86.46 199.95,85.73 v1(199.95,85.27) ; VRAM1.K10 211.38,72.12 v1(211.38,72.63)
FBA_CMD5: length 30.2
  TOP w0.114: v1(199.97,83.77) 200.4,83.34 201.32,83.34 202.18,82.48 202.18,79.91 202.91,79.18 202.91,77.87 201.87,76.82 201.87,75.94 203.06,74.74 210.6,74.74 212.45,72.9 212.45,71.59 v1(211.66,70.8)
  BOTTOM w0.114: v1(199.97,83.77) 199.79,83.77 199.54,84.03 199.54,85.84 199.17,86.21 198.07,86.21 197.66,85.81 197.13,85.81 GPU1.D26 ; v1(211.66,70.8) 211.66,70.8 VRAM1.L12
FBA_CMD6: length 28.8
  TOP w0.114: v1(211.73,75.26) 211.73,75.2 211.53,75 203.32,75 202.23,76.09 202.23,76.66 203.28,77.71 203.28,79.34 202.67,79.95 202.67,82.44 v1(200.6,84.51)
  BOTTOM w0.114: GPU1.F25 195.85,86.27 196.26,86.68 199.31,86.68 200.6,85.38 v1(200.6,84.51) ; v1(211.73,75.26) 211.65,75.34 211.65,76.41 211.26,76.8 VRAM1.K4
FBA_CMD7: length 25.8
  L6 w0.112: v1(200.6,81.31) 208.62,81.31 209.95,79.99 209.95,78.56 209.65,78.26 209.65,76.82 v1(210.9,75.57)
  BOTTOM w0.114: VRAM1.K5 210.9,75.64 v1(210.9,75.57) ; GPU1.F26 195.82,86.89 199.4,86.89 201.24,85.06 201.24,81.95 v1(200.6,81.31)
FBA_CMD8: length 24.4
  L6 w0.112: v1(210.86,77.22) 210.86,77.81 210.41,78.26 210.41,79.94 210,80.35 210,80.46 207.49,82.96 203.53,82.96 203.39,82.83 203.39,82.3 203.26,82.17 203.08,82.17 202.95,82.3 202.95,82.83 202.65,83.12 199.52,83.12 198.89,83.75 197.38,83.75 196.55,82.91 196.19,82.91 194.64,84.47 v1(194.64,85.06)
  BOTTOM w0.114: VRAM1.J4 210.46,76.82 v1(210.86,77.22) ; GPU1.F23 194.57,85.14 v1(194.64,85.06)
FBA_CMD9: length 31.4
  L6 w0.112: v1(193.48,85.14) 193.48,85.71 193.89,86.11 196.48,86.11 197.11,85.49 197.74,85.49 198.16,85.07 199.09,85.07 199.72,85.69 200.59,85.69 202.38,83.9 210.29,83.9 212.31,81.88 212.31,76.86 211.32,75.87 211.32,75.39 211.07,75.15 210.52,75.15 v1(210.1,75.57)
  BOTTOM w0.114: v1(193.48,85.14) 193.46,85.11 GPU1.G22 ; v1(210.1,75.57) 210.1,75.64 VRAM1.J5
FBA_CMD10: length 26.6
  L6 w0.112: v1(210.06,77.22) 210.48,76.81 211.83,76.81 212.08,77.05 212.08,79 211.74,79.33 211.53,79.33 210.87,79.99 210.87,80.66 208.17,83.35 199.64,83.35 198.97,84.03 197.57,84.03 197.06,84.54 195.75,84.54 194.59,85.7 v1(194.07,85.7)
  BOTTOM w0.114: VRAM1.H4 210.06,77.2 v1(210.06,77.22) ; GPU1.G23 194.06,85.7 v1(194.07,85.7)
FBA_CMD11: length 33.7
  L6 w0.112: v1(193.46,86.31) 193.78,86.63 208.07,86.63 213.31,81.4 213.31,80.12 212.84,79.65 212.84,77.03 212.87,77 212.87,75.75 212.78,75.66 212.78,75.37 212.26,74.85 209.93,74.85 v1(209.24,75.54)
  BOTTOM w0.114: GPU1.G24 193.51,86.27 v1(193.46,86.31) ; v1(209.24,75.54) 209.24,75.58 VRAM1.H5
FBA_CMD12: length 25.6
  TOP w0.114: v1(202.07,84.94) 202.73,84.94 202.86,85.08 202.86,85.47 202.99,85.6 203.18,85.6 203.32,85.47 203.32,85.08 203.45,84.94 204.08,84.94 205.57,83.45 205.76,83.45 206,83.7 206.19,83.7 206.32,83.56 206.32,83.37 206.08,83.13 206.08,82.94 207.03,81.99 207.22,81.99 208.01,82.78 208.2,82.78 208.33,82.65 208.33,82.46 207.54,81.67 207.54,81.48 207.68,81.34 207.86,81.34 208.81,82.29 209.02,82.29 209.16,82.15 209.16,81.99 208.19,81.02 208.19,80.83 208.76,80.26 208.76,78.3 v1(208.48,78.02)
  BOTTOM w0.114: v1(208.48,78.02) 208.86,77.64 VRAM1.G3 ; v1(202.07,84.94) 201.66,84.94 199.2,87.4 196.32,87.4
FBA_CMD13: length 28.9
  TOP w0.114: v1(201.3,86) 203.58,86 205.32,84.25 206.76,84.25 206.9,84.12 206.9,82.92 207.03,82.78 207.22,82.78 207.35,82.92 207.35,84.12 207.49,84.25 207.86,84.25 207.99,84.12 207.99,83.3 208.12,83.16 208.31,83.16 208.45,83.3 208.45,84.12 208.58,84.25 209.13,84.25 209.54,83.84 v1(209.54,79.82)
  BOTTOM w0.114: GPU1.G25 195.23,86.83 196.17,87.77 199.57,87.77 201.3,86.03 v1(201.3,86) ; R7820.2 209.34,80.01 v1(209.54,79.82) 209.55,79.82 210.05,79.32 210.05,78.81 VRAM1.J2
FBA_CMD14: length 31.3
  TOP w0.114: v1(210.86,78.82) 210.87,78.83 210.87,83.04 208.63,85.27 207.6,85.27 207.49,85.39 207.49,86.41 207.34,86.57 206.97,86.57 206.83,86.43 206.83,85.33 206.7,85.19 206.51,85.19 206.38,85.33 206.38,86.43 206.24,86.57 205.87,86.57 205.74,86.43 205.74,85.46 205.61,85.32 205.42,85.32 205.28,85.46 205.28,86.43 205.15,86.57 198.59,86.57 197.15,88.01 196.59,88.01 v1(196.15,88.44)
  BOTTOM w0.114: GPU1.G27 196.15,88.36 v1(196.15,88.44) ; R7816.1 211.63,81.35 210.86,80.58 v1(210.86,78.82) 210.86,78 VRAM1.J3
FBA_CMD15: length 26.7
  TOP w0.114: v1(197.48,88.44) 198.92,87 207.51,87 212.39,82.12 212.39,77.96 211.66,77.23 v1(211.66,77.22)
  BOTTOM w0.114: GPU1.G26 195.36,87.57 195.36,88.1 195.49,88.23 195.49,88.36 195.98,88.86 197.06,88.86 v1(197.48,88.44) ; VRAM1.L3 211.68,77.22 v1(211.66,77.22)
FBA_CMD16: length 27.2
  L3 w0.112: v1(209.24,98.22) 208.58,98.22 206.55,100.25 203.42,100.25 203.22,100.05 196.7,100.05 192.26,95.61 v1(192.26,90.91)
  BOTTOM w0.114: GPU1.M24 191.12,89.77 v1(192.26,90.91) ; VRAM4.L12 v1(209.24,98.22)
FBA_CMD17: length 43.6
  L3 w0.112: v1(209.84,96.41) 210.47,97.04 210.47,97.75 210.99,98.28 210.99,101.75 210.13,102.61 197.04,102.61 190.82,96.4 190.82,93.5 187.65,90.33 187.59,90.33 187.24,89.98 187.24,89.63 189.24,87.63 189.59,87.63 190.55,88.59 v1(190.55,89.21)
  BOTTOM w0.114: v1(209.84,96.41) 209.66,96.59 VRAM4.K10 ; v1(190.55,89.21) 190.55,89.2 GPU1.M23
FBA_CMD18: length 32
  L3 w0.112: v1(210.03,97.39) 209.62,97.8 208.68,97.8 206.79,99.68 206.31,99.68 206.18,99.55 206.18,98.74 206.05,98.61 205.86,98.61 205.73,98.74 205.73,99.55 205.6,99.68 205.42,99.68 205.29,99.55 205.29,98.74 205.16,98.61 204.97,98.61 204.84,98.74 204.84,99.55 204.71,99.68 196.87,99.68 192.53,95.34 192.53,91.24 192.68,91.09 192.68,89 v1(192.31,88.64)
  BOTTOM w0.114: VRAM4.K11 209.66,97.75 v1(210.03,97.39) ; GPU1.K24 192.31,88.63 v1(192.31,88.64)
FBA_CMD19: length 44.4
  L3 w0.112: v1(191.72,88.03) 191.07,88.03 190.44,87.4 189.14,87.4 189.01,87.54 186.64,89.9 186.64,90.57 187.18,91.1 187.18,91.1 189.78,93.7 189.78,95.9 196.86,102.97 210.29,102.97 211.22,102.04 211.22,97.72 v1(210.89,97.39)
  BOTTOM w0.114: v1(191.72,88.03) 191.74,88.01 GPU1.K23 ; v1(210.89,97.39) 210.89,97.43 VRAM4.H11
FBA_CMD20: length 27.9
  L3 w0.112: v1(211.2,96.19) 210.93,95.93 204.7,95.93 203.96,96.67 203.96,98.78 203.42,99.32 197.04,99.32 192.95,95.22 v1(192.95,92.09)
  BOTTOM w0.114: v1(192.95,92.09) 192.82,91.96 GPU1.M27 ; v1(211.2,96.19) 211.2,96.94 VRAM4.H10
FBA_CMD21: length 29.8
  L3 w0.112: v1(193.35,91.57) 193.41,91.63 193.41,95.14 196.67,98.41 201.84,98.41 202.41,97.84 203.47,97.84 203.73,97.59 203.73,96.57 204.6,95.7 211.3,95.7 211.68,96.08 211.68,98.19 v1(211.66,98.2)
  BOTTOM w0.114: v1(211.66,98.2) 212.06,98.6 VRAM4.G12 ; v1(193.35,91.57) 193.28,91.57 193.19,91.48 193.19,90.75 192.97,90.53 192.44,90.53 GPU1.M26
FBA_CMD22: length 27
  L3 w0.112: v1(210.87,92.61) 210.76,92.61 208.8,94.57 203.58,94.57 201.25,96.9 197.32,96.9 195.27,94.85 195.27,91.38 v1(194.8,90.91)
  BOTTOM w0.114: v1(210.87,92.61) 210.87,92.59 VRAM4.H4 ; 191.68,89.78 192.32,89.78 192.86,90.32 193.06,90.32 193.41,90.66 193.41,90.99 193.66,91.24 194.47,91.24 v1(194.8,90.91)
FBA_CMD23: length 27.1
  L3 w0.112: v1(211.6,93.48) 211.19,93.06 210.65,93.06 208.91,94.8 203.88,94.8 201.38,97.3 197.18,97.3 194.93,95.05 194.93,91.84 194.31,91.21 194.31,90.49 v1(194.49,90.31)
  BOTTOM w0.114: v1(194.49,90.31) 194.27,90.09 193.85,90.09 193.44,89.68 GPU1.K26 ; VRAM4.H5 211.26,93.13 v1(211.6,93.48)
FBA_CMD24: length 29.2
  L3 w0.112: v1(210.85,91.8) 209.19,93.46 209.19,93.72 208.6,94.31 203.32,94.31 201.1,96.54 197.49,96.54 195.6,94.64 195.6,90.19 193.65,88.23 193.65,87.9 193.1,87.36 192.82,87.36 192.35,86.89 v1(191.75,86.89)
  BOTTOM w0.114: v1(210.85,91.8) 210.85,91.81 VRAM4.J4 ; GPU1.K22 191.72,86.86 v1(191.75,86.89)
FBA_CMD25: length 29.3
  L3 w0.112: v1(210.87,93.48) 209.27,95.07 204.13,95.07 201.53,97.68 197.02,97.68 194.42,95.08 194.42,91.72 193.29,90.58 193.29,87.87 193.02,87.6 192.45,87.6 v1(192.29,87.44)
  BOTTOM w0.114: v1(192.29,87.44) 192.31,87.42 GPU1.J23 ; VRAM4.J5 210.46,93.07 v1(210.87,93.48)
FBA_CMD26: length 27.9
  L3 w0.112: v1(192.9,86.84) 192.91,86.84 193.95,87.88 193.95,88.22 195.88,90.15 195.88,94.38 197.65,96.15 200.95,96.15 203.02,94.08 208.5,94.08 208.96,93.63 208.96,92.89 v1(210.06,91.79)
  BOTTOM w0.114: v1(192.9,86.84) 192.9,86.84 192.9,86.87 193.25,87.23 193.25,87.84 GPU1.J25 ; VRAM4.K4 210.06,91.8 v1(210.06,91.79)
FBA_CMD27: length 28.8
  L3 w0.112: v1(210.08,94.87) 209.6,95.35 204.37,95.35 201.68,98.04 196.85,98.04 193.92,95.11 193.92,91.53 193.05,90.67 193.05,88.22 v1(192.87,88.04)
  BOTTOM w0.114: v1(210.08,94.87) 209.66,94.45 VRAM4.K5 ; v1(192.87,88.04) GPU1.J24
FBA_CMD28: length 28.3
  TOP w0.114: v1(201.09,90.86) 201.39,91.17 201.39,92.47 201.99,93.07 202.92,93.07 203.04,92.95 203.04,92.4 202.92,92.28 201.99,92.28 201.87,92.17 201.87,91.94 201.99,91.82 202.8,91.82 202.91,91.71 202.91,91.48 202.8,91.37 201.99,91.37 201.87,91.25 201.87,91.02 201.99,90.91 202.84,90.91 202.99,90.76 202.99,89.95 203.15,89.79 203.68,89.79 203.91,89.55 203.91,89.03 204.34,88.6 208.55,88.6 208.81,88.85 208.81,90.65 v1(208.46,91)
  BOTTOM w0.114: VRAM4.L3 v1(208.46,91) ; GPU1.K27 194.05,89.77 195.44,89.77 195.83,90.16 195.83,90.83 196.08,91.09 200.86,91.09 v1(201.09,90.86)
FBA_CMD29: length 32.4
  TOP w0.114: v1(200.91,88.47) 201.45,88.47 201.56,88.59 201.56,89.61 201.67,89.73 202.17,89.73 202.45,89.45 202.45,88.03 202.56,87.91 209.22,87.91 210.86,89.56 v1(210.86,90.2)
  BOTTOM w0.114: R7821.2 212.06,87.33 211.43,87.96 211.43,88.91 210.86,89.47 v1(210.86,90.2) VRAM4.J2 ; GPU1.K25 193.47,88.59 194.41,89.53 195.5,89.53 196.2,90.23 196.91,90.23 197.04,90.36 197.04,90.57 197.18,90.71 197.37,90.71 197.5,90.57 197.5,90.36 197.64,90.23 197.83,90.23 197.96,90.36 197.96,90.57 198.09,90.71 198.28,90.71 198.42,90.57 198.42,90.36 198.55,90.23 198.74,90.23 198.87,90.36 198.87,90.57 199.01,90.71 199.2,90.71 199.33,90.57 199.33,90.36 199.46,90.23 199.65,90.23 199.79,90.36 199.79,90.57 199.92,90.71 200.11,90.71 200.24,90.57 200.24,90.36 200.38,90.23 201.41,90.23 201.53,90.11 201.53,88.59 201.41,88.47 v1(200.91,88.47)
FBA_CMD30: length 35.5
  TOP w0.114: v1(210.07,91) 210.07,89.17 209.06,88.17 204.03,88.17 203.34,88.86 203.34,89.08 202.04,90.37 201.03,90.37 200.91,90.26 200.91,89.7 200.8,89.59 200.46,89.59 200.34,89.7 200.34,90.75 200.23,90.86 199.88,90.86 199.77,90.75 199.77,89.7 199.65,89.59 199.31,89.59 199.2,89.7 199.2,90.75 199.08,90.86 198.4,90.86 198.28,90.75 198.28,89.15 198.56,88.86 199.81,88.86 v1(200.21,88.46)
  BOTTOM w0.114: VRAM4.J3 210.07,91.01 v1(210.07,91) 210.07,88.48 210.54,88.01 R7824.1 ; v1(200.21,88.46) 200.78,89.04 200.78,89.55 200.67,89.67 196.02,89.67 195.51,89.15 GPU1.J27
FBA_CMD31: length 27.1
  TOP w0.114: v1(211.65,91.04) 212.22,91.04 212.34,90.92 212.34,90.26 211.84,89.76 211.44,89.76 210.18,88.49 210.18,86.24 210.03,86.08 208.96,86.08 208.76,86.29 208.76,87.33 208.64,87.44 199.04,87.44 198.86,87.62 v1(198.86,88.45)
  BOTTOM w0.114: v1(211.65,91.04) 211.7,91.04 VRAM4.G3 ; v1(198.86,88.45) 199.28,88.87 199.28,89.21 199.16,89.33 196.07,89.33 195.62,88.88 194.83,88.88 194.53,88.59 GPU1.J26
FBA_D0: length 16.5
  L6 w0.112: v1(191.17,81.51) 192.14,81.51 195.8,77.85 196.2,77.85 198.5,75.54 202.66,75.54 v1(203.39,76.27)
  BOTTOM w0.114: v1(203.39,76.27) 203.53,76.27 VRAM1.A4 ; GPU1.E18 191.21,81.54 v1(191.17,81.51)
FBA_D1: length 18.3
  L6 w0.112: v1(190.56,82.11) 191.89,82.11 195.39,78.62 196.19,78.62 198.8,76 202.4,76 v1(202.67,76.27)
  BOTTOM w0.114: VRAM1.A2 203.61,78.4 203.09,77.88 203.09,76.69 v1(202.67,76.27) ; v1(190.56,82.11) 190.59,82.14 GPU1.F18
FBA_D2: length 18.7
  L6 w0.112: v1(189.97,80.37) 190.54,80.37 190.98,80.81 192.52,80.81 198.23,75.1 203.14,75.1 v1(204.46,76.42)
  BOTTOM w0.114: v1(204.46,76.42) 204.48,76.42 VRAM1.B4 ; GPU1.E16 189.98,80.36 v1(189.97,80.37)
FBA_D3: length 19.7
  L6 w0.112: v1(203.58,77.22) 203.55,77.19 202.92,77.19 202.24,76.51 199.01,76.51 196.27,79.25 195.11,79.25 191.83,82.53 190.39,82.53 189.99,82.13 v1(189.99,81.63)
  BOTTOM w0.114: GPU1.F17 190.08,81.54 v1(189.99,81.63) ; VRAM1.B2 204.47,78.01 203.83,78.01 203.58,77.75 v1(203.58,77.22)
FBA_D4: length 18.8
  L6 w0.112: v1(207.67,76.42) 208.08,76.83 208.08,77.39 207.02,78.45 202.25,78.45 201.69,77.89 200.47,77.89 197.16,81.21 195.02,81.21 v1(194.05,82.17)
  BOTTOM w0.114: v1(207.67,76.42) 207.64,76.42 VRAM1.E4 ; v1(194.05,82.17) 194.02,82.14 GPU1.D20
FBA_D5: length 17.4
  L6 w0.112: v1(193.48,82.72) 194.28,82.72 195.57,81.44 197.65,81.44 200.81,78.27 201.47,78.27 202.04,78.84 207.65,78.84 v1(207.67,78.82)
  BOTTOM w0.114: GPU1.D21 193.49,82.73 v1(193.48,82.72) ; v1(207.67,78.82) 207.67,78.81 VRAM1.E2
FBA_D6: length 24.1
  L6 w0.112: v1(191.74,83.3) 192.31,83.3 192.71,83.7 193.08,83.7 193.41,83.37 194.42,83.37 195.65,82.14 198.06,82.14 198.07,82.15 198.87,82.15 199.55,81.47 199.55,81.36 200.01,80.9 200.78,80.9 200.8,80.92 208.1,80.92 208.76,80.26 208.76,79.08 208.07,78.38 208.07,77.81 208.46,77.42 v1(208.46,76.42)
  BOTTOM w0.114: v1(208.46,76.42) 208.44,76.42 VRAM1.F4 ; GPU1.F20 191.74,83.3 v1(191.74,83.3)
FBA_D7: length 19.3
  L6 w0.112: v1(192.89,83.29) 193.04,83.14 194.24,83.14 195.45,81.93 198.17,81.93 198.18,81.94 198.78,81.94 199.32,81.4 199.32,81.29 200.06,80.56 207.88,80.56 v1(208.35,80.09)
  BOTTOM w0.114: v1(192.89,83.29) 192.9,83.3 GPU1.E21 ; v1(208.35,80.09) 208.43,80.01 208.43,78.77 VRAM1.F2
FBA_D8: length 18
  L6 w0.112: v1(189.97,79.22) 190.78,79.22 197.33,72.67 201.77,72.67 202.81,71.64 v1(203.6,71.64)
  BOTTOM w0.114: GPU1.E15 189.99,79.24 v1(189.97,79.22) ; v1(203.6,71.64) 203.62,71.64 VRAM1.A11
FBA_D9: length 18.7
  L6 w0.112: v1(202.21,71.53) 197.11,71.53 192.13,76.51 192.13,77.21 190.7,78.64 v1(190.52,78.64)
  BOTTOM w0.114: v1(190.52,78.64) 190.55,78.67 GPU1.D15 ; VRAM1.A13 203.47,69.6 202.51,70.56 202.51,71.23 v1(202.21,71.53)
FBA_D10: length 19.7
  L6 w0.112: v1(189.37,79.78) 190.75,79.78 197.47,73.05 201.95,73.05 202.89,72.11 203.97,72.11 v1(204.46,71.62)
  BOTTOM w0.114: GPU1.F15 189.39,79.8 v1(189.37,79.78) ; v1(204.46,71.62) 204.86,71.22 VRAM1.B11
FBA_D11: length 22.1
  L6 w0.112: v1(203.17,69.19) 202.95,69.19 200.99,71.15 196.96,71.15 194,74.11 194,74.3 191.91,76.39 191.91,77.04 190.76,78.18 190.39,78.18 189.56,79.01 189.14,79.01 188.75,78.62 v1(188.2,78.62)
  BOTTOM w0.114: VRAM1.B13 204.45,69.19 203.18,69.19 v1(203.17,69.19) ; v1(188.2,78.62) 188.21,78.63 GPU1.F13
FBA_D12: length 28.7
  L6 w0.112: v1(206.86,71.62) 207.4,71.08 207.4,67.29 206.84,66.72 202.52,66.72 199.62,69.62 195.4,69.62 189.94,75.09 v1(189.94,76.89)
  BOTTOM w0.114: GPU1.C13 189.93,76.89 v1(189.94,76.89) ; v1(206.86,71.62) 207.26,71.22 VRAM1.E11
FBA_D13: length 23.2
  L6 w0.112: v1(206.89,69.21) 206.96,69.14 206.96,68.07 206.02,67.13 202.65,67.13 199.78,70.01 196.43,70.01 192.25,74.19 192.25,74.59 v1(190.49,76.35)
  BOTTOM w0.114: v1(206.89,69.21) 207.26,69.58 VRAM1.E13 ; v1(190.49,76.35) 190.5,76.35 GPU1.B13
FBA_D14: length 32.7
  L6 w0.112: v1(188.79,78.03) 188.79,77.45 189.19,77.06 189.19,74.81 196.22,67.77 200.4,67.77 202.18,65.99 207.25,65.99 208.43,67.17 208.43,67.95 207.66,68.71 v1(207.66,71.62)
  BOTTOM w0.114: v1(207.66,71.62) 208.06,71.23 VRAM1.F11 ; v1(188.79,78.03) 188.79,78.06 188.8,78.08 GPU1.E13
FBA_D15: length 28.2
  L6 w0.112: v1(208.01,67.73) 208.01,67.29 207.08,66.36 202.35,66.36 200.56,68.15 196.36,68.15 189.48,75.03 189.48,77.37 v1(189.37,77.48)
  BOTTOM w0.114: VRAM1.F13 208.06,69.56 207.69,69.19 207.69,68.05 v1(208.01,67.73) ; v1(189.37,77.48) 189.37,77.48 189.37,78.04
FBA_D16: length 39.1
  L3 w0.112: v1(195.37,73.91) 195.37,71.91 197.37,69.91 199.49,69.91 204.31,65.09 214.79,65.09 217.6,67.89 217.6,67.92 217.61,67.93 217.61,69.53 217.95,69.88 217.95,70.82 v1(217.98,70.84)
  BOTTOM w0.114: GPU1.B15 191.72,78.06 191.72,76.3 193.57,74.45 194,74.45 194.54,73.91 v1(195.37,73.91) ; v1(217.98,70.84) 217.57,71.25 217.48,71.25 217.48,71.25 217.11,71.25 217.11,71.25 216.91,71.25 VRAM1.U11
FBA_D17: length 38.3
  L3 w0.112: v1(217.38,70.02) 217.24,69.88 217.24,68.08 214.63,65.47 204.47,65.47 199.65,70.29 197.55,70.29 195.98,71.86 195.98,72.73 v1(196.26,73.01)
  BOTTOM w0.114: GPU1.C16 191.68,78.62 191.31,78.25 191.31,77.94 191.5,77.75 191.5,76.21 193.73,73.99 193.9,73.99 194.84,73.05 196.22,73.05 v1(196.26,73.01) ; VRAM1.U13 216.96,69.6 v1(217.38,70.02)
FBA_D18: length 34.9
  L3 w0.112: v1(215.67,71.58) 215.9,71.34 215.9,67.33 214.48,65.91 204.57,65.91 199.81,70.67 198.15,70.67 196.72,72.11 v1(196.72,72.55)
  BOTTOM w0.114: VRAM1.T11 216.05,71.2 v1(215.67,71.58) ; v1(196.72,72.55) 196.69,72.57 195.22,72.57 195.12,72.67 194.7,72.67 191.06,76.31 GPU1.A13
FBA_D19: length 38.5
  L3 w0.112: v1(218.04,69.21) 218.04,67.8 214.95,64.71 204.09,64.71 199.27,69.53 197.19,69.53 195.04,71.68 195.04,71.72 195,71.76 195,73.66 194.47,74.19 v1(194.47,74.8)
  BOTTOM w0.114: v1(218.04,69.21) 216.45,69.21 VRAM1.T13 ; GPU1.A15 191.97,77.25 191.97,76.35 193.52,74.8 v1(194.47,74.8)
FBA_D20: length 29.9
  L3 w0.112: v1(214.06,71.62) 213.66,71.22 213.66,69.05 212.96,68.34 209.97,68.34 209.32,68.99 207.98,68.99 207.1,69.88 203.15,69.88 202.44,70.59 202.12,70.59 200.51,72.2 200.13,72.2 197.25,75.07 v1(197.25,75.27)
  BOTTOM w0.114: v1(197.25,75.27) 196.16,75.27 193.75,77.68 193.72,77.68 193.59,77.8 193.59,78.62 193.69,78.72 193.69,79.02 193.44,79.28 GPU1.B18 ; VRAM1.N11 213.66,71.22 v1(214.06,71.62)
FBA_D21: length 27.3
  L3 w0.112: v1(196.16,76.36) 196.16,75.63 199.98,71.81 200.36,71.81 202.52,69.65 203.63,69.65 204.52,68.76 209.25,68.76 209.93,68.07 213.01,68.07 214.09,69.15 v1(214.09,69.19)
  BOTTOM w0.114: v1(196.16,76.36) 195.36,76.36 193.82,77.91 193.82,78.51 194,78.7 GPU1.A18 ; VRAM1.N13 213.68,69.6 v1(214.09,69.19)
FBA_D22: length 26.2
  L3 w0.112: v1(213.23,70.82) 212.77,70.36 212.77,69.86 212.66,69.75 209.61,69.75 209.43,69.57 208.05,69.57 207.29,70.34 203.57,70.34 203.18,70.72 203.18,71.72 201.94,72.96 200.45,72.96 199.13,74.28 199.13,74.58 195.47,78.25 v1(194.45,78.25)
  BOTTOM w0.114: v1(213.23,70.82) 212.86,71.19 VRAM1.M11 ; GPU1.A19 194.59,79.82 194.59,78.39 v1(194.45,78.25)
FBA_D23: length 28.1
  L3 w0.112: v1(195.28,77.29) 195.89,77.29 198.75,74.43 198.75,74.12 200.29,72.58 201.79,72.58 202.65,71.71 202.65,70.93 203.47,70.11 207.19,70.11 208.04,69.26 209.38,69.26 210.06,68.57 212.59,68.57 v1(213.24,69.22)
  BOTTOM w0.114: v1(195.28,77.29) 194.75,77.29 194.04,78 194.04,78.42 194.38,78.76 194.38,79.44 193.44,80.38 GPU1.C19 ; VRAM1.M13 v1(213.24,69.22)
FBA_D24: length 29.2
  L3 w0.112: v1(218.03,77.29) 218.58,77.84 218.58,79.64 214.45,83.77 211.98,83.77 211.63,84.13 208.67,84.13 208.47,83.92 208.44,83.92 202.52,83.92 v1(200.59,82)
  BOTTOM w0.114: v1(200.59,82) 200.54,81.94 198.37,81.94 197.9,82.41 197.9,82.96 197.64,83.22 197.11,83.22 GPU1.B24 ; v1(218.03,77.29) 217.53,76.8 VRAM1.U4
FBA_D25: length 27.9
  L3 w0.112: v1(217.42,78.42) 217.42,79.68 214.19,82.91 211.77,82.91 211.31,83.37 208.98,83.37 208.45,82.83 203.28,82.83 200.99,80.54 v1(199.41,80.54)
  BOTTOM w0.114: v1(217.42,78.42) 216.88,78.42 VRAM1.U2 ; v1(199.41,80.54) 199.15,80.28 198.88,80.28 197.07,82.1 196.79,82.1 196.64,82.25 196.29,82.25 195.79,82.74 GPU1.C23
FBA_D26: length 30.7
  L3 w0.112: v1(217.29,76.39) 217.74,76.39 218.81,77.46 218.81,79.95 217.62,81.13 217.62,81.14 214.61,84.15 212.14,84.15 211.79,84.51 208.51,84.51 208.31,84.31 202.21,84.31 v1(200.6,82.7)
  BOTTOM w0.114: v1(200.6,82.7) 200.3,83.01 199.61,83.01 198.78,82.17 198.44,82.17 198.21,82.41 198.21,83.25 GPU1.A25 ; VRAM1.T4 216.47,76.39 v1(217.29,76.39)
FBA_D27: length 28.1
  L3 w0.112: v1(198.61,81.53) 199.24,81.53 199.88,80.89 200.8,80.89 203.42,83.52 208.6,83.52 208.83,83.75 211.47,83.75 211.83,83.39 214.25,83.39 218.16,79.48 v1(218.16,78.4)
  BOTTOM w0.114: VRAM1.T2 216.48,78.82 216.69,78.82 216.7,78.81 217.02,78.81 217.03,78.82 217.24,78.82 217.25,78.83 217.59,78.83 217.6,78.82 217.67,78.82 218.09,78.4 v1(218.16,78.4) ; GPU1.A24 197.53,82.48 198.48,81.53 v1(198.61,81.53)
FBA_D28: length 23
  L3 w0.112: v1(199.52,77.5) 199.91,77.5 200.56,76.85 202.55,76.85 204.13,78.43 207.05,78.43 207.89,77.59 209.05,77.59 209.93,76.71 211.86,76.71 212.19,77.05 212.83,77.05 213.46,76.41 v1(214.05,76.41)
  BOTTOM w0.114: GPU1.A21 195.86,80.93 197.14,80.93 198.95,79.12 198.95,78.79 199.52,78.22 v1(199.52,77.5) ; VRAM1.N4 214.05,76.41 v1(214.05,76.41)
FBA_D29: length 25
  L3 w0.112: v1(196.64,80.51) 198.68,80.51 200.92,78.27 201.47,78.27 201.95,78.75 201.95,79.89 203.7,81.64 212.38,81.64 214.07,79.96 214.07,79.61 214.06,79.6 v1(214.06,78.81)
  BOTTOM w0.114: v1(196.64,80.51) 195.75,80.51 195.3,80.97 195.3,81.5 195.19,81.6 ; v1(214.06,78.81) 214.06,78.8 VRAM1.N2
FBA_D30: length 26.6
  L3 w0.112: v1(198.48,78.54) 199.39,78.54 200.71,77.21 202.38,77.21 202.99,77.83 202.99,79.78 203.78,80.57 209.49,80.57 210.73,79.33 212.1,79.33 212.57,78.87 212.57,77.9 v1(213.25,77.22)
  BOTTOM w0.114: VRAM1.M4 213.25,77.19 v1(213.25,77.22) ; v1(198.48,78.54) 198.47,78.55 196.25,78.55 195.07,79.74 195.07,79.99 194.03,81.02 GPU1.C20
FBA_D31: length 24.8
  L3 w0.112: v1(213.26,78.81) 213.26,79.38 211.46,81.18 203.78,81.18 202.5,79.9 202.5,78.7 201.69,77.89 200.75,77.89 199.13,79.52 v1(197.56,79.52)
  BOTTOM w0.114: GPU1.C21 194.63,81.56 194.99,81.2 194.99,80.97 195.66,80.29 196.01,80.29 196.78,79.52 v1(197.56,79.52) ; v1(213.26,78.81) 212.86,78.41 VRAM1.M2
FBA_D32: length 19
  L6 w0.112: v1(187.66,89.8) 187.72,89.87 187.72,89.99 190.5,92.77 190.7,92.77 191.27,93.33 192.62,93.33 193.04,92.91 203.16,92.91 v1(203.56,92.51)
  BOTTOM w0.114: v1(203.56,92.51) 203.87,92.2 VRAM4.U4 ; GPU1.R22 v1(187.66,89.8)
FBA_D33: length 18.6
  L6 w0.112: v1(189.38,90.36) 189.38,91 190.64,92.26 190.84,92.26 191.41,92.83 192.01,92.83 192.53,92.31 192.53,91.8 193.18,91.15 194.04,91.15 194.88,91.99 201.27,91.99 202.34,90.91 v1(203.55,90.91)
  BOTTOM w0.114: v1(189.38,90.36) 189.37,90.37 GPU1.R24 ; v1(203.55,90.91) 203.75,90.91 VRAM4.U2
FBA_D34: length 20.3
  L6 w0.112: v1(187.06,90.39) 187.73,90.39 190.33,92.99 190.6,92.99 191.16,93.55 192.94,93.55 193.2,93.29 203.76,93.29 v1(204.44,92.61)
  BOTTOM w0.114: v1(187.06,90.39) 187.08,90.37 GPU1.T22 ; v1(204.44,92.61) 204.85,92.2 VRAM4.T4
FBA_D35: length 19.6
  L6 w0.112: v1(188.82,89.82) 188.82,89.87 188.78,89.9 188.78,90.73 190.57,92.51 190.77,92.51 191.31,93.06 192.36,93.06 192.89,92.53 201.36,92.53 202.51,91.38 204.08,91.38 v1(204.46,91)
  BOTTOM w0.114: VRAM4.T2 v1(204.46,91) ; v1(188.82,89.82) 188.82,89.87 188.8,89.89 GPU1.R23
FBA_D36: length 21.7
  L6 w0.112: v1(191.07,90.89) 192.85,89.11 203.27,89.11 203.56,88.82 206.47,88.82 206.83,89.19 206.83,89.54 207.28,89.99 207.28,92.18 v1(206.86,92.6)
  BOTTOM w0.114: VRAM4.N4 v1(206.86,92.6) ; GPU1.N25 191.12,90.84 v1(191.07,90.89)
FBA_D37: length 17.7
  L6 w0.112: v1(206.83,90.2) 206.41,90.62 205.09,90.62 204.87,90.4 196.06,90.4 195.55,89.9 193.87,89.9 192.05,91.72 v1(191.75,91.72)
  BOTTOM w0.114: VRAM4.N2 206.86,90.2 v1(206.83,90.2) ; GPU1.N26 191.68,91.65 v1(191.75,91.72)
FBA_D38: length 25.6
  L6 w0.112: v1(189.94,89.75) 190.58,89.75 192.14,88.19 192.14,88.19 193.31,87.02 206.49,87.02 208.51,89.04 208.51,90.17 207.67,91.01 v1(207.67,92.6)
  BOTTOM w0.114: GPU1.N23 189.99,89.7 v1(189.94,89.75) ; v1(207.67,92.6) 207.67,92.59 VRAM4.M4
FBA_D39: length 21.2
  L6 w0.112: v1(207.7,90.2) 207.68,90.17 207.68,89.1 206.07,87.49 195.22,87.49 194.22,88.5 193.1,88.5 191.27,90.33 v1(190.56,90.33)
  BOTTOM w0.114: 190.55,89.78 190.55,90.33 v1(190.56,90.33) ; v1(207.7,90.2) 207.7,90.24 VRAM4.M2
FBA_D40: length 22.3
  L6 w0.112: v1(186.48,92.11) 188.83,94.47 196.15,94.47 196.85,95.16 200.72,95.16 201.09,95.53 201.09,97.19 v1(202.71,98.82)
  BOTTOM w0.114: GPU1.V23 186.52,92.15 v1(186.48,92.11) ; v1(202.71,98.82) 203.73,97.8 VRAM4.U11
FBA_D41: length 22.3
  L6 w0.112: v1(185.88,91.56) 185.88,92.1 186.45,92.67 186.71,92.67 188.78,94.74 195.69,94.74 197.19,96.24 199.47,96.24 v1(202.05,98.82)
  BOTTOM w0.114: VRAM4.U13 202.63,99.4 v1(202.05,98.82) ; v1(185.88,91.56) 185.88,91.56 GPU1.V22
FBA_D42: length 21
  L6 w0.112: v1(204.46,97.4) 201.47,94.41 197.18,94.41 196.57,93.81 191.04,93.81 190.46,93.22 189.31,93.22 187.68,91.59 v1(187.68,90.95)
  BOTTOM w0.114: v1(187.68,90.95) 187.69,90.96 188.23,90.96 ; v1(204.46,97.4) VRAM4.T11
FBA_D43: length 24.4
  L6 w0.112: v1(203.35,98.81) 202.79,98.25 202.79,96.68 200.91,94.8 197,94.8 196.24,94.04 190.95,94.04 190.41,93.5 188.38,93.5 187.19,92.31 187.19,91.97 187.43,91.73 187.43,91.35 187.03,90.95 186.49,90.95 v1(186.44,91)
  BOTTOM w0.114: v1(186.44,91) 186.48,90.96 GPU1.U22 ; v1(203.35,98.81) 203.55,99.01 204.47,99.01 VRAM4.T13
FBA_D44: length 26.7
  L6 w0.112: v1(186.45,94.49) 186.49,94.49 187.66,95.65 192.17,95.65 192.42,95.91 195.16,95.91 198.95,99.7 206.75,99.7 208.08,98.37 208.08,97.82 v1(207.66,97.4)
  BOTTOM w0.114: v1(186.45,94.49) GPU1.Y24 ; VRAM4.N11 207.26,97.8 v1(207.66,97.4)
FBA_D45: length 27
  L6 w0.112: v1(207.67,99.8) 207.32,100.15 203.43,100.15 202.6,100.98 199.16,100.98 194.91,96.74 186.41,96.74 v1(185.29,95.61)
  BOTTOM w0.114: v1(207.67,99.8) 207.27,99.4 VRAM4.N13 ; v1(185.29,95.61) 185.86,95.04 GPU1.AA24
FBA_D46: length 30
  L6 w0.112: v1(208.47,97.4) 208.44,97.4 208.31,97.53 208.31,98.47 206.85,99.93 203.28,99.93 203.14,100.07 198.77,100.07 195.04,96.34 189.13,96.34 188.95,96.52 187.5,96.52 186.04,95.07 186.04,94.32 186.25,94.11 186.25,93.7 185.84,93.29 v1(185.29,93.29)
  BOTTOM w0.114: v1(208.47,97.4) 208.07,97.8 VRAM4.M11 ; GPU1.Y22 v1(185.29,93.29)
FBA_D47: length 31.3
  L6 w0.112: v1(207.49,101.35) 207.39,101.45 199.11,101.45 194.84,97.18 185.57,97.18 184.65,96.27 184.65,94.55 185.3,93.9 v1(185.84,93.9)
  BOTTOM w0.114: GPU1.AA23 v1(185.84,93.9) ; VRAM4.M13 208.42,99.76 208.42,100.54 207.61,101.35 v1(207.49,101.35)
FBA_D48: length 43.8
  L6 w0.112: v1(217.51,100.45) 217.88,100.82 217.88,101.89 215.42,104.36 211.96,104.36 211.51,104.8 197.8,104.8 193.49,100.49 190.01,100.49 188.77,101.73 187.13,101.73 186.57,101.16 186.57,99.44 v1(186.12,99)
  BOTTOM w0.114: 185.79,97.94 186.05,98.2 186.05,98.87 186.12,98.94 186.12,98.99 v1(186.12,99) ; v1(217.51,100.45) 217.85,100.1 217.85,98.15 217.5,97.8 VRAM4.A11
FBA_D49: length 41.4
  L6 w0.112: v1(216.51,101.74) 214.64,103.61 211.6,103.61 211.14,104.07 198.1,104.07 193.79,99.76 190.54,99.76 190.43,99.88 190.02,99.88 188.64,101.25 187.81,101.25 187.42,100.86 187.42,100.59 186.92,100.08 186.92,99.26 v1(187.01,99.17)
  BOTTOM w0.114: GPU1.AB25 185.86,96.13 186.28,96.56 186.28,96.86 186.89,97.47 187.13,97.71 187.13,98.05 187.01,98.18 v1(187.01,99.17) ; VRAM4.A13 216.86,99.44 216.45,99.85 216.45,100.51 216.68,100.74 216.68,101.57 v1(216.51,101.74)
FBA_D50: length 45.3
  L6 w0.112: v1(186.1,100.69) 186.1,101.21 187.01,102.11 188.92,102.11 190.16,100.87 193.35,100.87 197.65,105.17 211.66,105.17 212.1,104.73 215.56,104.73 218.09,102.2 218.09,100.03 217.26,99.19 217.25,99.19 216.46,98.4 v1(216.46,98.2)
  BOTTOM w0.114: VRAM4.B11 v1(216.46,98.2) ; v1(186.1,100.69) 186.18,99.79 185.89,99.44 185.64,99.12 185.64,98.38 185.42,98.07 185.37,97.89 185.37,97.52 GPU1.AD26
FBA_D51: length 43.5
  L6 w0.112: v1(186.98,100.99) 187.46,101.48 188.72,101.48 190.07,100.12 193.64,100.12 197.95,104.44 211.36,104.44 211.8,103.99 215.24,103.99 216.99,102.25 216.99,100.07 v1(217.27,99.79)
  BOTTOM w0.114: v1(186.98,100.99) 186.98,100.12 186.55,99.69 186.55,98.35 186.16,97.97 186.16,97.78 185.6,97.21 185.26,96.87 GPU1.AC25 ; VRAM4.B13 216.45,99.01 217.02,99.01 217.27,99.26 v1(217.27,99.79)
FBA_D52: length 36.1
  L6 w0.112: v1(214.06,98.21) 214.47,98.63 214.47,100.48 212.5,102.45 211.19,102.45 210.67,102.97 198.57,102.97 194.25,98.66 190.73,98.66 190.25,99.15 189.56,99.15 v1(188.91,99.8)
  BOTTOM w0.114: v1(188.91,99.8) 188.91,99.32 188.03,98.44 188.03,97.16 187.65,96.78 187.65,96.26 GPU1.AA27 ; v1(214.06,98.21) 213.66,97.81 VRAM4.E11
FBA_D53: length 33.3
  L6 w0.112: v1(214.06,99.78) 213.64,100.21 212.92,100.21 210.52,102.61 198.72,102.61 194.4,98.3 190.8,98.3 190.16,98.93 189.06,98.93 188.44,98.32 v1(188.44,97.59)
  BOTTOM w0.114: VRAM4.E13 213.68,99.4 v1(214.06,99.78) ; GPU1.AA26 187.18,95.79 187.71,95.79 187.93,96.01 187.93,96.65 188.44,97.16 v1(188.44,97.59)
FBA_D54: length 34.7
  L6 w0.112: v1(212.84,96.09) 212.84,96.45 211.09,98.19 211.09,99.11 210.66,99.55 209.9,99.55 209.66,99.31 208.84,99.31 208.25,99.9 208.25,101.17 207.61,101.82 198.96,101.82 194.71,97.56 189.91,97.56 v1(189.85,97.63)
  BOTTOM w0.114: v1(212.84,96.09) 212.84,96.41 212.5,96.74 212.5,97.44 VRAM4.F11 ; v1(189.85,97.63) 189.85,96.64 188.31,95.1 188.31,94.54 GPU1.W26
FBA_D55: length 35.9
  L6 w0.112: v1(213.26,99.79) 213.03,99.79 212.05,100.77 211.87,100.77 211.07,99.98 210.86,99.98 210.73,100.11 210.73,100.27 211.55,101.09 211.55,101.27 210.43,102.4 209.22,102.4 209.01,102.18 198.81,102.18 194.56,97.93 190.86,97.93 190.07,98.72 189.73,98.72 189.38,98.37 189.38,97.83 v1(189.15,97.59)
  BOTTOM w0.114: v1(213.26,99.79) 212.87,99.4 VRAM4.F13 ; GPU1.Y25 187.13,94.56 187.13,95.09 187.57,95.52 187.74,95.52 188.19,95.97 188.19,96.24 188.43,96.48 188.9,96.48 189.5,97.08 189.5,97.24 v1(189.15,97.59)
FBA_D56: length 36.9
  L3 w0.112: v1(197.66,91.52) 197.66,90.78 199.26,89.18 200.77,89.18 201.07,88.88 201.08,88.88 201.32,88.64 201.32,88.63 204.38,85.58 214.52,85.58 217.87,88.92 217.87,92.01 v1(217.52,92.36)
  BOTTOM w0.114: v1(197.66,91.52) 197.16,92.02 194.26,92.02 193.45,92.82 191.67,92.82 191.44,92.59 191.44,92.5 191.03,92.09 GPU1.R26 ; v1(217.52,92.36) 217.02,92.36 VRAM4.A4
FBA_D57: length 36.4
  L3 w0.112: v1(200.22,91.54) 200.22,90.25 204.52,85.96 214.27,85.96 217.45,89.13 v1(217.45,90.6)
  BOTTOM w0.114: v1(217.45,90.6) VRAM4.A2 ; v1(200.22,91.54) 200.22,92.2 199.35,93.07 195.62,93.07 195.04,93.64 191.46,93.64 189.91,92.09 GPU1.T25
FBA_D58: length 40.5
  L3 w0.112: v1(196.36,91.52) 196.36,89.99 195.7,89.33 195.7,88.06 196.27,87.49 201.89,87.49 204.18,85.19 214.7,85.19 218.23,88.73 218.23,92.36 217.7,92.89 216.72,92.89 v1(216.46,92.63)
  BOTTOM w0.114: GPU1.N27 192.25,92.03 192.76,92.53 193.15,92.53 194.17,91.52 v1(196.36,91.52) ; VRAM4.B4 216.46,92.6 v1(216.46,92.63)
FBA_D59: length 32.8
  L3 w0.112: v1(198.95,91.52) 198.95,91.54 199.4,91.99 201.07,91.99 201.6,91.46 201.6,89.42 204.67,86.34 213.99,86.34 215.87,88.22 v1(215.87,88.59)
  BOTTOM w0.114: v1(198.95,91.52) 197.96,92.51 195.13,92.51 194.54,93.1 191.5,93.1 GPU1.R27 ; v1(215.87,88.59) 215.87,89.38 215.67,89.59 215.67,90.21 VRAM4.B2
FBA_D60: length 34.8
  L3 w0.112: v1(214.05,91.81) 214.48,91.38 214.48,90 213.99,89.51 213.99,88.42 213.18,87.61 205.04,87.61 202.74,89.91 202.74,91.94 200.73,93.95 v1(199.98,93.95)
  BOTTOM w0.114: v1(214.05,91.81) VRAM4.E4 ; v1(199.98,93.95) 198.78,95.15 190.58,95.15 189.68,94.26 189.46,94.04 188.93,94.04 GPU1.V26
FBA_D61: length 32.4
  L3 w0.112: v1(197.76,95.63) 199,94.39 200.82,94.39 203.02,92.2 203.02,89.95 205.03,87.94 212.19,87.94 213.48,89.23 213.48,89.54 214.06,90.11 v1(214.06,91)
  BOTTOM w0.114: v1(197.76,95.63) 197.71,95.63 197.58,95.76 190.66,95.76 GPU1.V27 ; v1(214.06,91) VRAM4.E2
FBA_D62: length 30.7
  L3 w0.112: v1(200.33,95.71) 200.76,95.71 202.89,93.58 203.73,93.58 204.28,93.03 207.84,93.03 208.08,92.78 208.08,92.01 208.04,91.96 208.04,90.82 209.08,89.78 211.83,89.78 212.46,90.41 v1(212.46,91.8)
  BOTTOM w0.114: GPU1.W27 190.45,96.69 199.35,96.69 v1(200.33,95.71) ; VRAM4.F4 v1(212.46,91.8)
FBA_D63: length 32.5
  L3 w0.112: v1(213.26,90.2) 212.34,89.28 212.34,89.07 211.44,88.17 209.79,88.17 208.27,89.69 205.18,89.69 204.02,90.84 204.02,92.64 203.63,93.02 202.78,93.02 201.01,94.8 199.92,94.8 v1(199.03,95.69)
  BOTTOM w0.114: VRAM4.F2 v1(213.26,90.2) ; v1(199.03,95.69) 198.59,96.13 190.45,96.13 188.16,93.85 GPU1.W25
FBA_DEBUG0: length 23.3
  TOP w0.102: v2(199.99,70.28) 199.71,70.01 R7801.1 198.9,70.08 198.24,70.74 196.55,70.74 192.49,74.8 v1(191.17,74.8)
  L4 w0.102: v1(191.17,74.8) 191.7,75.33 191.7,78.58 190.73,79.55 190.73,80.52 191.31,81.1 191.34,81.1 191.58,81.34 191.58,81.82 191.33,82.07 191.33,83.56 192.27,84.5 v1(192.88,84.5)
  BOTTOM w0.102: GPU1.F22 v1(192.88,84.5)
FBA_DEBUG1: length 23.2
  TOP w0.102: v1(191.56,74.29) 192.71,74.29 196.67,70.34 v2(197.17,70.34) 197.79,70.34 R7803.1
  L4 w0.102: v1(191.56,74.29) 191.1,74.29 190.76,74.63 190.76,76.01 191.49,76.74 191.49,78.46 190.42,79.54 190.42,80.52 189.58,81.36 189.58,82.02 189.88,82.32 189.88,82.99 191.17,84.27 v1(191.17,86.31)
  BOTTOM w0.102: v1(191.17,86.31) 191.23,86.31 191.25,86.3 GPU1.J22
