# Allegro board 17859-1.0710WZS1337.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PWR_VCCGT_ISUMN_RC: length 0.9
  BOTTOM w0.254: PR4645.1 35.22,70.85 PC4623.1
PWR_VCCGT_ISUMNB: length 4.7
  BOTTOM w0.203: 36.34,67.97 36.34,67.61 v2(36.48,67.47) 36.59,67.36 PU4601.8
  BOTTOM w0.254: 36.34,67.97 36.34,68.79 PR4670.1 35.99,69.83 PC4623.2 35.96,70.06 PR4642.1
PWR_VCCGT_ISUMP: length 19.6
  BOTTOM w0.203: PU4601.7 36.13,66.96 35.96,67.13 35.96,67.7 35.69,67.97 35.05,67.97 34.86,68.16 PC4630.1 33.79,68.16 33.53,67.9 PR4643.1 33.52,67.87 PR4641.1 32.3,68.33 31.13,68.33 30.8,68.66 30.8,68.86 30.65,69.01 30.65,70.11 PC4609.1 PC4653.1 PC4628.1 31.72,72.7 PR4808.1 31.57,72.98 30.8,72.98 30.37,73.4 v2(30.37,73.56) 30.37,74.04 30.68,74.35 30.68,75.16 31.54,76.02 32.35,76.02 32.61,75.77 PR4816.1
PWR_VCCGT_ISUMP_GA: length 39.6
  TOP w0.203: v2(61.18,73.31) 61.18,73.84 v1(62.12,74.78)
  L6 w0.203: v1(62.12,74.78) 61.87,74.53 61.46,74.53 61.26,74.73 61.26,76.49 60.86,76.89 57.59,76.89 57.13,76.43 56.37,76.43 55.79,75.85 52.56,75.85 50.51,73.8 50.51,73.14 49.92,72.55 39.16,72.55 38.91,72.8 33.72,72.8 33.57,72.95 v1(33.5,72.95)
  BOTTOM w0.203: PR4821.2 34.11,72.49 33.67,72.93 33.57,72.93 33.55,72.95 v1(33.5,72.95) 33.14,72.95 32.89,72.7 PR4808.2 ; PG4808.1 61.36,73.29 61.36,74.12 62.02,74.78 v1(62.12,74.78)
PWR_VCCGT_ISUMP_GB: length 35.6
  TOP w0.254: v1(34.79,76.33) 34.84,76.28 34.84,76.23 35.05,76.02 v2(35.05,75.36)
  L6 w0.254: v1(60.65,80.98) 60.98,80.98 61.26,80.7 61.26,78.62 60.7,78.06 57.11,78.06 56.81,77.75 51.18,77.75 49.14,75.72 46.5,75.72 46.37,75.59 45.76,75.59 45.74,75.57 45.13,75.57 44.01,74.44 40.82,74.44 40.46,74.81 38.27,74.81 36.82,76.25 34.92,76.25 34.84,76.33 v1(34.79,76.33)
  BOTTOM w0.254: PG4813.1 v1(60.65,80.98) ; v1(34.79,76.33) 34.36,75.9 PR4816.2 34.46,75.77 35.2,75.03 PR4823.2
PWR_VCCGT_NTC: length 5.2
  BOTTOM w0.203: PU4601.3 36.91,65.36 36.52,64.98 36.52,64.24
  BOTTOM w0.254: 36.52,64.24 36.52,63.93 36.86,63.6 v2(36.86,63.05) 36.86,62.82 35.89,61.85 PR4616.1
PWR_VCCGT_NTC1: length 27.1
  TOP w0.254: PR4617.1 49.07,69.37 v1(48.36,70.08) ; v1(35.05,61.12) 35.05,61.6 v2(34.87,61.78)
  L4 w0.254: v1(44.95,60.86) 45.61,61.52 45.61,68.83 46.73,69.95 47.29,69.95 47.57,70.23 48.08,70.23 48.23,70.08 v1(48.36,70.08)
  L6 w0.254: v1(44.95,60.86) 44.95,60.99 43.81,62.13 38.63,62.13 37.84,61.34 35.27,61.34 v1(35.05,61.12)
  BOTTOM w0.254: v1(35.05,61.12) 35.06,61.13 35.06,61.49 PR4616.2 34.03,61.19 33.63,61.19 PR4621.2
PWR_VCCGT_PWMA: length 16.5
  TOP w0.254: PR4802.2 47.6,75.87 46.4,75.87 v1(46.16,76.11) ; v2(36.98,69.47) 37.08,69.37 v1(37.69,69.37)
  L4 w0.254: v1(37.69,69.37) 37.74,69.32 37.87,69.32 38.43,68.76 39.16,68.76 39.95,69.55 39.95,71.12 41.12,72.29 42.49,72.29 46.16,75.96 v1(46.16,76.11)
  BOTTOM w0.203: PU4601.12 38.5,69.17 38.3,69.37 v1(37.69,69.37)
PWR_VCCGT_PWMA_RA: length 3.8
  TOP w0.254: PR4802.1 48.51,75.81 PR4817.1 48.88,75.02 49.45,75.59 v2(49.5,75.59) 49.65,75.59 50.4,74.84 PU4801.1
PWR_VCCGT_PWMB: length 24.5
  TOP w0.254: v2(48.61,87.33) 49.02,86.92 PR4811.2 49.02,86.11 49.24,85.88 49.24,85.29 48.95,84.99 48.48,84.99 48.08,84.59 v1(48.08,84.23)
  L4 w0.254: v1(38.57,69.8) 38.57,70.47 40.91,72.8 42.26,72.8 44.83,75.36 44.83,76.28 46.91,78.36 46.91,81.64 47.54,82.27 47.54,83.09 48.14,83.68 48.14,84.14 48.08,84.2 v1(48.08,84.23)
  BOTTOM w0.203: v1(38.57,69.8) 38.62,69.8 38.9,69.52 PU4601.13
PWR_VCCGT_PWMB_RB: length 5
  TOP w0.254: PU4802.1 51.46,84.63 49.88,86.21 PR4811.1 49.88,87.66 v2(49.78,87.76) 49.83,87.81 PR4818.1
PWR_VCCGT_RTN: length 7.4
  BOTTOM w0.203: PU4601.6 36.63,66.56
  BOTTOM w0.254: PR4666.2 31.85,67.36 v2(32.3,66.91) 32.46,66.75 PC4619.2 32.53,65.94 33.27,65.94 33.65,66.32 34.61,66.32 PC4622.1 34.79,66.5 PR4639.1 35.5,66.56 36.63,66.56
PWR_VCCGT_SNB1: length 2.2
  BOTTOM w0.254: v2(56.13,76.58) 56.45,76.9 PC4810.1
  BOTTOM w0.635: PR4805.2 57.22,77.54 PC4810.1
PWR_VCCGT_SNB2: length 2.2
  BOTTOM w0.254: PC4813.1 63.44,86.16 63.44,86.82 v2(63.7,87.07)
  BOTTOM w0.635: PC4813.1 62.91,86.13 PR4814.2
PWR_VCCGT_SWA:
  vias: v2(55.85,70.44) v2(56.97,75.8) v3(56.04,74.78) v3(56.06,73.89) v3(56.06,73) v3(56.07,72.09) v3(56.09,71.2) v3(56.88,74.78) v3(56.9,73.89) v3(56.9,73) v3(56.93,72.11) v3(56.93,71.22) v3(57.91,75.8) v3(57.94,74.91) v3(58.8,75.8) v3(58.78,74.91) v3(59.81,75.8) v3(59.8,74.91)
PWR_VCCGT_SWB:
  vias: v2(56.05,84.74) v2(59.68,82.81) v3(56.69,80.47) v3(56.69,79.63) v3(56.69,78.74) v3(57.45,84.2) v3(57.47,85.07) v3(57.53,78.87) v3(57.58,79.71) v3(58.3,85.04) v3(58.31,84.18) v3(58.46,79.71) v3(58.46,78.87) v3(59.15,85.09) v3(59.18,84.18) v3(59.33,79.71) v3(59.3,78.87) v3(60.04,85.09) v3(60.04,84.18) v3(60.19,79.71) v3(60.19,78.87) v3(60.9,85.14) v3(60.9,84.28)
PWR_VCCGT_VCCDA: length 3.5
  TOP w0.254: v1(49.63,73.23) 49.64,73.24 PU4801.3
  BOTTOM w0.305: v1(49.63,73.23) v2(50.34,73.23) 50.34,74.09 PC4809.1 50.39,74.22 PR4803.1
PWR_VCCGT_VCCDB: length 5.8
  TOP w0.254: PU4802.3 51.01,83.63 v1(51,83.64) ; PR4813.1 51.45,87.05 51.68,86.82 v2(51.68,86.06) 51.68,85.58 v1(51.79,85.47)
  TOP w0.406: PC4812.1 51.45,88.14 PR4813.1
  BOTTOM w0.254: v1(51,83.64) 51,84.43 51.79,85.22 v1(51.79,85.47)
PWR_VCCSA_BST: length 2.8
  TOP w0.305: v2(88.44,105.59) 88.44,104.85 v1(88.28,104.7)
  TOP w0.508: PR5001.2 87.75,105.06 88.11,104.7 v1(88.28,104.7)
  BOTTOM w0.305: PU5001.2 88.36,104.63 v1(88.28,104.7)
PWR_VCCSA_BST_RC: length 2.5
  TOP w0.305: v2(88.54,103.71) 87.32,103.71
  TOP w0.508: PC5005.1 87.34,102.67 87.34,103.69 PR5001.1
PWR_VCCSA_COMP: length 4.6
  BOTTOM w0.203: PU4601.24 43.46,66.96 43.53,67.03
  BOTTOM w0.254: 43.53,67.03 44.06,67.57 44.06,67.69 v2(44.09,67.72) 44.34,67.97 44.34,68.58 44.6,68.84 PR4640.1 45.13,68.94 PC4624.1
PWR_VCCSA_COMP_RC: length 1.7
  BOTTOM w0.254: v2(44.14,69.37) 44.19,69.37 44.52,69.7 PR4640.2 PC4601.1
PWR_VCCSA_DRVH: length 9
  TOP w0.635: v3(95.88,98.08) 91.55,102.4 89.62,102.4 v3(89.55,102.47)
  BOTTOM w0.406: PU5002.4 v3(95.88,98.08)
  vias: v2(88.77,102.97)
PWR_VCCSA_DRVL:
  vias: v2(92.5,105.67)
PWR_VCCSA_FB: length 5
  BOTTOM w0.203: PU4601.25 43.49,66.56 43.76,66.3 44.29,66.3 v2(44.32,66.32) 44.44,66.32 45,66.88 PR4638.2
  BOTTOM w0.381: PR4638.2 45.21,67.31 PR4637.1 PR4632.2
PWR_VCCSA_FB1: length 4.4
  TOP w0.254: PC4621.2 42.54,66.88 v1(44.32,66.88) 44.32,66.27 v2(44.09,66.04)
  BOTTOM w0.305: v1(44.32,66.88) 44.47,67.03 44.47,67.47 44.52,67.52 44.52,67.57 44.93,67.97 PR4638.1
PWR_VCCSA_FB2: length 5.4
  BOTTOM w0.254: v2(48.46,69.12) 48.28,68.94 PC4617.2 48.56,67.95 PC4620.1 48.56,66.73 PR4601.1 48.49,66.69 47.1,66.69 46.96,66.55 PC4616.2 46.63,67.26 PR4637.2
PWR_VCCSA_FB_RC: length 1.7
  BOTTOM w0.381: PR4632.1 47.21,68.07 PC4617.1 47.37,67.57 v2(47.59,67.34)
PWR_VCCSA_FCCM: length 157.5
  TOP w0.254: v1(42.82,63.88) 42.82,63.45 v2(43.12,63.15)
  L4 w0.254: v1(87.78,106.15) 87.78,106 88.16,105.62 90.37,105.62 91.59,104.4 v1(91.69,104.4) ; v1(14.73,68.05) 14.8,67.97 14.8,66.75 15.39,66.17 15.39,62.74 15.92,62.21 15.92,57.36 18.64,54.64 21.4,54.64 21.84,55.07 22.62,55.07 23.37,55.82 23.96,55.82 25.98,57.84 29.77,57.84 29.77,57.84 30.64,57.84 31.05,58.24 31.64,58.24 31.94,58.54 31.94,58.91 32.29,59.26 33.78,59.26 33.93,59.41 34.39,59.41 34.46,59.34 34.95,59.34 35.48,59.86 35.48,60.81 35.55,60.89 35.55,61.62 36.77,62.84 36.77,63.6 36.67,63.71 36.67,64.16 37.05,64.54 38.53,64.54 39.64,63.43 42.41,63.43 42.72,63.73 42.72,63.76 42.82,63.86 v1(42.82,63.88)
  L6 w0.254: v1(14.73,68.05) 13.81,68.97 13.81,78.92 17.35,82.47 19.96,82.47 21.13,83.64 21.13,84.1 21.58,84.56 21.58,87.3 21.21,87.67 21.21,88.84 22.98,90.6 22.98,91.34 22.37,91.95 22.37,93.96 24.3,95.89 27.65,95.89 28.37,96.6 38.67,96.6 40.35,98.29 40.35,98.3 40.63,98.58 62.2,98.58 70.76,107.14 77.46,107.14 77.99,106.62 87.35,106.62 87.78,106.19 v1(87.78,106.15)
  BOTTOM w0.203: v1(42.82,63.88) 42.89,63.95 42.89,64.76 42.68,64.96 PU4601.29
  BOTTOM w0.254: v1(91.69,104.4) 91.59,104.4 91.35,104.63 PU5001.7
PWR_VCCSA_IMON: length 3.9
  TOP w0.254: PR4644.1 41.52,67.01 PC4629.2 41.57,67.82 v2(42.8,67.82) 42.97,67.64 v1(43.38,67.64)
  BOTTOM w0.203: PU4601.23 42.72,67.36 42.79,67.44 43.12,67.44 43.3,67.62 43.35,67.62 v1(43.38,67.64)
PWR_VCCSA_ISUMN: length 129.5
  TOP w0.203: 96.83,105.76 96.01,106.58 92.59,106.58 92.16,107.01 86.88,107.01 86.14,106.27 86.14,104.24 86.13,104.23 86.13,101.97 86.4,101.69 86.4,100.12 88.79,97.73 88.79,97.01 v1(88.61,96.83) ; 96.83,105.76 97.42,105.17 v1(97.71,105.17) ; 96.83,105.76 v2(96.95,105.87)
  L3 w0.203: v1(88.61,96.83) 88.72,96.73 88.72,95.94 87.67,94.9 80.45,94.9 79.33,93.77 72.51,93.77 71.79,94.49 66.43,94.49 65.44,93.5 46.83,93.5 45.92,94.41 44.83,94.41 40.58,90.17 40.58,88.71 36.98,85.1 36.98,83.06 36.11,82.2 36.11,75.49 36.44,75.16 36.44,74.61 33.49,71.66 33.49,68.41 32.68,67.6 32.68,66.82 33.04,66.46 v1(33.04,66.45)
  L6 w0.203: v1(47.7,63.78) 47.57,63.91 45.04,63.91 44.26,64.7 41.33,64.7 40.85,64.21 39.13,64.21 37.7,65.64 34.27,65.64 33.64,66.27 33.54,66.27 33.36,66.45 33.07,66.45 33.07,66.45 v1(33.04,66.45)
  BOTTOM w0.203: PR5004.2 100.02,105.97 100.02,106.16 99.87,106.31 99.87,106.33 99.49,106.71 98.22,106.71 97.76,106.25 97.76,106.24 97.58,106.06 PR4611.1 97.71,105.77 v1(97.71,105.17) ; PR4620.1 45.03,64.83 PR4618.2 45.79,64.75 PC4605.1 46.1,64.44 PR4613.1 46.1,63.7 PR4615.1 46.76,63.05 PC4603.2 47.52,63.6 v1(47.7,63.78)
PWR_VCCSA_ISUMN_P_1: length 2.1
  BOTTOM w0.254: v2(47.78,64.53) 47.77,64.52 47.37,64.52 47.21,64.67 PC4608.2 46.63,64.53 46.96,64.2 PR4613.2
PWR_VCCSA_ISUMN_P_2: length 101.5
  TOP w0.254: v1(48.1,97.56) 48.1,96.68 48.41,96.37 48.41,95.26 48.61,95.05 48.61,92.99 47.67,92.05 47.67,89.11 48.18,88.6 48.18,86.06 v1(48.74,85.5)
  L3 w0.203: v1(96.13,105.16) 94.86,103.89 89.43,103.89 87.19,101.65 83.56,101.65 82.37,102.85 81.6,102.85 81.1,102.34 81.1,101.37 80.79,101.07 79.01,101.07 78.6,101.48 75.98,101.48 75.97,101.49 75.95,101.49 74.68,102.76 73.61,102.76 73.59,102.77 73.26,102.77 73.25,102.78 72.35,102.78 68.53,98.97 65.21,98.97 63.21,96.97 50.26,96.97 49.99,96.7 48.97,96.7 v1(48.1,97.56)
  L3 w0.254: v1(49.35,63.76) 49.35,63.07 49.09,62.82 47.39,62.82 41.78,68.43 41.78,69.78 42.64,70.64 42.64,71.1 44.11,72.57 44.11,74.12 45.03,75.03 45.03,75.82 45,75.85 45,76.3 45.03,76.33 45.03,77.22 46.3,78.49 46.3,78.9 46.27,78.92 46.27,79.43 47.39,80.55 47.39,84.28 48.61,85.5 v1(48.74,85.5)
  BOTTOM w0.254: PR4625.2 49.39,64.95 48.97,64.52 48.97,64.21 v2(48.99,64.21) 48.99,64.01 49.24,63.76 v1(49.35,63.76) ; v1(96.13,105.16) 96.72,105.74 PR4611.2
PWR_VCCSA_ISUMN_R: length 7.1
  BOTTOM w0.203: PG5001.1 100.11,100.43 99.88,100.66 99.88,104.41 PR5004.1 100.48,104.83 100.93,105.29 100.93,106.34 v2(101.11,106.52)
PWR_VCCSA_ISUMN_RC: length 1.6
  BOTTOM w0.254: v2(45.19,63.88) 45.19,63.88 45.18,63.87 PC4611.2 45.79,62.99 PR4615.2
PWR_VCCSA_ISUMNB: length 3.6
  BOTTOM w0.203: PR4620.2 43.57,64.7 v2(43.35,64.7) 43.35,64.79 42.78,65.36 PU4601.28
  BOTTOM w0.254: PR4620.2 44.26,63.95 PC4611.1
PWR_VCCSA_ISUMP: length 130
  TOP w0.203: 95.1,106.25 v2(95.1,106.07) ; 95.1,106.25 95.87,106.25 97.44,104.68 97.5,104.68 97.5,104.68 97.91,104.68 98.34,105.11 v1(98.34,105.13) ; 95.1,106.25 92.45,106.25 92.02,106.68 87.01,106.68 86.47,106.14 86.47,104.1 86.46,104.09 86.46,102.11 86.74,101.83 86.74,100.26 89.12,97.87 89.12,96.95 v1(89.28,96.8)
  L3 w0.203: v1(33.17,67.21) 33.17,67.62 33.82,68.27 33.82,71.52 36.77,74.47 36.77,75.3 36.44,75.62 36.44,82.06 37.31,82.92 37.31,84.97 40.91,88.57 40.91,90.04 44.96,94.08 45.78,94.08 46.69,93.17 65.58,93.17 66.57,94.16 71.65,94.16 72.37,93.44 79.46,93.44 80.59,94.57 87.81,94.57 89.05,95.8 89.05,96.57 v1(89.28,96.8)
  L6 w0.203: v1(33.17,67.21) 33.17,67.11 33.67,66.6 33.78,66.6 34.41,65.97 37.84,65.97 39.26,64.54 40.71,64.54 41.19,65.03 44.39,65.03 45.18,64.24 47.43,64.24 47.63,64.44 47.63,65.03 v1(47.69,65.08)
  BOTTOM w0.203: PU4601.27 42.84,65.76 43.28,65.33 44.9,65.33 PR4618.1 45.16,65.59 PC4605.2 PC4608.1 46.86,65.59 47.29,65.15 47.62,65.15 v1(47.69,65.08) 48.48,65.08 PR4625.1 ; PR5003.2 99.53,106.2 99.35,106.38 98.35,106.38 98.09,106.11 98.09,105.49 98.34,105.23 v1(98.34,105.13)
PWR_VCCSA_ISUMP_R: length 6.4
  BOTTOM w0.203: v2(98.62,105.79) 98.7,105.79 98.9,105.59 98.9,105.44 99.51,104.83 PR5003.1 99.55,104.81 99.55,100.64 99.35,100.43 PG5011.1
PWR_VCCSA_PWM: length 149.4
  TOP w0.254: v1(42.18,63.93) 42.13,63.88 v2(41.62,63.88)
  L4 w0.254: v1(42.18,63.93) 39.87,63.93 38.6,65.2 36.98,65.2 35.71,63.93 35.71,62.51 34.46,61.27 34.46,60.45 33.94,59.92 33.09,59.92 32.96,59.79 31.9,59.79 31.42,59.31 31.27,59.31 30.87,58.91 30.87,58.79 30.43,58.35 29.98,58.35 29.98,58.35 25.77,58.35 23.76,56.34 23.29,56.34 23.26,56.31 23.13,56.31 22.4,55.58 21.62,55.58 21.19,55.15 18.85,55.15 16.43,57.57 16.43,62.44 15.89,62.97 15.89,66.4 15.34,66.96 15.34,68.18 v1(14.73,68.79)
  L6 w0.254: v1(87.14,106.11) 77.76,106.11 77.24,106.63 70.99,106.63 62.43,98.07 40.86,98.07 38.88,96.09 28.59,96.09 27.86,95.36 24.5,95.36 22.88,93.74 22.88,92.18 23.49,91.57 23.49,90.35 21.74,88.6 21.74,87.89 22.09,87.53 22.09,84.28 21.79,83.98 21.79,83.26 19.7,81.18 16.78,81.18 14.31,78.71 14.31,69.2 v1(14.73,68.79)
  BOTTOM w0.203: v1(42.18,63.93) 42.18,64.46 PU4601.30
  BOTTOM w0.254: PU5001.3 88.59,105.13 88.1,105.62 87.4,105.62 87.14,105.88 v1(87.14,106.11)
PWR_VCCSA_RTN: length 9.9
  TOP w0.254: v1(43.35,65.99) v2(42.73,65.37) 42.21,64.85 PR4627.2 41.52,64.87 PC4613.1
  BOTTOM w0.203: v1(43.35,65.99) 43.18,66.16 PU4601.26
  BOTTOM w0.254: PR4602.1 48.05,65.92 47.77,66.2 47.24,66.2 47.06,66.02 46.25,66.02 PC4616.1 45.56,66.4 45.05,66.4 44.39,65.74 43.61,65.74 v1(43.35,65.99)
PWR_VCCSA_SW: length 11
  TOP w0.508: PC5005.2 89.22,103.23 v3(90.36,103.23)
  TOP w0.635: v3(96.95,98.12) 96.95,98.35 91.99,103.3 90.44,103.3 v3(90.36,103.23)
  vias: v2(94.08,105.11)
PWR_VCORE_ALERT#: length 2.3
  BOTTOM w0.089: PR4623.2 39.54,61.85 39.54,63.38 39.7,63.54 PU4601.36
PWR_VCORE_BOOT: length 2
  TOP w0.305: 50.36,62.23 50.38,62.25 PU4701.5
  TOP w0.508: 50.36,62.23 v2(50.08,62.23) PR4705.2
PWR_VCORE_BOOT_RC: length 2.6
  TOP w0.254: PR4705.1 47.72,62.66 47.37,63.02 47.37,63.17 47.26,63.27 v2(47.26,63.38)
  TOP w0.508: PR4705.1 47.72,60.97 PC4707.1
PWR_VCORE_BOOTR: length 2.2
  TOP w0.305: 50.03,60.96 50.32,61.25 PU4701.7
  TOP w0.635: v2(50.08,60.94) 50.06,60.94 ; 50.06,60.94 50.03,60.96 ; 50.06,60.94 50.03,60.94 50.01,60.96 PC4707.2
PWR_VCORE_COMP: length 6.6
  BOTTOM w0.203: 40.11,70.37 40.1,70.36 40.1,70.26 40.11,70.25 40.11,69.91 40.1,69.91 PU4601.16
  BOTTOM w0.254: 40.11,70.37 40.11,71.03 38.68,72.47 v2(38.2,72.47) 37.94,72.72 PC4639.1 PR4656.1
PWR_VCORE_COMP1: length 0.7
  BOTTOM w0.254: PC4640.1 38.81,74.81 PR4656.2
PWR_VCORE_FB: length 4.9
  BOTTOM w0.203: PU4601.17 40.5,69.9
  BOTTOM w0.254: PR4658.1 PR4660.1 41.11,71.81 PR4657.1 40.66,71.35 v2(40.66,70.77) 40.66,70.06 40.5,69.9
PWR_VCORE_FB1: length 2
  BOTTOM w0.381: PC4641.1 39.41,73.08 v2(39.41,72.39) 40.02,71.78 PR4657.2
PWR_VCORE_FB2: length 5
  BOTTOM w0.254: v2(40.74,76.76) 40.74,76.15 PR4663.2 41.02,75.14 PC4644.1 40.98,74.5 PC4643.2 ; PR4660.2 41.23,73.39 PC4642.2
  BOTTOM w0.305: PC4642.2 41.88,73.49 PR4667.2 41.77,74.32 PC4643.2
PWR_VCORE_FB_RC: length 0.9
  BOTTOM w0.305: PR4658.2 40.24,73.62 PC4643.1
PWR_VCORE_FCCM#: length 12.7
  TOP w0.254: v1(43.81,68.84) 43.91,68.84 44.09,68.66 44.24,68.66 44.29,68.61 v2(44.34,68.61) ; v1(48.81,63.32) 48.74,63.4 PR4706.2
  L3 w0.254: v1(43.81,68.84) 45.92,68.84 47.77,66.98 47.77,66.98 48.71,66.04 48.71,63.43 v1(48.81,63.32)
  BOTTOM w0.203: v1(43.81,68.84) 43.68,68.84 43.3,68.46 43.02,68.46 42.73,68.16 PU4601.21
PWR_VCORE_FCCM#_R: length 1.9
  TOP w0.254: PU4701.2 50.73,63.75 50.49,63.99 50.49,64.01 49.78,64.71 PR4706.1
PWR_VCORE_IMON: length 8.8
  BOTTOM w0.203: 39.08,69.85 39.3,69.64 PU4601.14
  BOTTOM w0.254: PC4638.1 37.09,75.71 PR4661.1 37.03,74.89 36.57,74.43 36.57,72.8 37.38,71.99 37.38,70.97 v2(37.97,70.39) 38.73,70.39 39.08,70.03 39.08,69.85
PWR_VCORE_ISUMN: length 24.1
  L6 w0.203: v1(58.03,67.24) 57.55,67.24 56.94,67.85 50.9,67.85 50.03,66.98 46.96,66.98 45.36,68.58 45.36,70.31 45.57,70.52 45.86,70.52 46.04,70.34 v1(46.1,70.34)
  BOTTOM w0.203: v1(46.1,70.34) 45.92,70.51 PR4648.2 PR4651.2 46.1,71.94 PR4701.2 46.25,72.65 PC4631.1 45.76,73.13 PR4649.2 45.16,73.15 PR4652.2 44.42,73.13 PC4634.1 ; v2(58.54,67.62) 58.49,67.62 58.21,67.34 58.13,67.34 v1(58.03,67.24) 57.45,67.24 PR4650.1
PWR_VCORE_ISUMN_G: length 23.3
  L6 w0.203: v1(59.76,68.63) 59.61,68.48 59.61,68.43 59.07,67.9 59.06,67.9 58.98,67.82 57.91,67.82 57.86,67.87 57.85,67.87 56.07,69.65 49.87,69.65 48.88,70.64 47.14,70.64 v1(46.96,70.46)
  BOTTOM w0.203: PR4701.1 46.96,71.78 v1(46.96,70.46) ; PG4708.1 61.82,62.82 61.61,63.02 61.61,63.94 60.65,64.91 60.65,66.79 59.81,67.63 v2(59.81,67.67) 59.77,67.67 59.48,67.96 59.48,68.3 59.76,68.58 v1(59.76,68.63)
PWR_VCORE_ISUMN_P_1: length 2.6
  BOTTOM w0.254: PC4635.1 PC4652.1 45.1,73.92 PR4649.1 46.02,73.99 v2(46.17,73.84)
PWR_VCORE_ISUMN_P_2: length 20.8
  TOP w0.254: v1(50.01,67.69) 49.93,67.62 47.97,67.62 v2(47.37,68.21) 44.98,70.61 44.98,74.02 v1(45.59,74.63)
  L6 w0.254: v1(50.01,67.69) 50.01,67.82 50.64,68.46 54.68,68.46 54.71,68.48 55.14,68.48 55.39,68.74 v1(55.39,68.96)
  BOTTOM w0.254: PR4650.2 56.2,67.13 55.8,67.54 55.8,68.46 55.39,68.86 v1(55.39,68.96) ; PR4653.2 45.13,75.47 45.59,75.01 v1(45.59,74.63)
PWR_VCORE_ISUMN_RC: length 2.1
  BOTTOM w0.254: v2(45.26,72.21) 44.57,71.53 PR4651.1 43.99,71.28 PC4632.1
PWR_VCORE_ISUMNA: length 3.9
  BOTTOM w0.203: 42.54,68.74 42.08,68.74 42.07,68.75 PU4601.20
  BOTTOM w0.254: PR4648.1 44.14,70.51 PC4632.2 43.76,69.78 42.97,68.99 v2(42.97,68.91) 42.79,68.74 42.54,68.74
PWR_VCORE_ISUMP: length 8.6
  BOTTOM w0.203: PR4708.2 43.61,76.08 PR4653.1 43.61,74.75 PC4635.2 PC4652.2 PR4652.1 43.5,73.13 PC4634.2 43.5,71.66 42.77,70.92 v2(42.77,70.52) 41.7,69.45 41.5,69.45 41.3,69.25 PU4601.19
PWR_VCORE_ISUMP_G: length 28.3
  TOP w0.203: v1(46.27,70.97) 45.59,71.66 45.59,73.31 46.07,73.79 46.07,74.91 v2(45.51,75.47) v1(45.51,76.08)
  L6 w0.203: v1(46.27,70.97) 49.02,70.97 50.01,69.98 56.2,69.98 57.98,68.2 57.99,68.2 58.04,68.15 58.85,68.15 59.13,68.43 v1(59.13,68.63)
  BOTTOM w0.203: v1(59.13,68.63) 59.15,68.61 59.15,67.71 60.32,66.54 60.32,64.77 61.28,63.81 61.28,63.05 61.06,62.82 PG4707.1 ; PR4708.1 45.36,76.23 v1(45.51,76.08)
PWR_VCORE_NTC: length 2.5
  BOTTOM w0.203: PU4601.15 39.7,69.9
  BOTTOM w0.254: 39.7,69.98 39.7,70.66 PR4662.1 ; 39.7,69.98 v2(39.69,69.98) ; 39.7,69.98 39.7,69.9
PWR_VCORE_NTC1: length 37.3
  TOP w0.254: v1(38.1,71.21) 38.96,71.21 39.84,70.33 39.84,69.16 v2(36.17,65.49) 34.56,63.88 34.56,62.72 33.95,62.11 v1(33.95,60.66) ; v1(48.84,58.12) 48.86,58.14 PR4654.1
  L6 w0.254: v1(33.95,60.66) 33.95,59.9 34.69,59.16 39.95,59.16 41.29,60.51 41.29,60.84 41.57,61.12 43.22,61.12 45.56,58.78 48.36,58.78 48.84,58.3 v1(48.84,58.12)
  BOTTOM w0.254: PR4655.2 37.13,72.98 37.79,72.32 37.79,71.52 v1(38.1,71.21) 38.54,71.66 PR4662.2
PWR_VCORE_PROG1: length 5.6
  BOTTOM w0.203: v2(42.16,62.97) 41.85,62.97 41.3,63.52 PU4601.32
  BOTTOM w0.254: PR4629.1 45.3,61.51 44.9,61.9 43.9,61.9 42.83,62.97 v2(42.16,62.97)
PWR_VCORE_PROG2: length 5
  BOTTOM w0.203: PU4601.31 41.7,63.71 42.01,63.4 42.34,63.4 42.39,63.35
  BOTTOM w0.254: 42.39,63.35 43.25,63.35 v2(43.42,63.19) 43.42,63.1 44.11,62.41 45.69,62.41 PR4628.1
PWR_VCORE_PWM: length 13.1
  TOP w0.254: v2(44.06,67.41) 44.06,67.87 v1(43.73,68.2) ; PR4702.2 48.51,65.48 48.2,65.18 48.2,63.38 v1(48.15,63.32)
  L3 w0.254: v1(48.15,63.32) 48.2,63.38 48.2,65.81 45.88,68.14 43.79,68.14 v1(43.73,68.2)
  BOTTOM w0.203: v1(43.73,68.2) 43.66,68.13 43.17,68.13 42.82,67.77 42.64,67.77 42.63,67.76 PU4601.22
PWR_VCORE_PWM_R: length 3.9
  TOP w0.254: PU4701.1 49.84,65.48 PR4702.1 PR4712.1 49.6,66.78 v2(49.19,67.19)
PWR_VCORE_RTN: length 6.5
  BOTTOM w0.203: PU4601.18 40.9,69.64 41.22,69.95
  BOTTOM w0.254: 41.22,69.95 v2(41.6,69.95) 42.4,70.76 42.4,71.14 42.79,71.53 PR4659.2 42.7,71.88 PC4637.1 PC4642.1 PR4668.2
PWR_VCORE_SCLK: length 5
  BOTTOM w0.089: PU4601.37 39.3,62.75 38.53,61.98 v2(38.53,61.27) 38.53,61.12 38.25,60.84 38.25,60.12 PR4624.2
PWR_VCORE_SDIO: length 2.7
  BOTTOM w0.089: PU4601.35 40.1,63.4 39.9,63.2 v2(39.9,62.89) 39.9,62.72 40.05,62.56 40.05,61.7 PR4622.2
PWR_VCORE_SNB: length 2.8
  TOP w0.254: PR4703.2 63.49,61.8 v2(64.1,61.8) PC4706.1
PWR_VCORE_SW:
  vias: v2(54.96,65.18) v2(57.98,63.86) v3(55.92,65.1) v3(56.03,65.97) v3(56.75,64.62) v3(56.76,65.51) v3(56.77,63.73) v3(56.77,62.84) v3(56.8,61.95) v3(56.8,61.06) v3(56.84,60.18) v3(56.81,59.26) v3(57.7,65.1) v3(57.83,60.46) v3(57.83,59.44) v3(58.24,58.7) v3(58.59,65.1) v3(58.72,60.46) v3(58.72,59.44) v3(59.46,65.08) v3(59.61,60.4) v3(59.61,59.39)
PWR_VCORE_VCC: length 3.7
  BOTTOM w0.203: 40.51,63.32 40.5,63.33 PU4601.34
  BOTTOM w0.305: PR4610.2 40.91,60.84 PC4607.1 40.91,62.18 40.94,62.21 v2(40.94,62.26) 40.94,62.74 40.51,63.17 40.51,63.32
PWR_VCORE_VCC_R: length 3
  TOP w0.254: v1(50.01,63.76) 50.53,63.25 PU4701.3
  BOTTOM w0.203: v1(50.01,63.76) 50.79,63.76 PC4708.1 50.88,63.85 PR4704.1
PWR_VCORE_VIN: length 5.2
  BOTTOM w0.203: PU4601.33 40.9,63.34 41.4,62.84
  BOTTOM w0.305: v2(44.65,61.37) 44.6,61.32 PR4612.2 43.35,61.32 42.79,61.88 PC4606.1 42.36,61.88 41.4,62.84
PWR_VCORE_VRHOT#: length 2.8
  BOTTOM w0.203: PU4601.38 38.9,63.1 38.7,62.89 v2(38.68,62.89)
  BOTTOM w0.254: PR4607.2 37.64,61.95 38.58,62.89 v2(38.68,62.89)
PWR_VDDQ:
  vias: v2(41.09,14.13) v3(43.05,14.76) v3(43.1,15.61) v3(43.1,13.92) v3(43.1,12.31)
PWR_VDDQ_BOOT: length 1.4
  BOTTOM w0.203: 51.68,15.52 51.97,15.23 PU5101.27
  BOTTOM w0.508: 51.68,15.52 PR5111.1
PWR_VDDQ_BOOTA: length 3
  BOTTOM w0.508: v2(52.75,17.43) 51.45,17.43 PR5111.2 51,17.88 PC5114.2
PWR_VDDQ_BOOTB: length 3.1
  BOTTOM w0.203: 50.49,14.96 50.6,14.86 PU5101.25
  BOTTOM w0.508: 50.49,14.96 50.44,14.96 49.83,15.57 v2(49.83,15.85) 49.83,16.87 PC5114.1
PWR_VDDQ_CS: length 2.4
  BOTTOM w0.203: PR5102.2 53.57,10.23 PU5101.10
  BOTTOM w0.254: PR5102.2 53.49,9.6 v2(52.62,9.6)
PWR_VDDQ_EN: length 2.7
  BOTTOM w0.102: PR5105.2 56.74,12.98 56.04,12.28 PU5101.6
PWR_VDDQ_FB: length 3.8
  TOP w0.381: 54.53,13.29 54.63,13.19 v1(55.47,13.19) 55.77,13.19 55.92,13.34 PR5107.2 56.33,13.24 v2(56.33,12.42)
  BOTTOM w0.203: v1(55.47,13.19) 55.17,13.48 PU5101.3
PWR_VDDQ_PG: length 7.3
  BOTTOM w0.102: v2(59.58,14.23) 59.58,13.57 59.15,13.13 PR5109.2 PR5104.2 58.9,11.66 56.84,11.66 56.66,11.48 55.95,11.48 55.9,11.43 55.01,11.43 54.96,11.48 PU5101.8
PWR_VDDQ_PH: length 1.4
  TOP w0.508: PR5110.1 48.76,11.08 v1(49.57,11.89)
  vias: v2(48.97,12.35)
PWR_VDDQ_SNB: length 2.6
  TOP w0.508: v2(45.84,9.5) PR5110.2 PC5118.1
PWR_VDDQ_TON: length 2.5
  BOTTOM w0.127: PU5101.7 55.59,11.88 v2(55.63,11.92) 56.62,11.92 PR5103.2
PWR_VDDQ_VCC: length 4.1
  BOTTOM w0.203: PR5102.1 54.7,9.96 53.97,10.69 PU5101.9
  BOTTOM w0.508: PR5102.1 54.78,9.88 PC5108.1 56.03,9.88 56.15,9.76 v2(56.53,9.76) 56.65,9.87 57.02,9.87 PR5108.2
PWR_VDDQ_VDDQ: length 33.9
  TOP w0.127: v1(55.49,13.87) 55.82,14.2 PR5107.1 56.24,14.21 58.05,14.21 58.15,14.32 60.17,14.32 60.83,13.66 v1(60.83,11.24)
  TOP w0.254: PG5113.1 39.41,10.99 v1(39.03,10.6)
  L6 w0.127: v1(50.51,10.14) 51.42,11.04 60.7,11.04 60.83,11.17 v1(60.83,11.24)
  BOTTOM w0.127: v1(55.49,13.87) 55.42,13.87 55.41,13.88 PU5101.2 ; v1(50.51,10.14) 50.51,9.96 v2(50.03,9.48) 49.91,9.35 39.39,9.35 39.03,9.71 v1(39.03,10.6)
PWR_VDDQ_VLDOIN: length 1.7
  BOTTOM w0.203: 52.5,15.75 52.37,15.63 PU5101.28
  BOTTOM w0.508: v3(53,16.26) 52.5,15.75
  vias: v2(54.05,16.74)
PWR_VDDQ_VTT: length 1.4
  BOTTOM w0.203: 53.13,15.55 53.13,15.52 52.77,15.16 PU5101.29 ; 53.56,15.37 53.56,14.86 PU5101.31
  vias: v2(56.71,17.68)
PWR_VDDQ_VTTREF: length 2
  BOTTOM w0.203: PU5101.1 54.89,14.28 55.29,14.68 v2(55.52,14.68) 56.18,14.68 PC5113.1
PWR_VGA_CORE_BOOT1: length 2.1
  TOP w0.203: v2(121.13,102.42) 120.56,101.84 PU8514.1
  TOP w0.508: v2(121.13,102.42) 121.13,103.46
PWR_VGA_CORE_BOOT1_1: length 2.6
  TOP w0.635: v2(123.54,104.78) 122.6,104.78 PC8509.1 122.37,104.6 121.3,104.6 PR8506.2
PWR_VGA_CORE_BOOT2:
  vias: v2(121.33,98.07)
PWR_VGA_CORE_BOOT2_1: length 2.8
  TOP w0.254: v2(122.68,95.46) 122.68,96.37 PC8517.1
  TOP w0.635: PR8509.2 121.39,95.86 121.89,95.86 121.91,95.89 121.93,95.89 122.52,96.48 PC8517.1
PWR_VGA_CORE_EN: length 105.6
  TOP w0.089: PU8514.3 119.76,102.31 v2(119.48,102.59) 118.59,103.48 PC8526.2 118.59,104.75 PR8523.2 PR8522.2 118.54,106.53 118.95,106.94 118.95,107.75 117.9,108.79 110.75,108.79 108.89,106.93 107.31,106.93 106.79,106.4 R8529.1 105.68,106.4 R8546.2 ; R8546.2 105.61,105.72 104.82,104.93 104.82,101.96 105.18,101.6 107.47,101.6 108.25,100.83 108.25,99.87 v1(108.53,99.59) ; R8546.2 105.15,106.94 104.44,106.94 103.6,107.77 v1(103.6,108.33)
  L6 w0.102: v1(158.52,75.21) 158.52,75.37 156.56,77.32 154.99,77.32 151.68,80.62 151.47,80.62 150.51,81.58 150.51,82.06 149.08,83.49 146.98,83.49 145.94,84.53 145.28,84.53 139.92,89.89 129.01,89.89 129.01,89.89 128.43,89.89 125.08,93.25 123.87,93.25 123.84,93.27 123.67,93.27 123.66,93.27 123.48,93.27 123.33,93.42 123.33,93.6 122.75,94.19 117.27,94.19 116.35,95.1 116.32,95.1 115.05,96.38 113.53,96.38 113.52,96.38 113.27,96.38 112.67,96.98 112.67,97.48 112.34,97.81 111.84,97.81 111.08,97.04 110.42,97.04 108.53,98.94 v1(108.53,99.59)
  BOTTOM w0.089: v1(103.6,108.33) 103.6,107.7 C8501.2 ; D8602.A 163.57,75.77 162.91,75.11 161.3,75.11 160.81,74.62 159.21,74.62 158.62,75.21 v1(158.52,75.21)
PWR_VGA_CORE_LGATE1: length 17.8
  TOP w0.203: PU8514.19 121.58,100.53 121.91,100.87 v3(122.22,100.87)
  TOP w0.508: v3(122.22,100.87) 122.47,101.12 PR8508.1
  TOP w0.635: v3(134,100.36) 133.83,100.18 PU8510.8
  L3 w0.635: v3(122.22,100.87) 122.35,100.74 127.93,100.74 v3(128.21,100.46) 128.49,100.18 133.83,100.18 v3(134,100.36)
  BOTTOM w0.305: v3(122.22,100.87) 122.8,100.28 v2(122.96,100.28)
  BOTTOM w0.635: v3(128.21,100.46) 128.49,100.18 PU8512.8
PWR_VGA_CORE_LGATE2: length 15.8
  TOP w0.203: v3(122.12,99.34) 121.73,99.73 PU8514.17
  TOP w0.635: v3(128.37,98.63) 128.39,98.63 128.47,98.71 PU8515.8
  L3 w0.635: v3(133.93,98.45) 133.67,98.71 128.47,98.71 128.39,98.63 v3(128.37,98.63) 128.29,98.71 125.14,98.71 124.5,99.34 v3(122.12,99.34)
  BOTTOM w0.305: v2(122.6,98.86) v3(122.12,99.34)
  BOTTOM w0.635: PU8516.8 133.67,98.71 v3(133.93,98.45)
PWR_VGA_CORE_PHASE1: length 11
  L3 w0.635: v3(134.31,104.6) 133.9,104.19 123.97,104.19 v3(123.63,103.85)
  vias: v2(135.1,103.76)
PWR_VGA_CORE_PHASE2: length 11.8
  L3 w0.635: v3(123.57,97.82) 124.53,96.85 128.19,96.85 129.56,95.48 v3(134.41,95.48)
  vias: v2(135.5,95.13)
PWR_VGA_CORE_PSI: length 5.5
  TOP w0.102: PU8514.4 119.36,101.93 v2(118.13,103.15) 117.88,103.41 PC8522.2 117.72,104.22 PR8517.1 PR8515.2 117.72,106.23 PR8516.2
PWR_VGA_CORE_REFADJ: length 3.9
  TOP w0.203: PU8514.6 117.49,100.93 117.29,101.13 v2(117.29,101.2)
  TOP w0.254: v2(117.29,101.2) v1(117.29,101.76)
  BOTTOM w0.127: v1(117.29,101.76) 117.24,101.81 116.12,101.81 115.84,102.09 PR8511.1
PWR_VGA_CORE_REFIN: length 10.4
  TOP w0.127: PU8514.7 117.78,100.53 117.75,100.56 117.22,100.56 v1(116.48,101.3)
  TOP w0.254: PC8521.1 114.75,96.85 PR8512.1 114.19,97.41 v1(113.63,97.41) 113.63,97.06 113.38,96.8 PR8514.1
  BOTTOM w0.127: v1(113.63,97.41) 114.08,97.41 115.44,98.77 v2(115.44,100.36) 115.54,100.36 v1(116.48,101.3)
PWR_VGA_CORE_REFIN_R: length 2.4
  TOP w0.254: v2(113.43,95.46) 113.81,95.46 114.24,95.89 PR8514.2 114.8,96.34 PR8561.2
PWR_VGA_CORE_RGND:
  vias: v2(116.88,97.26)
PWR_VGA_CORE_SS: length 3.5
  BOTTOM w0.254: v2(118.79,100.87) 118.03,100.87 PC8518.1 117.95,100.79 PR8577.1 118.18,100.08 PR8526.1 PR8527.1
PWR_VGA_CORE_SS/VSEN: length 3.5
  TOP w0.127: v1(118.61,97.87) 118.96,98.21 PU8514.11
  BOTTOM w0.254: v2(118.61,97.26) v1(118.61,97.87) 118.79,98.04 PR8526.2 118.08,99.32 PR8576.2
PWR_VGA_CORE_TON: length 3.2
  TOP w0.127: PU8514.9 117.84,99.73 117.69,99.89 117.02,99.89 116.94,99.98 v2(116.88,99.98) 116.63,99.72 115.51,99.72 PR8504.2
PWR_VGA_CORE_TON_1: length 5.3
  TOP w0.127: PC8507.2 113.98,101.44 113.98,100.27 114.32,99.93 PR8504.1
  TOP w0.254: PC8507.2 115.74,103.2 PR8503.2 116.5,103.2 v2(116.68,103.03)
PWR_VGA_CORE_UGATE1: length 19.4
  TOP w0.203: v3(120.26,102.49) 120.16,102.39 PU8514.2
  TOP w0.635: v3(134,105.84) 133.78,106.07 PU8510.1
  L3 w0.635: v3(120.26,102.49) 120.65,102.49 123.49,105.34 127.96,105.34 v3(128.31,105.69) 128.47,105.84 v3(134,105.84)
  BOTTOM w0.305: v2(133.98,107.01) 134,106.99 v3(134,105.84)
  BOTTOM w0.635: v3(128.31,105.69) 128.7,106.07 PU8512.1
PWR_VGA_CORE_UGATE2: length 19.6
  TOP w0.203: v3(120.44,97.87) 120.44,98.05 120.16,98.33 PU8514.14
  TOP w0.635: v3(128.19,93.32) 128.19,93.17 128.54,92.81 PU8515.1
  L3 w0.635: v3(133.9,93.21) 133.76,93.34 128.21,93.34 v3(128.19,93.32) 128.11,93.4 128.03,93.4 125.72,95.71 124.02,95.71 121.85,97.88 120.45,97.88 v3(120.44,97.87)
  BOTTOM w0.305: v2(120.8,97.13) 120.8,97.51 v3(120.44,97.87)
  BOTTOM w0.635: v3(133.9,93.21) 133.43,93.21 PU8516.1
PWR_VGA_CORE_VID: length 4.8
  TOP w0.203: 118.6,101.62 PU8514.5
  TOP w0.254: v1(117.6,102.57) 118.55,101.62 118.6,101.62
  BOTTOM w0.254: v2(114.88,102.97) 115.61,102.97 PC8510.2 116.5,103.13 PR8507.2 117.11,102.57 v1(117.6,102.57)
PWR_VGA_CORE_VREF: length 10.2
  TOP w0.127: v1(113.54,98.37) 113.81,98.63 114.78,98.63 PC8514.2 ; v1(115.63,101.46) 115.31,101.14 PR8510.1 116.71,100.69 117.09,100.31 117.62,100.31 117.67,100.26 117.68,100.26 117.8,100.13 PU8514.8
  BOTTOM w0.127: v1(113.54,98.37) v2(114.23,98.37) 114.34,98.37 114.88,98.91 114.88,100.38 115.63,101.14 v1(115.63,101.46)
PWR_VGA_CORE_VREF_R: length 8.2
  TOP w0.127: PR8510.2 114.45,101.02 114.68,101.25 114.83,101.25 v1(114.88,101.3) ; PC8519.1 114.85,97.61 PR8512.2 114.09,97.92 113.36,97.92 113.1,98.18 113.1,98.76 v1(113.28,98.94)
  BOTTOM w0.127: v1(113.28,98.94) 113.84,99.5 v2(113.84,99.9) 113.84,100.41 114.68,101.25 114.83,101.25 v1(114.88,101.3) 114.88,101.4 114.32,101.96 PR8511.2
PWR_VGA_CORE_VSNS: length 5.9
  TOP w0.254: PC8524.1 117.49,98.02 v1(117.32,97.84) 117.32,97.54 117.7,97.16 PR8525.2 118.33,96.78 PC8523.1
  BOTTOM w0.254: v2(116.17,99.32) PR8576.1 PR8519.1 117.16,98.48 117.16,98 v1(117.32,97.84) 117.32,97.31 PR8518.2
PWR_VGA_CORE_VSNS/SS: length 3.6
  TOP w0.127: v1(119.48,97.87) 119.48,97.89 119.36,98.02 PU8514.12
  TOP w0.254: PR8525.1 118.82,97.23 119.45,97.87 v1(119.48,97.87)
  BOTTOM w0.254: v2(120.47,98.88) 120.19,98.61 PR8527.2 119.58,97.97 v1(119.48,97.87)
PWR_VGA_NVVDD_OR: length 2.7
  TOP w0.102: Q8504.D 103.73,104.8 v2(103.73,105.41) 103.73,105.46 R8546.1
PWR_VGA_NVVDD_OR#: length 17.5
  TOP w0.102: v2(105.66,102.36) 106.3,103 Q8504.G 106.49,103.42 106.92,103.85 v1(106.92,104.3) 106.92,105.2 107.12,105.4 Q8509.3 107.47,105.05 108.11,104.41 108.46,104.41 108.77,104.1 Q8509.6 ; Q8605.G 100.09,107.02 v1(101.44,105.67)
  L3 w0.102: v1(106.92,104.3) 106.92,104.73 106,105.64 104.46,105.64 103.73,106.38 102.15,106.38 v1(101.44,105.67)
  BOTTOM w0.102: v1(106.92,104.3) 106.92,104.43 106.04,105.31 R8541.2
PWR_VGA_NVVDD_PG: length 102.1
  TOP w0.102: v2(171.34,93.25) v1(171.34,93.83) ; C8630.1 113.53,100.18 113.79,99.93 v2(113.79,99.19) 113.68,99.19 113.3,99.57 v1(113.18,99.57) 113.02,99.73 111.79,99.73 R8532.1 ; PU8514.13 119.76,98.3 119.91,98.15 119.91,97.34 120.16,97.08 v1(120.16,97.06) 120.16,97.03 120.24,96.95 PR8505.2
  L3 w0.102: v1(171.34,93.83) 171.06,93.83 170.76,94.14 170.73,94.14 170.45,94.41 170.45,94.44 170.07,94.82 170.07,96.14 170.78,96.85 170.78,99.82 v1(171.01,100.05) ; v1(158.92,88.34) 158.46,87.89 157.22,87.89 v1(156.74,88.37) 156.9,88.53 156.9,89.12 154.15,91.87 153.08,91.87 152.37,92.59 146.37,92.59 146.35,92.56 134.16,92.56 132.51,90.91 129.25,90.91 125.52,94.64 123.79,94.64 121.79,96.65 120.57,96.65 v1(120.16,97.06) 119.78,96.68 116.2,96.68 113.3,99.57 v1(113.18,99.57)
  L6 w0.102: v1(158.92,88.34) 158.92,101.7 163.62,106.4 165.4,106.4 165.91,105.9 167.91,105.9 168.22,105.59 168.98,105.59 170.89,103.69 170.89,100.18 v1(171.01,100.05)
  BOTTOM w0.102: R8638.2 171.83,93.34 v1(171.34,93.83) ; v1(156.74,88.37) 156.08,87.71 R8650.1
PWR_VGA_NVVDD_PG#: length 4.3
  BOTTOM w0.102: v2(159.76,99.75) R8640.2 158.63,99.99 Q8607.6 157.46,100.6 157.37,100.69 156.92,100.69 156.81,100.59 Q8607.5
PWR_VGA_NVVDD_PG_OR: length 2.3
  BOTTOM w0.102: Q8606.2 169.69,93.97 v2(170.15,93.51) 170.64,93.02 R8638.1
PWR_VGA_S0_PG: length 3.7
  BOTTOM w0.102: PR8623.1 PR8625.2 145.16,84.08 v2(145.16,84.33) 145.16,85.53 145.28,85.66 PU8603.2
PWR_VGA_SNUB1: length 2.9
  TOP w0.508: v2(138.22,105.97) 137.69,106.5 PC8508.1
  TOP w0.635: PR8501.2 137.59,105.18 138.22,105.82 v2(138.22,105.97)
PWR_VGA_SNUB2: length 2.8
  TOP w0.508: v2(138.25,95.86) 137.74,95.35 PC8520.1
  TOP w0.635: PR8513.2 137.61,96.62 138.25,95.99 v2(138.25,95.86)
PWR_VTT_EN: length 3.4
  BOTTOM w0.127: PU5101.5 55.67,12.68 56.05,13.05 56.05,13.51 v2(56.15,13.62)
  BOTTOM w0.203: PR5106.2 56.28,13.74 v2(56.15,13.62)
Q501_G: length 4.8
  TOP w0.127: Q501.G 145.9,40.6 v2(145.89,40.59) 145.12,40.59 Q502.D 144.22,39.69 R507.1
Q4009_G: length 6.2
  TOP w0.127: R2740.2 54.15,54.56 54.86,53.85 56.61,53.85 56.86,54.1 56.86,54.13 v2(57.09,54.36) 57.7,53.75 57.7,53.1 Q2705.G
Q6204_G: length 5.6
  TOP w0.254: R6512.2 180.99,16.23 181.71,15.52 v2(181.71,15.22) 181.68,15.19 v1(180.99,15.19)
  BOTTOM w0.254: Q6503.2 Q6503.5 181.12,15.32 v1(180.99,15.19)
Q6205_Q: length 12.2
  TOP w0.381: R6522.2 v1(178.81,5.83)
  BOTTOM w0.356: v1(178.81,5.83) 178.11,6.53 172.31,6.53 171.77,7.06 171.77,7.37 170.86,8.28 170.3,8.28 169.97,8.61 v2(169.97,8.87) 169.08,8.87 Q6505.D
Q7601_G: length 4.9
  BOTTOM w0.102: R7957.2 179.14,60.12 178.07,60.12 177.97,60.02 Q7901.2 Q7901.5 177.97,56.75 v2(177.9,56.67)
RESET_OUT#: length 251.5
  TOP w0.102: v1(73.55,45.42) 74.77,44.2 74.77,44.02 79.69,39.11 99.9,39.11 100.81,40.01 100.81,40.03 100.93,40.16 105.56,40.16 v2(109.84,44.45) 110.17,44.77 112.78,44.77 112.78,44.77 113.4,44.77 v1(114,45.37) 114,45.45 114.19,45.64 114.19,45.65 114.95,46.41 115.84,46.41 115.97,46.28 117.32,46.28 117.67,46.64 117.67,48.57 117.82,48.72 117.82,48.77 117.9,48.85 117.9,51.3 117.34,51.86 117.34,51.89 ; v1(22.63,46.05) 22.22,45.65 R2617.1 ; v1(117.37,42.37) 118.46,42.37 118.77,42.06 118.77,40.16 ED1703.2 ; v1(212.62,31.35) 212.62,35.3 213.71,36.39 213.71,37.44 213.51,37.64 213.51,40.01 215.46,41.97 215.46,42.31 215.23,42.55 214.85,42.55 214.12,43.28 214.12,43.3 214.01,43.4 Q4001.3 ; U2401.73 32.35,46.51 32.4,46.46 33.37,46.46 34.61,47.7 34.61,48.39 v1(34,49)
  L4 w0.102: v1(34,49) 34.64,48.36 34.64,47.73 33.31,46.4 32.3,46.4 30.76,47.93 29.97,47.93 29.43,47.4 27.22,47.4 27.05,47.58 26.33,47.58 25.88,48.03 23.49,48.03 23.08,47.63 23.08,46.51 v1(22.63,46.05) ; v1(170.22,35.51) 170.1,35.51 169.49,36.12 169.49,36.35 168.9,36.93 168.9,37.32 167.79,38.43 167.08,38.43 162.02,43.49 162.02,43.51 v1(161.79,43.74)
  L6 w0.102: v1(170.22,35.51) 171.52,35.51 172.31,36.3 176.55,36.3 176.57,36.27 176.6,36.27 177.82,35.05 179.14,35.05 180.05,34.14 186.1,34.14 186.66,33.58 189.88,33.58 191.66,31.8 193.59,31.8 194.96,30.43 201.21,30.43 201.93,31.15 205.85,31.15 206.57,30.43 211.7,30.43 v1(212.62,31.35)
  BOTTOM w0.102: v1(34,49) 34,49.1 34.28,49.38 35.38,49.38 36.57,50.57 45.21,50.57 45.43,50.35 49.66,50.35 50.47,51.16 52.95,51.16 53.59,51.79 53.99,51.79 54.3,51.49 56.9,51.49 57.34,51.05 58.44,51.05 58.95,50.55 58.99,50.55 60.19,49.35 60.19,49.33 61.84,47.68 68.35,47.68 68.6,47.93 71.04,47.93 v1(73.55,45.42) ; v1(114,45.37) 114,44.74 114.52,44.22 115.74,44.22 117.27,42.7 117.27,42.65 117.37,42.54 v1(117.37,42.37) 117.55,42.37 117.62,42.29 120.36,42.29 122.9,39.75 143.19,39.75 145.25,41.81 152.9,41.81 153.72,42.63 161,42.63 161.79,43.42 v1(161.79,43.74)
RESET_OUT#_G: length 3
  TOP w0.102: Q2602.G 22.22,42.3 v2(22.22,43.33) R2617.2 R2616.2
RING2_HPMIC1: length 14.4
  TOP w0.508: v2(12.8,2.8) 10.76,0.76 3.75,0.76 AUD1.3 ; 13.86,2.97 ED2908.1
RSMRST_PWRGD#: length 8.6
  TOP w0.127: D4002.K 202.99,48.72 203.4,48.31 203.4,47.13 v2(204.03,46.49) R4032.2 R4029.2 R4030.2 202.82,45.36 R4031.2 202.81,45.52 R4033.2
RT8812_PVCC: length 3.6
  TOP w0.203: PU8514.18 v2(122.17,100.13)
  TOP w0.508: v2(122.17,100.13) 122.22,100.08 PC8506.1 123.41,99.06 PR8502.2
RTC_3P3_EN_G: length 14.6
  TOP w0.102: R2567.2 209.7,20.48 C2517.1 209.67,23.65 D2502.A 207.89,23.65 v1(207.69,23.45)
  BOTTOM w0.102: Q2510.G 199.24,23.95 202.71,23.95 202.82,24.06 205.76,24.06 v2(205.94,23.88) 206.37,23.45 v1(207.69,23.45)
RTC_AUX_S5: length 110
  TOP w0.305: R2512.2 210.99,21.95 211.68,22.63 211.68,23.37 212.34,24.03 R2505.2
  TOP w0.508: R2204.1 145.94,51.92 v2(144.47,53.39) 144.19,53.67 v1(142.82,53.67) ; R2512.2 210.99,21.19 v1(211.04,21.14)
  L4 w0.508: 187.84,25.54 195.69,25.54 195.73,25.58 201.9,25.58 203.09,24.39 205.2,24.39 206.39,23.19 206.39,22.52 207.5,21.41 209.42,21.41 209.7,21.14 v1(211.04,21.14) ; 187.84,25.54 182.46,30.91 179.85,30.91 179.24,30.3 177.26,30.3 176.75,30.81 176.75,31.6 177.11,31.96 177.11,33.63 171.34,39.4 168.6,39.4 v1(166.76,41.23) ; 187.84,25.54 190.16,23.22 v1(190.16,19.13)
  L6 w0.508: v1(142.82,53.67) 142.67,53.52 142.67,50.92 145.74,47.84 148.55,47.84 153.18,43.21 v1(153.26,43.21) 159.71,43.21 160.52,42.4 160.75,42.4 160.83,42.31 162.58,42.31 163.39,41.51 166.44,41.51 166.67,41.28 166.72,41.28 v1(166.76,41.23)
  BOTTOM w0.508: v1(190.16,19.13) 190.93,19.89 190.93,24.72 Q2507.D
  vias: v1(115.39,47.02)
RTC_DET#: length 124.1
  TOP w0.102: v1(189.76,28.43) 189.81,28.37 191.23,28.37 192.27,29.42 196.77,29.42 v2(197.79,28.4) 204.87,21.31 205.86,21.31 206.98,20.2 206.98,17.66 208.3,16.33 211.12,16.33 211.53,15.93 211.53,15.14 211.88,14.79 212.72,14.79 213.33,14.18 213.33,11.15 212.9,10.72 Q2501.D
  L3 w0.102: v1(133.39,71.45) 133.39,71.45 133.5,71.35 135.33,71.35 137.76,68.91 141.04,68.91 144.19,65.76 v1(144.82,65.76)
  L4 w0.102: v1(144.82,65.76) 144.82,59 157.87,45.95 159.78,45.95 160.01,45.72 160.37,45.72 160.65,46 162.6,46 162.86,45.75 162.86,43.99 164.99,41.86 166.74,41.86 168.78,39.83 171.52,39.83 177.82,33.53 178.53,33.53 179.95,32.11 184.68,32.11 188.36,28.43 v1(189.76,28.43)
  BOTTOM w0.076: CPU1.CP22 129.28,71.15 129.49,71.34 131.29,71.34 131.38,71.43
  BOTTOM w0.102: 131.38,71.43 R1519.1 133.37,71.43 v1(133.39,71.45) 134.11,70.74 R1554.2
RTC_RST#: length 70.2
  TOP w0.102: v1(142.98,41.27) 142.98,41.73 142.34,42.37 142.34,45.78 143.23,46.68 144.1,46.68 144.62,47.2 144.62,49.23 Q1802.D ; RN1801.4 116.46,48.69 116.25,48.9 115.71,48.9 115.49,49.12 ; v1(127.27,41.63) 127.27,41.71 126.66,42.32 126.66,43.03 126.82,43.18 127.5,43.18 127.65,43.34 TP9953.1 126.87,44.45 C1806.1 127.38,45.32 G1801.2 ; 115.49,49.12 ED1801.1 ; 115.49,49.12 v1(117.49,51.13)
  BOTTOM w0.076: CPU1.BR34 118.64,62.93 118.64,62.01 118.75,61.81 118.75,61.42 118.34,61 118.34,60.73 118.64,60.43 118.64,59.41 118.23,59.01 118.23,57.47 117.77,57.01
  BOTTOM w0.102: 117.77,57.01 117.77,53.55 119.48,51.84 119.48,50.96 118.99,50.47 118.64,50.47 117.98,51.13 v1(117.49,51.13) 117.9,50.73 117.9,50.3 117.22,49.62 117.22,46.65 118.48,45.38 120.16,45.38 122.66,42.88 126.03,42.88 v1(127.27,41.63) 127.43,41.63 127.72,41.93 137.09,41.93 137.34,41.68 141.35,41.68 141.76,41.27 v1(142.98,41.27)
RTCRST_ON: length 251.5
  TOP w0.089: U2401.31 47.58,49.31 48.04,49.77 48.04,50.71 48.42,51.08 48.42,51.56 48.39,51.58 48.39,52.34 49.07,53.02 v1(49.07,53.27)
  TOP w0.127: R2567.1 R2518.1 207.77,19.56 207.4,19.93 207.4,20.73 207.6,20.93 208.07,20.93 208.38,21.24 D2502.K 208.38,22.53 208.15,22.76 207.09,22.76 206.74,23.12 206.74,25.01 207.89,26.16 v1(207.89,32.72) ; v1(144.37,50.22) 144.03,49.88 Q1802.G 143.2,47.45 v2(143.05,47.6) 142.69,47.96 EC1804.1 141.42,47.96 R1816.1
  L4 w0.127: v1(207.89,32.72) 206.51,31.33 201.96,31.33 201.43,31.87 199.85,31.87 196.67,28.68 v1(192.42,28.68)
  L6 w0.127: v1(207.89,32.72) 206.89,33.72 205.11,33.72 204.71,33.31 201.28,33.31 200.32,34.28 195.72,34.28 195.47,34.52 195.47,35.46 191.77,39.17 183.36,39.17 182.82,39.7 180.06,39.7 176.3,43.46 166.21,43.46 v1(165.42,42.67) 163.91,42.67 161.7,44.88 160.55,44.88 160.38,45.05 159.56,45.05 159.15,44.64 153.25,44.64 147.67,50.22 v1(144.37,50.22)
  BOTTOM w0.127: v1(192.42,28.68) 191.81,28.07 191.81,26.34 190.79,25.32 Q2507.G ; v1(165.42,42.67) 164.79,42.04 164.79,40.87 161.93,38.01 149.28,38.01 148.08,36.81 116.99,36.81 112.19,41.61 108.81,41.61 108.12,42.29 78.71,42.29 71.92,49.09 68,49.09 67.77,48.86 62.31,48.86 61.36,49.81 61.36,49.91 59.56,51.72 59.46,51.72 58.95,52.23 58.01,52.23 56.69,53.55 55.14,53.55 54.62,54.07 53.14,54.07 53.02,53.95 53,53.95 51.59,52.54 49.46,52.54 49.07,52.92 v1(49.07,53.27)
RUNPWROK: length 5.2
  TOP w0.102: R2421.2 41.78,53.55 v2(41.78,53.46) 41.1,52.78 40.23,52.78 39.97,52.53 39.97,52.12 39.58,51.73 U2401.48
SATA_LED#: length 201.7
  L3 w0.102: v1(113.68,103) 113.68,103.28 112.92,104.04 112.47,104.04 112.24,104.27 112.24,104.73 110.05,106.91 109.19,106.91 109.16,106.94 106.62,106.94 106.57,106.99 105.02,106.99 104.26,107.75 101.11,107.75 100.68,107.32 87.45,107.32 86.05,105.92 81.86,105.92 81.68,105.74 77.92,105.74 77.18,105.01 67.63,105.01 62.12,99.49 38.63,99.49 35.15,96.01 33.24,96.01 31.74,94.52 28.29,94.52 27.41,93.64 23.55,93.64 22.32,92.41 v1(22.32,90.81)
  L4 w0.102: v1(113.68,103) 113.71,102.97 113.71,102.78 113.74,102.75 113.74,99.11 113.79,99.05 113.79,98.78 115.41,97.16 115.68,97.16 119.67,93.17 123.74,93.17 123.95,93.37 125.09,93.37 126.54,91.93 126.54,91.32 128.44,89.41 133.9,89.41 134.59,90.1 141.56,90.1 142.06,89.6 142.06,89.18 v1(142.08,89.16) ; v1(132.84,80.32) 132.92,80.32 135.77,77.47 137.08,77.47 137.48,77.07 142.46,77.07 143.02,77.63 143.02,77.78 143.05,77.8 143.05,77.96 143.02,77.98 143.02,79.59 144.11,80.67 149.07,80.67 149.93,79.81 v1(153.68,79.81)
  L6 w0.102: v1(142.08,89.16) 146.12,85.12 146.22,85.12 147.26,84.08 149.36,84.08 150.35,83.09 151.02,83.09 153.68,80.43 v1(153.68,79.81)
  BOTTOM w0.102: R6408.1 18.31,90.66 18.66,90.3 19.47,90.3 D6401.1 21.37,88.76 22.32,89.72 v1(22.32,90.81) ; CPU1.CN7 129.22,80.25 129.97,80.25 130.23,80.5 130.77,80.5 131.19,80.09 132.61,80.09 v1(132.84,80.32) 132.94,80.32 v2(133.52,79.73) 135.58,77.68 136.72,77.68 137.36,77.04 140.1,77.04 140.41,76.74 R1606.2
SATA_LED#_D: length 17.9
  TOP w0.102: Q6401.S 26.32,99.12 25.37,98.17 25.37,96.04 v2(25.09,95.76) 24.89,95.56 21.66,95.56 21.13,96.09 19.22,96.09 18.92,95.79 v1(18.92,95.35)
  L6 w0.102: v1(18.92,95.35) 18.92,94.64 19.3,94.26 19.3,91.32 v1(19.11,91.12)
  BOTTOM w0.102: D6401.3 19.36,90.87 v1(19.11,91.12) 18.31,91.92 R6408.2
SD_RCOMP: length 14.5
  TOP w0.305: v2(134.79,53.62) 134.46,53.62 134.23,53.39 R1901.1
  TOP w0.508: R1901.1 133.85,54.55 132.2,56.2 132.2,56.85 129.15,59.9 129.15,62 v1(128.14,63.01)
  BOTTOM w0.305: CPU1.CK33 127.44,63.48 CPU1.CM34 127.9,63.26 v1(128.14,63.01)
SENSOR_DB_DET#: length 14.1
  TOP w0.102: R1913.2 R1912.1 122.68,50.73 122.24,51.16 122.24,51.72 122.37,51.84 122.37,53.75 121.97,54.15 v1(121.55,54.15)
  BOTTOM w0.076: 121.44,55.9 121.35,55.99 121.35,56.95 121.04,57.26 121.04,59.08 121.14,59.17 121.14,60.44 120.96,60.62 120.96,61.29 121.1,61.43 121.1,61.77 121.09,61.79 121,61.88 121,62.13 CPU1.BW36
  BOTTOM w0.102: 121.44,55.9 121.55,55.79 v2(121.55,55.49) v1(121.55,54.15)
SENSOR_I2C_SCL: length 141.7
  TOP w0.089: v1(167.71,64.34) 167.53,64.16 167.53,64.14 167.46,64.07 167.46,60.84 171.42,56.89 171.42,49.44 170.42,48.43 167.65,48.43 167.39,48.69 166.24,48.69 165.63,49.3 165.3,49.3 164.31,50.3 R7013.1
  L3 w0.127: v1(110.56,98.12) 110.56,99.69 109.58,100.66 108.2,100.66 108.16,100.7 108.15,100.7 107.2,101.65 106.48,101.65 105.57,102.57 105.53,102.57 103.8,104.3 97.23,104.3 96.69,104.83 96.69,105.23 96.34,105.59 96.33,105.59 96.32,105.6 91.53,105.6 91.52,105.59 91.48,105.59 90.21,104.32 89.24,104.32 87,102.09 83.74,102.09 82.42,103.41 v1(82.14,103.41)
  L6 w0.102: v1(167.71,64.34) 168.07,64.7 168.07,65.74 162.94,70.87 162.94,71.92 155.86,78.99 v1(154.75,78.99) 154.75,80.22 151.25,83.72 150.58,83.72 149.57,84.74 147.47,84.74 146.48,85.73 146.47,85.73 144.49,87.7 144.49,88.83 142.74,90.58 128.72,90.58 125.37,93.93 124.15,93.93 122.3,95.79 116.61,95.79 114.46,97.93 113.37,97.93 112.81,98.49 110.93,98.49 v1(110.56,98.12)
  BOTTOM w0.089: v1(82.14,103.41) 82.14,103.18 81.4,102.44 81.4,101 SBD1.6 ; v1(154.75,78.99) 154.32,78.56 153.49,78.56 v2(153.03,78.11) 153.23,77.9 R2020.2
SENSOR_I2C_SCL_2G: length 79.8
  TOP w0.089: 166.18,51.62 165.63,51.62 R7013.2 165.17,50.02 165.6,49.58 165.73,49.58 165.75,49.57 166.04,49.57 166.63,48.97 167.81,48.97 168.09,48.7 170.19,48.7 v2(170.58,49.1) 171.14,49.65 171.14,56.52 v1(168.6,59.06)
  TOP w0.305: 166.18,51.62 U7001.1
  L6 w0.089: v1(215.54,52.48) 210.83,52.48 210.35,52.96 206.09,52.96 200.32,58.72 200.32,59.92 200.07,60.17 200.07,62.11 199.26,62.92 194.91,62.92 193.66,64.16 189.99,64.16 188.95,65.2 183.44,65.2 182.62,66.02 179.37,66.02 177.67,64.32 177.21,64.32 172.56,59.67 169.21,59.67 v1(168.6,59.06)
  BOTTOM w0.089: IOBD1.2 215.77,52.25 v1(215.54,52.48)
SENSOR_I2C_SDA: length 134.4
  TOP w0.089: R7014.1 170.81,51.03 170.81,56.25 168.17,58.89 168.17,59.67 167.16,60.68 167.16,64.14 167.25,64.24 167.25,64.75 167.48,64.98 v1(167.63,64.98)
  L3 w0.127: v1(110.62,97.48) 111.02,97.87 111.02,99.82 109.8,101.04 108.36,101.04 108.32,101.08 108.31,101.08 107.36,102.03 107.36,102.03 107.28,102.11 106.57,102.11 105.72,102.96 105.7,102.96 103.98,104.68 97.4,104.68 97.08,105 97.08,105.55 96.65,105.98 90.34,105.98 89.86,105.5 89.85,105.5 89.07,104.72 89.07,104.71 86.83,102.47 83.99,102.47 v1(82.82,103.63)
  L6 w0.102: v1(167.63,64.98) 167.63,65.69 162.63,70.69 162.63,71.79 156.72,77.7 155.43,77.7 154.25,78.88 v1(154.25,79.49) 154.25,80.29 151.13,83.42 150.46,83.42 149.47,84.4 147.37,84.4 146.35,85.42 146.34,85.42 144.19,87.57 144.19,88.7 142.62,90.27 128.59,90.27 125.24,93.63 124.03,93.63 122.17,95.48 116.48,95.48 114.98,96.98 113.45,96.98 113.05,97.39 113.05,97.64 112.5,98.19 111.34,98.19 v1(110.62,97.48)
  BOTTOM w0.089: SBD1.7 81.05,100.23 81.05,102.97 81.91,103.84 82.62,103.84 v1(82.82,103.63) ; v1(154.25,79.49) 154.22,79.45 153.94,79.45 153.87,79.38 153.49,79.38 153.41,79.45 v2(152.83,79.45) 152.47,79.1 R2021.2
SENSOR_I2C_SDA_2G: length 75.1
  TOP w0.089: 168.19,51.18 168.19,50.78 168.35,50.62 169.54,50.62 R7014.2 169.92,50.9 170.54,51.52 170.54,55.78 v2(169.75,56.57) 168.99,57.33 168.99,57.6 167.74,58.86 v1(167.74,59.11)
  TOP w0.305: U7001.4 168.19,51.18
  L6 w0.089: v1(219.17,52.2) 217.27,54.1 214.19,54.1 211.34,56.96 206.88,56.96 206.44,57.39 204.44,57.39 204.06,57.78 203.28,57.78 201.47,59.59 201.09,59.59 200.3,60.38 200.3,62.21 199.31,63.2 195.06,63.2 193.8,64.45 190.08,64.45 189.02,65.51 183.46,65.51 182.72,66.25 179.27,66.25 177.64,64.62 177.1,64.62 172.38,59.9 168.52,59.9 v1(167.74,59.11)
  BOTTOM w0.089: v1(219.17,52.2) 218.72,51.75 IOBD1.3
SIO_EXT_SCI#: length 13.4
  BOTTOM w0.089: CPU1.CR8 129.92,79.92 130.32,80.31 130.68,80.31 131.69,79.3 133.67,79.3 135.68,77.29 136.57,77.29 137.2,76.67 138.83,76.67 v2(138.85,76.69) 139.33,76.2 141.07,76.2 R1608.2
SIO_EXT_SMI#: length 7
  TOP w0.102: v1(132.2,80.5) 132.2,80.19 132.48,79.91 132.48,79.23 v2(132.46,79.2) 132.35,79.1 130.32,79.1 129.89,79.53 R402.1
  BOTTOM w0.102: v1(132.2,80.5) 132.15,80.5 131.93,80.71 130.16,80.71 129.96,80.52 CPU1.CP7
SIO_EXT_WAKE#: length 216.4
  TOP w0.102: v2(171.93,36.17) 171.54,36.55 v1(171.54,36.61) ; v1(40.61,38.76) 40.61,36.7 40.78,36.54 U2401.116
  L3 w0.102: v1(171.54,36.61) 171.54,37.04 171.04,37.54 170.38,37.54 170.15,37.31 169.46,37.31 166.11,40.67 166.11,44.58 161.03,49.66 161.03,51.96 157.69,55.3 155.6,55.3 153.99,56.9 153.99,68.04 151.9,70.13 147.13,70.13 146.47,69.47 138.43,69.47 133.62,74.28 133.62,74.81 132.35,76.08 v1(132.35,76.62)
  BOTTOM w0.076: CPU1.CN12 129.1,77.58 129.2,77.6 129.33,77.6 129.34,77.6 129.53,77.57 129.67,77.57 129.87,77.6 129.99,77.6 130.1,77.58 130.52,77.26 130.89,77.18 131.32,77.14 131.92,76.62 v1(132.35,76.62)
  BOTTOM w0.102: v1(132.35,76.62) 132.58,76.85 133.52,76.85 134.1,76.27 135.4,76.27 135.72,75.95 136.04,75.95 136.37,75.62 R2041.2 ; v1(40.61,38.76) 40.99,38.39 44.84,38.39 45.64,37.59 49.23,37.59 49.4,37.42 50.01,37.42 50.18,37.59 51.65,37.59 51.89,37.82 53.31,37.82 54.38,36.75 55.86,36.75 56.32,37.21 57.58,37.21 58.78,36.02 67.28,36.02 67.56,36.3 68.9,36.3 72.45,32.74 153.51,32.74 154.27,33.5 167.24,33.5 169.89,36.15 171.09,36.15 v1(171.54,36.61)
SIO_PWRBTN#: length 148.7
  TOP w0.102: v1(37.11,40.54) 37.43,40.87 37.43,47.54 37.84,47.95 37.84,49.2 37.98,49.34 U2401.52 ; v1(60.97,38.29) 60.97,35.82 TP1714.1 63.6,33.2 64.94,33.2 66.92,35.18 67.38,35.18 69.76,32.81 123.34,32.81 130.96,40.43 131.2,40.43 v2(131.34,40.57) 131.6,40.83 131.6,41.23 v1(131.8,41.43)
  L6 w0.102: v1(131.8,41.43) 131.8,41.68 126.94,46.54 126.94,50.47 126.51,50.9 126.51,52.15 125.98,52.68 125.98,52.91 121.01,57.88 121.01,57.95 121,57.97 121,58.41 120.1,59.31 120.1,61.29 118.56,62.83 118.56,63.1 118.51,63.15 118.51,63.48 118.56,63.53 118.56,65.83 119.64,66.91 v1(119.88,66.91)
  BOTTOM w0.102: v1(37.11,40.54) 37.8,39.86 39.82,39.86 40.18,40.21 43.68,40.21 43.71,40.19 48.25,40.19 48.46,40.39 52.34,40.39 52.72,40.01 54.63,40.01 54.88,40.26 56.2,40.26 56.89,39.58 58.11,39.58 59.39,38.29 v1(60.97,38.29) ; CPU1.BU28 119.58,67.23 119.86,66.96 119.86,66.93 v1(119.88,66.91)
SIO_RCIN#: length 27.1
  TOP w0.089: v1(136.75,53.6) 136.77,53.57 136.77,51.77 R1820.2 137.5,51.04 137.62,51.04 137.64,51.06 v2(137.69,51.06)
  L6 w0.089: v1(120.83,66.32) 122.12,65.03 122.12,62.23 124.83,59.52 124.83,59.51 124.89,59.45 124.89,58.53 128.93,54.49 128.95,54.49 129.01,54.42 136.18,54.42 136.72,53.88 136.72,53.62 v1(136.75,53.6)
  BOTTOM w0.089: v1(120.83,66.32) CPU1.BV29
SIO_SLP_A#: length 7.2
  BOTTOM w0.127: CPU1.BU37 119.67,61.51 119.67,60.5 119.42,60.25 119.42,58.78 119.12,58.47 119.12,58.17 119.64,57.65 TP9951.1 118.82,55.34 TP1713.1
SKTOCC#: length 4
  BOTTOM w0.102: TP619.1 87.51,86.92 CPU1.E1
SLEEVE_R: length 1.5
  BOTTOM w0.762: AUD1.4 2.86,12.65 2.97,12.65
  vias: v2(14.47,13.03)
SM_DRAMRST#: length 186
  TOP w0.127: v1(174.47,33.07) 174.01,33.07 171.75,35.33 171.75,35.46 170.75,36.46 170.03,36.46 167.19,39.3 v2(165.58,39.3) 165.33,39.04 148.76,39.04 148.48,39.32 148.48,41.43 148.41,41.51 148.41,41.71 148.08,42.04 R504.2 ; v1(55.92,17.94) ED1217.1 ; v1(135.93,18.39) 135.66,18.11 ED1302.1
  L3 w0.127: v1(174.47,33.07) 174.99,32.55 174.99,25.8 175.41,25.38 176.47,25.38 177.69,24.16 177.69,23.95 v1(177.9,23.75)
  L4 w0.127: v1(55.92,17.94) 57.19,16.67 59.18,16.67 60.75,15.09 62.15,15.09 62.2,15.04 65.86,15.04 67.56,13.34 70,13.34 71.04,12.3 73.58,12.3 73.74,12.46 75.72,12.46 76.78,11.4 89.61,11.4 91.11,12.91 96.26,12.91 97.17,13.82 99.23,13.82 102.28,16.87 108.23,16.87 109.98,18.61 135.01,18.61 135.23,18.39 v1(135.93,18.39) 136.75,19.21 153.44,19.21 153.59,19.05 169.49,19.05 v1(170.58,17.96)
  L6 w0.127: v1(177.9,23.75) 178.15,23.5 178.15,22.56 177.93,22.34 177.93,20.33 177.93,19.09 177.68,18.84 177.68,18.61 177.42,18.35 176.94,18.35 176.36,17.77 170.77,17.77 v1(170.58,17.96)
  BOTTOM w0.089: DM1.108 58.63,18.8 58.76,18.67 58.76,18.32 58.51,18.07 58.16,18.07 57.84,18.39 56.38,18.39 v1(55.92,17.94)
  BOTTOM w0.127: v1(135.93,18.39) 135.63,18.69 DM2.108
