# Allegro board 17859-1.0710WZS1337.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_I2C_SDA_ISH1: length 32.2
  TOP w0.089: v1(150.72,75.59) 150.67,75.64 150.67,76.15 RN2008.1
  L4 w0.114: v1(125.72,70.68) 126.33,70.07 127.65,70.07 129.97,72.4 132.42,72.4 133.66,73.64 135.4,73.64 136.21,74.45 136.34,74.45 136.81,74.92 143.92,74.92 146.76,77.76 149.4,77.76 150.72,76.44 v1(150.72,75.59)
  BOTTOM w0.089: v1(125.72,70.68) 126.02,70.99 CPU1.CH22 ; v1(150.72,75.59) 150.72,75.72 v2(150.03,76.41)
CPU_I2C_SDA_P0: length 111
  TOP w0.089: v1(164.15,49.56) 164.69,49.02 v2(165.02,49.02) 165.53,49.02 166.24,48.31 167.39,48.31 168.22,47.49 168.22,46.92 171.97,43.17 171.97,37.28 177.34,31.91 177.69,31.91 178.23,31.37 178.23,30.5 179.62,29.11 179.62,25.81 180.87,24.56 180.87,21.38 182.04,20.21 182.04,17.68 182.42,17.3 182.42,13.9 v1(182.19,13.67) 181.69,13.67 EC6502.1 ; R6519.1 177.32,12.25 v1(177.92,12.85)
  L4 w0.089: v1(177.92,12.85) 181.37,12.85 v1(182.19,13.67)
  L6 w0.089: v1(132.05,77.75) 132.33,78.04 132.84,78.04 134.56,76.31 134.56,75.64 135.71,74.5 137.2,74.5 137.59,74.88 139.88,74.88 140.51,75.51 144.15,75.51 145.33,74.33 145.33,73.05 146.72,71.66 148.05,71.66 148.58,71.12 151.4,71.12 154.73,67.8 154.73,57.13 157.22,54.64 158.46,54.64 163.54,49.56 v1(164.15,49.56)
  BOTTOM w0.076: CPU1.CM11 128.82,78.23 129.45,78.41 129.49,78.41 129.67,78.41 129.87,78.39 130.01,78.39 130.22,78.46 131.11,78.46 131.72,78.33 132.05,78.07 v1(132.05,77.75)
  BOTTOM w0.089: v1(182.19,13.67) 182.01,13.67 181.77,13.91 Q6503.4
CPU_I2C_SDA_P1: length 91.6
  L4 w0.114: v1(55.88,90.61) 55.88,90.86 56.51,91.49 62.4,91.49 63.76,90.13 71.17,90.13 71.6,90.57 78.24,90.57 78.96,89.84 82.93,89.84 82.95,89.82 93.82,89.82 94.96,88.68 102.54,88.68 103.99,87.23 103.99,86.26 103.53,85.8 103.53,83.72 105.04,82.21 105.04,79.58 107.17,77.45 108.2,77.45 109.04,76.61 112.11,76.61 112.97,75.75 117.09,75.75 117.82,75.01 120.09,75.01 120.38,74.71 121.43,74.71 121.75,75.03 123.17,75.03 123.92,75.78 123.92,75.95 124.25,76.28 124.4,76.28 125.34,77.22 127.04,77.22 v1(127.47,76.79)
  BOTTOM w0.089: CPU1.CK12 127.32,77 127.47,76.86 v1(127.47,76.79) ; R5554.2 55.79,86.74 EC5505.7 EC5505.4 55.79,88.62 56.2,89.03 v2(56.2,89.49) 56.2,90.28 v1(55.88,90.61) 55.88,90.62 56.06,90.8 LCD1.37
CPU_POPIRCOMP: length 7.1
  TOP w0.406: v1(117.12,68.2) 116.5,68.82 116.5,69.67 114.14,72.04 v2(114.14,72.06) 114.01,72.19 114.01,73.05 R304.1
  BOTTOM w0.2: CPU1.BP27 117.31,68.2 v1(117.12,68.2)
CPU_SMB_ALERT#: length 23.2
  L6 w0.102: v1(143.38,71.07) 141.81,72.65 135.35,72.65 132.55,75.45 130.69,75.45 130.54,75.29 126.81,75.29 126.36,74.84 v1(126.36,74.78)
  BOTTOM w0.089: CPU1.CJ15 126.67,75.15 126.36,74.84 v1(126.36,74.78)
  BOTTOM w0.102: v1(143.38,71.07) 143.38,72.04 R1551.2 v2(144.44,71.69) 144.85,71.28 R1552.1
CPU_SMB_ALERT#_P0: length 31.7
  TOP w0.102: v2(126.26,74.09) 125.66,74.69 v1(125.66,74.79)
  L4 w0.102: v1(125.66,74.79) 126.08,74.37 127.11,74.37 129.94,77.21 129.94,77.59 130.61,78.26 132.68,78.26 134.08,76.86 136.77,76.86 137.18,76.46 143.33,76.46 146.15,79.28 147.02,79.28 v1(147.45,79.71)
  BOTTOM w0.089: CPU1.CG15 125.37,75.08 v1(125.66,74.79)
  BOTTOM w0.102: R1843.1 146.09,78.97 146.32,79.2 146.32,79.94 146.53,80.14 147.02,80.14 v1(147.45,79.71) 147.59,79.57 R1504.2 R1505.1
CPU_SMB_ALERT#_P1: length 27.7
  TOP w0.102: v1(135.66,49.17) 135.17,48.69 v2(135.17,48.62) R1837.2 R1555.1
  BOTTOM w0.076: CPU1.CC34 123.41,63.54 123.68,62.98 123.68,61.95 123.7,61.93 123.78,61.81 123.78,61.42 123.77,61.4 123.77,61.37 123.58,61.18 123.58,60.78 123.91,60.45 123.91,58.99 124.2,58.7
  BOTTOM w0.102: 124.2,58.7 125.11,57.79 125.11,57.44 124.87,57.21 124.87,55.28 126.55,53.6 126.55,52.14 128.42,50.27 129.27,50.27 131.84,47.7 134.69,47.7 135.66,48.67 v1(135.66,49.17)
CPU_SMB_SCL: length 27.7
  TOP w0.089: RN1811.4 144.81,73.26 142.57,73.26 v1(141.8,74.02)
  L6 w0.089: v1(127.01,75.88) 131.91,75.88 131.92,75.87 132.64,75.87 134.7,73.81 137.36,73.81 137.58,73.59 141.37,73.59 v1(141.8,74.02)
  BOTTOM w0.089: v1(141.8,74.02) v2(142.46,74.68) 142.55,74.77 142.69,74.77 144.31,76.39 146.18,76.39 146.43,76.14 146.43,74.88 146.57,74.74 Q1801.3 ; v1(127.01,75.88) 127.01,75.96 CPU1.CK14
CPU_SMB_SCL_P0: length 11.4
  TOP w0.089: v1(125.67,75.83) 126.16,75.34 v2(126.69,75.34)
  L3 w0.114: v1(125.67,75.83) 126.04,75.46 129.97,75.46 130.88,74.55 131.31,74.55 131.55,74.32 132.32,74.32 v1(132.35,74.35)
  BOTTOM w0.089: v1(132.35,74.35) 132.74,74.35 133.53,73.56 RN1807.8 ; v1(125.67,75.83) 125.67,75.92 CPU1.CH14
CPU_SMB_SCL_P1: length 211.7
  TOP w0.089: Q2601.3 58.02,42.64 57.83,42.83 56.81,42.83 56.56,42.57 56.56,41.96 56.11,41.51 v2(55.82,41.51) 55.75,41.58 v1(53.94,41.58) 53.79,41.43 R2438.2
  L6 w0.089: v1(132.01,73.82) 132.54,73.82 132.61,73.88 133.49,73.88 135.24,72.14 139.84,72.14 140.54,71.43 140.54,68.72 142.18,67.08 142.18,66.38 144.41,64.16 144.41,57.81 152.78,49.44 158.17,49.44 158.58,49.84 159.99,49.84 161.51,48.31 162.75,48.31 163.91,47.15 167.86,47.15 v1(168.64,47.93)
  BOTTOM w0.089: CPU1.CN15 129.07,75.47 129.45,75.09 130.08,75.09 130.24,74.93 130.58,74.93 131.69,73.82 v1(132.01,73.82) 132.55,73.82 132.62,73.88 132.96,73.88 133.24,73.6 133.24,73.49 133.75,72.97 RN1807.7 ; v1(53.94,41.58) 54.02,41.66 56.76,41.66 57.45,40.97 59.9,40.97 60.05,40.82 60.07,40.82 60.32,40.57 64.52,40.57 65.11,39.98 69.53,39.98 70.82,38.69 110.53,38.69 115.31,33.91 153,33.91 153.77,34.67 163.37,34.67 166.95,38.26 167.79,38.26 169.31,39.78 169.31,40.85 169.84,41.37 169.84,44.64 169.12,45.36 169.12,45.74 168.22,46.64 168.22,47.51 v1(168.64,47.93) 169.97,47.93 170.63,48.59 170.96,48.59 170.99,48.62 171.49,48.62 176.78,53.9 176.78,54 176.91,54.13 176.91,54.16 177.06,54.31 177.06,54.59 177.31,54.84 177.31,55.68 177.32,55.69 Q7901.6
CPU_SMB_SDA: length 26.6
  TOP w0.089: v1(142.44,74.02) 142.89,73.56 143.96,73.56 144.37,73.97 145.26,73.97 145.52,73.71 RN1811.3
  L6 w0.089: v1(126.37,75.87) 126.76,75.48 130.47,75.48 130.62,75.63 132.63,75.63 135.3,72.96 141.38,72.96 v1(142.44,74.02)
  BOTTOM w0.089: Q1801.6 v2(144.48,76.04) 144.41,76.04 142.44,74.07 v1(142.44,74.02) ; v1(126.37,75.87) 126.37,75.59 CPU1.CH15
CPU_SMB_SDA_P0: length 12.4
  TOP w0.089: v1(124.99,74.81) 124.68,74.5 v2(124.68,74.17)
  L3 w0.114: v1(124.99,74.81) 125.44,75.25 129.85,75.25 130.88,74.22 131.15,74.22 131.54,73.83 131.54,73.38 v1(132.02,72.9)
  BOTTOM w0.089: v1(124.99,74.81) 124.72,75.07 CPU1.CF15 ; v1(132.02,72.9) 132.96,72.9 133.98,71.88 RN1807.5
CPU_SMB_SDA_P1: length 211.3
  TOP w0.089: R2439.2 56.07,40.52 v2(56.41,40.18) 56.66,39.93 59.22,39.93 59.32,40.02 Q2601.6 59.7,40.58 v1(59.89,40.38)
  L6 w0.089: v1(132.79,73.48) 133.64,73.48 135.29,71.83 139.73,71.83 140.24,71.32 140.24,68.6 141.88,66.96 141.88,66.27 144.11,64.04 144.11,57.69 152.66,49.14 158.04,49.14 158.06,49.13 158.29,49.13 158.69,49.53 159.86,49.53 161.39,48.01 162.63,48.01 163.8,46.84 164.05,46.84 164.07,46.86 168.31,46.86 v1(168.64,47.2)
  BOTTOM w0.089: CPU1.CM15 128.48,75.47 128.94,75.01 128.94,74.74 129.12,74.56 130.08,74.56 130.19,74.67 130.56,74.67 131.81,73.42 132.72,73.42 v1(132.79,73.48) 132.84,73.48 133.85,72.47 RN1807.6 ; Q7901.3 178.94,59.13 180.44,59.13 180.79,59.49 181.27,59.49 181.4,59.36 181.4,58.68 180.99,58.27 180.28,58.27 177.59,55.58 177.59,54.74 177.34,54.49 177.34,54.21 177.18,54.05 177.18,54.03 177.06,53.9 177.06,53.8 171.57,48.31 170.73,48.31 170.07,47.65 169.1,47.65 v1(168.64,47.2) 168.64,46.75 170.12,45.27 170.12,41.28 169.59,40.74 169.59,39.68 167.89,37.98 167.05,37.98 163.47,34.39 153.89,34.39 153.12,33.63 115.22,33.63 110.42,38.43 70.71,38.43 69.42,39.71 64.59,39.71 64.09,40.21 60.07,40.21 v1(59.89,40.38)
CPVEE: length 3.8
  TOP w0.203: U2701.27 20.63,15.4 20.06,15.98 19.67,15.98
  TOP w0.305: 19.67,15.98 19.02,15.98 18.38,15.34 C2709.2
CTL1: length 2.7
  BOTTOM w0.102: R3601.2 17.65,31.27 v2(17.82,31.09) 18,31.09 18.18,31.27 18.18,31.98 18.31,32.11 U3601.6
CTL2: length 2.3
  BOTTOM w0.102: R3606.2 17.24,32.77 v2(17.7,33.23) 18.31,32.61 U3601.7
CTL3: length 2.7
  BOTTOM w0.102: R3602.2 18.82,34.65 v2(18.65,34.48) U3601.8
DAT_TP_SIO: length 189.6
  TOP w0.089: v2(182.72,10.16) 182.54,9.98 v1(182.14,9.98) 182.14,10.26 181.65,10.75 EC6501.1 181.38,10.59 181.38,10.14 181.23,9.99 RN6504.3 180.57,10.86 RN6503.2 ; v1(33.9,44.33) 33.85,44.33 33.64,44.11 U2401.79
  L4 w0.114: v1(182.14,9.98) 180.41,11.71 177.92,11.71 176.37,13.26 175.16,13.26 174.74,13.68 174.74,15.87 170.42,20.19 109.17,20.19 107.92,18.94 103.51,18.94 103.5,18.93 101.92,18.93 99.84,16.84 95.45,16.84 95.1,17.19 88.33,17.19 87.71,16.57 84.07,16.57 82.47,14.96 73.15,14.96 73.12,14.94 71.24,14.94 69.62,16.56 66.59,16.56 65.86,17.3 62.05,17.3 60.4,18.95 57.18,18.95 54.38,21.75 54.38,27.23 54.12,27.49 54.12,30.97 53.79,31.3 53.79,32.48 54.15,32.85 54.15,36.66 52.06,38.75 52.06,40.95 48.91,44.1 48.76,44.1 47.64,45.21 47.24,45.21 47.06,45.04 44.22,45.04 44.04,45.21 42.49,45.21 41.95,45.75 41.62,45.75 40.82,46.55 37.78,46.55 37.26,46.03 34.02,46.03 32.81,44.82 32.81,44.48 33.14,44.15 33.34,44.15 33.45,44.25 33.5,44.25 33.57,44.33 v1(33.9,44.33)
DBC_EN_R: length 6.5
  BOTTOM w0.102: LCD1.8 41.56,91.81 41.14,91.39 41.14,90.96 40.35,90.17 v2(40.35,87.3) 40.43,87.23 R5518.2
DBC_PANEL_EN: length 175
  TOP w0.102: v1(62.9,37.51) 63.33,37.09 71.26,37.09 v2(73.02,35.33) 73.98,34.37 122.3,34.37 126.79,38.86 126.79,41.84 126.51,42.12 126.51,42.17 126.46,42.22 126.46,46.97 127.5,48.01 127.5,49.25 127.81,49.56 R2043.2 127.03,50.02 125.67,51.38 125.67,53.98 127.07,55.37 127.07,55.93 126.64,56.37 126.64,57.61 125.8,58.45 125.8,61.12 124.44,62.47 124.44,63.46 123.95,63.96 123.95,64.59 v1(123.56,64.98)
  L3 w0.102: v1(34.97,60.48) 34.94,60.48 34.92,60.45 34.72,60.45 34.59,60.58 34.59,64.85 34.44,65 34.44,66.7 34.51,66.78 34.51,67.39 34.44,67.47 34.44,71.07 37.66,74.3 37.66,75.47 37.18,75.95 37.18,79.44 39.1,81.36 40.48,81.36 40.94,81.81 40.94,83.8 v1(40.51,84.23) ; v1(62.9,37.51) 62.22,38.19 62.22,43.83 60.55,45.5 60.55,47.53 60.57,47.55 60.57,47.73 59.3,49 59.3,49.1 59.15,49.25 59.15,50.4 57.25,52.3 57.25,54.33 57.12,54.46 57.11,54.46 56.4,55.17 54.17,55.17 52.61,56.73 50.2,56.73 49.85,57.08 49.85,57.28 49.6,57.54 49.6,58.14 v1(49.47,58.27)
  L6 w0.102: v1(34.97,60.48) 35,60.48 35.17,60.66 35.22,60.66 35.48,60.91 38.04,60.91 38.83,61.7 43.28,61.7 44.62,60.35 45.13,60.35 46.04,61.27 46.37,61.27 46.4,61.24 47.42,61.24 49.35,59.31 49.35,58.4 v1(49.47,58.27)
  BOTTOM w0.102: v1(40.51,84.23) 40.43,84.31 R5518.1 ; CPU1.CA31 122.5,64.98 v1(123.56,64.98)
DC_IN_OFF: length 2.2
  BOTTOM w0.254: v2(31.19,77.14) 31.87,77.14 R4369.2 32.1,77.9 32.44,78.25 Q4349.6
DCBATOUT: length 14.6
  TOP w0.406: PR4477.2 171.75,13.57 v1(172.05,13.26)
  TOP w0.508: PD4407.A 168.02,4.22 167.05,5.18 v1(167.05,5.21) ; v1(201.15,50.69) 201.08,50.75 200.96,50.75 200.81,50.9 PR4509.1 ; v1(201.72,44.27) 201.14,43.68 201.14,42.55 200.32,41.73 ; PR8503.1 v1(115.79,104.8)
  L6 w0.508: v1(201.15,50.69) 202.25,49.58 202.29,49.58 202.66,49.21 202.66,48.69 202.25,48.27 202.25,46.3 202.29,46.26 202.29,44.48 202.09,44.28 201.74,44.28 v1(201.72,44.27)
  vias: v1(45.66,60.07) v1(85.85,98.91) v1(85.8,98.28) v1(115.74,3.63) v1(116.5,106.96) v2(44.22,92.08) v2(45.57,62.24) v2(52.08,13.28) v2(63.9,98.56) v2(69.09,2.92) v2(85.3,97.75) v2(98.28,2.72) v2(104.06,10.04) v2(116.29,16.73) v2(117.22,105.89) v2(123.86,106.32) v2(126.54,92.37) v2(126.97,93.14) v2(131.82,12.47) v2(148.74,14.29) v2(159.99,70.05) v2(174.83,50.49) v2(182.21,28.35) v2(196.28,41.43) v3(45.97,59.39) v3(47.03,59.41) v3(47.77,78.26) v3(47.77,77.42) v3(59,8.13) v3(59.05,7.29) v3(62.22,7.04) v3(63.24,7.04) v3(67.56,101.76) v3(68.22,102.29) v3(68.55,101.19) v3(69,101.99) v3(101.39,10.37) v3(102.41,10.37) v3(115.61,4.4) v3(116.38,3.25) v3(120.47,105.67) v3(121.35,105.78) v3(129.23,12.55) v3(129.23,11.71) v3(129.79,91.87) v3(129.79,13.19) v3(129.97,12.14) v3(130.63,91.87) v3(131.13,107.01) v3(131.46,91.87) v3(132.07,107) v3(132.3,91.87) v3(132.81,13.01) v3(133.01,107) v3(133.65,13.01) v3(134.56,12.98) v3(141.47,15.6) v3(142.31,15.6) v3(169.59,69.93) v3(170.22,69.34) v3(170.38,70.28) v3(170.94,68.89) v3(171.14,69.88) v3(181.2,27.18) v3(181.2,26.34) v3(182.09,27.16) v3(182.09,26.32) v3(182.95,27.13) v3(182.95,26.29)
DCBATOUT_LCD:
  vias: v2(38.08,94.76) v3(38.4,93.32) v3(39.29,93.32)
DGPU_HOLD_RST#: length 53.6
  TOP w0.127: v1(135.76,69.8) 136.11,69.45 139.54,69.45 142.08,66.91 145.55,66.91 146.44,67.79 146.44,68.91 147.09,69.56 147.09,71.78 146.26,72.61 146.26,73.72 146.5,73.97 148.18,73.97 148.38,74.17 152.83,74.17 152.85,74.2 153.03,74.2 153.92,75.09 155.57,75.09 v1(156.76,76.28)
  BOTTOM w0.127: EC2002.1 163.44,83.14 R7604.1 162.3,81.99 160.45,81.99 160.18,82.26 U7601.1 159.68,82.9 v2(157.79,81.01) 156.77,80 156.77,76.29 v1(156.76,76.28) ; RN2009.4 136.48,72.7 136.28,72.5 136.28,70.33 v1(135.76,69.8) 135.58,69.98 133.83,69.98 133.17,70.64 132.68,70.64 132.24,71.08 CPU1.CR22
DGPU_PWR_1V: length 3.2
  BOTTOM w0.356: v2(157.14,92.69) 157.12,92.66 157.12,91.3 156.64,90.82 U8605.1
  BOTTOM w0.508: R8649.2 v2(157.14,92.69)
DGPU_PWR_EN: length 52.8
  TOP w0.102: v1(135.18,69.54) 135.18,69.8 135.59,70.21 136.31,70.21 136.82,69.71 139.64,69.71 142.17,67.17 145.35,67.17 146.2,68.02 146.2,69.01 146.72,69.53 146.72,71.81 146.01,72.51 146.01,73.82 146.41,74.22 147.92,74.22 148.81,75.11 149.68,75.11 150.16,74.63 152.64,74.63 154.92,76.91 155.8,76.91 156.08,77.19 156.69,77.19 157.88,76 v1(157.88,75.21)
  BOTTOM w0.076: 132.46,70.56 132.19,70.82 129.84,70.82 129.75,70.85 129.46,70.85 129.36,70.83 129.36,70.82 129.16,70.82 129.1,70.85 128.98,70.97 128.98,71 128.87,71.16 128.78,71.25 128.75,71.27 127.86,71.27 127.7,71.11 127.7,70.14 CPU1.CM24
  BOTTOM w0.102: R8605.1 156.58,74.27 Q8604.G 156.28,75.11 156.43,75.26 157.83,75.26 v1(157.88,75.21) ; 132.46,70.56 132.61,70.41 133.04,70.41 133.73,69.73 135,69.73 v1(135.18,69.54) 135.26,69.54 135.4,69.4 135.4,68.89 R2011.2 136.32,68.84 v2(136.32,69.29) 136.53,69.51 136.53,71.5 136.52,71.51 136.52,71.77 RN2009.3
DGPU_PWR_EN#: length 4.1
  BOTTOM w0.102: Q8608.6 161.38,101.14 161.16,100.92 R8643.1 161.16,99.85 v2(161.23,99.77) 161.51,99.77 161.61,99.88 161.61,100.21 161.9,100.49 Q8608.5
DGPU_PWR_EN_Q: length 97.5
  TOP w0.102: v1(127.72,108.7) 126.13,107.11 120.47,107.11 119.88,106.53 119.88,105.2 119.51,104.83 PR8523.1
  L3 w0.102: v1(127.72,108.7) 128.14,109.12 148.99,109.12 149,109.11 152.43,109.11 155.9,105.64 155.9,101.98 156.69,101.2 156.69,98.45 157.88,97.26 v1(157.88,96.09)
  BOTTOM w0.102: v1(157.88,96.09) 157.88,96.27 159.61,98 162.05,98 163.21,99.16 163.21,100.33 163.37,100.49 Q8608.2 165.48,100.49 166.45,101.46 166.45,102.07 166.92,102.54 167.61,102.54 168.52,101.63 168.78,101.37 169.54,101.37 169.72,101.55 R8611.1 ; v1(157.88,96.09) 158.18,96.09 159.26,95.01 159.26,89.32 158.48,88.53 158.48,87.39 160.1,85.77 160.1,84.19 155.78,79.86 v2(155.78,79.58) 155.78,79.15 154.76,78.13 R8626.2 154.76,77.29 Q8604.D 155.33,75.94 155.75,75.52 155.75,74.25 156.59,73.41 R8605.2 ; v1(157.88,96.09) 157.14,95.35 R8649.1
DGPU_PWR_EN_R: length 3.6
  BOTTOM w0.127: U8601.5 172.14,100.43 171.93,100.64 v2(171.24,100.64) 170.38,100.64 C8603.1 170.23,100.94 170.38,101.09 170.48,101.09 R8611.2
DGPU_PWROK: length 238.5
  TOP w0.102: v1(113.06,100.21) 112.88,100.03 111.93,100.03 R8533.2 ; v1(56.83,32.07) 57.35,31.55 129.84,31.55 136.77,38.48 136.77,40.03 139.74,43 139.74,44.71 138.45,46 138.45,47.96 139.52,49.02 v1(139.52,53.67) ; EC2401.1 56.59,48.72 R2477.2 55.9,48.11 55.65,48.36 v1(55.65,48.7)
  L3 w0.102: v1(157.6,83.34) 157.58,83.34 152.44,88.47 146.73,88.47 145.74,89.46 145.66,89.46 145.56,89.56 145,89.56 v1(144.75,89.31)
  L4 w0.102: v1(149.52,77.02) 149.35,77.19 149.27,77.19 149.07,77.4 148.66,77.4 148.46,77.19 146.76,77.19 144.27,74.7 144.24,74.7 144.09,74.55 143.4,74.55 143.35,74.5 141.07,74.5 141.04,74.53 138.78,74.53 138.75,74.55 138.4,74.55 138.37,74.53 136.95,74.53 136.49,74.07 136.37,74.07 135.73,73.43 133.97,73.43 132.7,72.16 130.45,72.16 127.74,69.46 127.74,69.36 127.51,69.12 126.89,69.12 v1(126.49,69.52) ; v1(56.83,32.07) 57.46,32.07 57.83,32.44 57.83,37.42 57.09,38.15 57.09,41.02 56.47,41.65 56.47,42.5 56.07,42.9 56.07,42.91 56.05,42.93 56.05,48.3 v1(55.65,48.7)
  L6 w0.102: v1(144.75,89.31) 144.72,89.33 144.72,89.39 143.22,90.88 128.85,90.88 125.5,94.24 124.28,94.24 122.35,96.17 116.72,96.17 113.99,98.9 113.99,99.37 113.16,100.21 v1(113.06,100.21) ; v1(139.52,53.67) 139.52,54.53 137.99,56.06 135.86,56.06 131.3,60.62 131.3,61.45 131.06,61.68 131.06,61.75 128.9,63.91 128.9,66.02 126.82,68.1 126.82,69.19 v1(126.49,69.52)
  BOTTOM w0.102: v1(157.6,83.34) 156.13,81.87 153.59,81.87 v2(152.32,80.6) 152.06,80.34 152.06,77.51 151.44,76.89 149.65,76.89 v1(149.52,77.02) ; U8502.4 112.89,100.04 v1(113.06,100.21) 113.06,100.21 113.25,100.41 R8534.1 ; CPU1.CJ25 126.67,69.33 v1(126.49,69.52)
DGPU_PWROK_L: length 7.3
  TOP w0.102: R8532.2 R8533.1 109.48,100.33 109.38,100.23 109.38,100.22 v1(109.37,100.21)
  BOTTOM w0.102: v1(109.37,100.21) 109.37,100.18 109.04,99.85 109.04,98.99 R8531.2 109.28,98.74 U8502.1 110.58,98.74 111.07,98.25 v2(111.07,96.88)
DGPUHOT#: length 282
  TOP w0.102: v1(198.14,59.46) 198.22,59.54 203.24,59.54 203.78,59.01 204.95,59.01 205.4,59.46 205.87,59.46 206.35,58.98 206.93,58.98 208.05,57.86 212.11,57.86 213.69,59.44 PQ4402.D 214.17,58.24 214.55,57.86 215.54,57.86 216.2,57.2 v1(216.2,56.97) ; v1(64.84,34.6) 64.31,34.6 62.02,36.88 62.02,37.32 62.14,37.44 62.14,38.78 61.42,39.5 58.03,39.5 v2(57.98,39.45) 56.1,39.45 55.9,39.25 55.82,39.25 55.77,39.19 53.51,39.19 51.82,40.88 50.71,40.88 50.46,41.13 R2422.1
  L3 w0.102: v1(177.59,65.18) 177.59,65.08 180.97,61.7 180.97,59.74 180.54,59.31 180.54,58.78 180.87,58.45 181.88,58.45 183.31,59.87 189.25,59.87 190.54,58.58 190.54,52.89 191.54,51.89 194.74,51.89 195.35,52.5 195.88,52.5 197.91,54.54 197.91,56.52 198.3,56.91 198.3,59.3 v1(198.14,59.46)
  L6 w0.102: v1(217.09,25.56) 216.48,26.17 216.48,27.43 215.28,28.63 206.83,28.63 205.5,29.96 202.57,29.96 201.95,29.34 194.51,29.34 193.14,30.71 189.17,30.71 188.92,30.96 185.65,30.96 183.59,33.02 179.55,33.02 178.63,33.94 177.3,33.94 176.06,35.17 172.85,35.17 172.41,34.73 172.41,34.14 v1(172,33.73)
  BOTTOM w0.102: D7902.K 175.82,67.1 177.59,65.33 v1(177.59,65.18) ; v1(216.2,56.97) 216.75,56.97 222.37,51.35 222.37,26.78 221.15,25.56 v1(217.09,25.56) ; v1(172,33.73) 170.68,32.41 154.72,32.41 153.96,31.65 118.05,31.65 118.05,31.65 115.75,31.65 67.79,31.65 v1(64.84,34.6)
DIMM1_SA0: length 4.2
  TOP w0.102: R1205.2 95.8,20.17 R1204.1 96.64,20.91 v2(96.79,21.06) 96.95,21.21 v1(97.5,21.21)
  BOTTOM w0.102: DM1.256 97.64,21.11 97.53,21.21 v1(97.5,21.21)
DIMM1_SA1: length 3.9
  TOP w0.102: R1210.2 100.12,20.32 R1208.1 98.47,19.59 v2(98.47,19.43) 99.05,19.43 v1(99.21,19.59)
  BOTTOM w0.102: v1(99.21,19.59) 99.04,19.75 DM1.260
DIMM1_SA2: length 4.8
  TOP w0.102: 75.48,19.15 75.38,19.05 74.59,19.05 v2(74.57,19.08) 74.57,19.43 75.15,20.02 R1212.2 75.15,21.21 v1(75.13,21.23)
  BOTTOM w0.102: v1(75.13,21.23) 75.13,21.23 DM1.166
DIMM2_SA0: length 6.8
  TOP w0.102: R1302.2 177.92,19.61 177.77,19.76 v2(177.29,19.76) 177.24,19.71 v1(177.24,18.8) 177.18,18.75 R1303.2
  BOTTOM w0.102: DM2.256 174.64,19.06 175.05,18.65 177.08,18.65 v1(177.24,18.8)
DIMM2_SA1: length 4.9
  TOP w0.102: v1(176.59,19.49) 176.59,19.67 177.13,20.22 177.77,20.22 177.92,20.37 R1307.2 R1306.2 177.92,22.3 v2(177.87,22.35)
  BOTTOM w0.102: v1(176.59,19.49) 176.33,19.75 DM2.260
DIMM2_SA2: length 7.1
  TOP w0.102: R1310.2 153.97,20.12 R1311.2 153.38,20.14 v2(153.08,20.45) 152.66,20.87 152.66,21.69 v1(151.91,22.43)
  BOTTOM w0.102: DM2.166 152.14,22.21 v1(151.91,22.43)
DMIC_CLK_EDP: length 5.1
  TOP w0.089: R5556.2 50.39,89.77 v2(50.39,90.3) 50.11,90.58 v1(49.83,90.58)
  BOTTOM w0.089: R5503.2 49.66,90.49 49.75,90.58 v1(49.83,90.58) 49.96,90.71 50.64,90.71 50.89,90.96 50.89,91.46 51.06,91.63 LCD1.27
DMIC_DATA_EDP: length 5.5
  TOP w0.089: v1(51.12,90.58) 51.1,90.58 51.02,90.5 v2(51.02,89.18) 51.02,89.13 50.54,88.65 R5557.2
  BOTTOM w0.089: LCD1.28 51.56,91.73 51.15,91.32 51.15,90.63 51.12,90.6 v1(51.12,90.58) 51.1,90.58 50.47,89.95 R5502.2
DMIC_PCH_CLK: length 215.4
  TOP w0.089: v1(172.08,73.45) 171.76,73.14 166.05,73.14 164.87,74.31 164.72,74.47 159.55,74.47 158.93,73.84 v1(154.71,73.84) ; v1(49.5,97.56) 49.5,97.54 49.33,97.37 v2(49.33,95.62) 49.33,93.53 49.32,93.53 49.32,92.71 48.39,91.78 48.39,90.19 R5556.1
  L3 w0.127: v1(49.5,97.56) 49.73,97.79 62.89,97.79 64.82,99.72 64.82,99.77 65.72,100.67 68.3,100.67 68.33,100.64 68.78,100.64 68.81,100.67 69.09,100.67 72.01,103.58 73.58,103.58 73.6,103.57 73.93,103.57 73.94,103.56 75.03,103.56 76.27,102.33 77.41,102.33 77.41,102.32 78.29,102.32 78.71,102.75 80.28,102.75 80.89,103.36 80.89,103.48 81.93,104.52 83.13,104.52 84.27,103.38 85.82,103.38 87.45,105.01 87.45,105.06 88.13,105.74 88.16,105.74 88.16,105.74 88.59,105.74 89.59,106.75 100.94,106.75 101.07,106.88 101.08,106.88 101.31,107.11 101.32,107.11 101.33,107.13 104.04,107.13 104.06,107.11 104.07,107.11 104.78,106.4 106.32,106.4 106.37,106.35 108.92,106.35 113.04,102.24 113.31,102.24 113.35,102.2 114.02,102.2 114.06,102.24 114.23,102.24 114.45,102.45 114.5,102.45 114.76,102.71 114.76,103.08 114.75,103.1 114.75,103.1 114.27,103.58 114.27,104.41 114.25,104.44 114.25,107.33 114.31,107.39 114.31,107.41 114.79,107.89 114.81,107.89 115.07,108.16 115.11,108.16 115.57,108.62 117.16,108.62 117.54,108.99 117.54,108.99 117.56,109.01 118.25,109.01 118.26,108.99 118.35,108.99 120.1,107.25 126.92,107.25 128.29,108.61 128.39,108.61 128.42,108.65 147.58,108.65 148.46,107.77 148.46,107.72 151.45,104.72 151.45,95.82 152.93,94.35 152.95,94.35 157.94,89.36 159.21,89.36 159.39,89.18 159.42,89.18 160.4,88.21 160.4,88.17 160.44,88.13 160.44,87.98 160.46,87.96 160.46,86.11 163.18,83.4 163.18,83.39 171.98,74.58 171.98,74.58 172.08,74.48 v1(172.08,73.45)
  L4 w0.127: v1(131.86,69.11) 132.76,70.01 133.91,70.01 134.33,70.44 134.34,70.44 134.48,70.58 135.69,70.58 135.73,70.61 136.14,70.61 137.51,71.99 140.79,71.99 140.91,72.11 141.01,72.11 141.45,72.55 144.23,72.55 145.51,73.83 145.52,73.83 146.15,74.45 147.82,74.45 147.83,74.45 147.83,74.45 147.88,74.4 148.52,74.4 148.82,74.1 151.56,74.1 151.79,73.87 154.68,73.87 v1(154.71,73.84)
  BOTTOM w0.076: 130.73,69.65 130.35,69.65 130.16,69.61 130.07,69.52 129.87,69.52 arc(129.82,69.53) 129.76,69.55 129.28,69.77 CPU1.CP24
  BOTTOM w0.089: v1(131.86,69.11) 131.74,69.24 131.14,69.24 130.79,69.59 130.78,69.59 130.73,69.65
DMIC_PCH_DATA: length 219.3
  TOP w0.089: v1(155.19,73.26) 155.45,73.52 158.99,73.52 159.61,74.15 164.66,74.15 165.96,72.85 v1(172.54,72.85) ; v1(48.84,97.56) v2(48.84,96.87) 48.84,95.43 49.04,95.22 49.04,92.81 48.1,91.87 48.1,89.72 R5557.1
  L3 w0.127: v1(172.54,72.85) 171.98,72.85 171.6,73.24 171.6,74.42 162.8,83.23 162.8,83.24 160.25,85.79 160.23,85.79 160.02,86 160.02,86.21 160.01,86.22 160.01,88.05 159.27,88.8 157.99,88.8 157.82,88.98 157.78,88.98 152.79,93.97 152.77,93.97 151.07,95.66 151.07,104.56 148.08,107.56 148.08,107.61 147.42,108.27 128.58,108.27 128.55,108.23 128.54,108.23 127.18,106.87 119.94,106.87 118.19,108.61 118.1,108.61 118.09,108.63 117.72,108.63 117.7,108.61 117.7,108.61 116.86,107.77 115.23,107.77 114.97,107.51 114.95,107.51 114.69,107.25 114.69,107.23 114.63,107.17 114.63,104.6 115.32,103.91 115.32,102.78 115.15,102.61 115.15,102.55 114.66,102.07 114.61,102.07 114.39,101.86 114.22,101.86 114.18,101.82 113.19,101.82 113.15,101.86 112.88,101.86 108.76,105.97 106.22,105.97 106.17,106.02 104.62,106.02 103.91,106.73 103.9,106.73 103.88,106.75 101.49,106.75 101.48,106.73 101.47,106.73 101.23,106.5 101.23,106.5 101.1,106.37 89.87,106.37 88.87,105.36 88.75,105.36 88.75,105.36 88.31,105.36 87.83,104.88 87.83,104.83 86,103 84.09,103 82.95,104.14 82.11,104.14 81.27,103.3 81.27,103.18 80.46,102.36 78.87,102.36 78.4,101.9 76.15,101.9 74.87,103.18 73.78,103.18 73.77,103.19 73.44,103.19 73.42,103.2 72.17,103.2 69.25,100.29 68.97,100.29 68.94,100.26 67.66,100.26 67.64,100.29 65.93,100.29 63.04,97.39 50.09,97.39 49.81,97.12 49.28,97.12 v1(48.84,97.56)
  L4 w0.127: v1(131.21,68.84) 131.39,68.66 132.16,68.66 132.98,69.48 133.68,69.48 134,69.79 134,69.79 134.44,70.23 139.68,70.23 141.17,71.72 141.17,71.73 141.61,72.17 144.39,72.17 145.67,73.45 145.68,73.45 146.3,74.06 147.68,74.06 147.72,74.02 148.25,74.02 148.61,73.66 151.38,73.66 151.51,73.54 151.53,73.54 151.63,73.43 154.27,73.43 154.45,73.26 v1(155.19,73.26)
  BOTTOM w0.076: CPU1.CN24 129.12,69.54 129.16,69.53 129.61,69.42 129.63,69.42 129.75,69.37 129.79,69.36 130.31,69.36 130.37,69.42 130.6,69.42
  BOTTOM w0.089: 130.6,69.42 130.71,69.42 131.21,68.92 v1(131.21,68.84)
DMIC_SCL_CODEC: length 136.5
  TOP w0.089: v1(32.22,24.26) 32.41,24.26 32.94,23.73 32.94,18.44 32.96,18.41 32.96,18.39 35.71,15.65 35.73,15.65 35.76,15.62 35.87,15.62 37.08,14.41 37.08,13.53 35.72,12.16 31.02,12.16 30.52,12.65 v2(28.47,12.65) 28.44,12.68 28.32,12.68 27.78,13.21 27.78,14.61 27.38,15 U2701.3
  L4 w0.114: v1(23.54,52.23) 22.75,52.23 22.6,52.07 22.57,52.07 18.03,47.53 16.4,47.53 14.62,45.75 14.62,38.66 18.49,34.8 18.49,34.57 19.98,33.07 22.37,33.07 22.82,33.53 22.99,33.53 26.79,29.72 29.18,29.72 29.69,29.21 29.69,28.32 31.16,26.85 31.16,26.67 31.19,26.65 31.19,25.61 31.21,25.58 31.21,25.53 31.36,25.38 31.44,25.3 31.44,25.04 v1(32.22,24.26)
  L6 w0.089: v1(23.54,52.23) 23.59,52.28 23.59,52.97 26.13,55.51 26.13,57.91 26.68,58.47 26.68,66.63 25.26,68.06 25.26,72.01 25.83,72.58 25.83,78.59 32.71,85.47 33.65,85.47 34.09,85.92 38.18,85.92 v1(40.51,83.59)
  BOTTOM w0.089: R5503.1 50.12,88.49 50.22,88.49 EC5501.1 50.11,87.64 50.11,87 50.33,86.78 50.33,85.13 48.72,83.52 45.92,83.52 45.66,83.26 45.66,81.51 44.93,80.77 v2(44.55,80.77) 44.47,80.7 42.64,80.7 42,81.34 41.67,81.34 41.22,81.79 41.22,82.88 v1(40.51,83.59)
DMIC_SDA_CODEC: length 138.9
  TOP w0.089: v1(32.13,25.07) 33.26,23.94 33.26,18.51 34.64,17.12 34.64,17.1 35.81,15.93 35.95,15.93 37.35,14.52 37.35,13.42 35.78,11.84 33.2,11.84 31.68,10.32 EC2711.1 31.62,11.07 31.1,11.59 30.5,11.59 30.09,11.18 v2(29.74,11.18) 29.1,11.18 27.55,12.73 27.55,14.51 27.27,14.79 26.97,14.79 26.79,14.6 U2701.2 ; v2(40,83.26) 40.13,83.26 v1(40.46,82.93)
  L4 w0.114: v1(32.13,25.07) 32.03,25.07 31.44,25.66 31.44,26.93 30.12,28.25 30.12,29.31 29.28,30.15 26.89,30.15 23.11,33.94 22.7,33.94 22.31,33.55 20.03,33.55 18.87,34.71 18.87,34.95 15.34,38.48 15.34,44.43 17.92,47.02 18.05,47.02 22.75,51.72 v1(23.16,51.72)
  L6 w0.089: v1(23.16,51.72) 23.18,51.74 23.74,51.74 24.53,52.53 24.53,52.99 26.49,54.94 26.49,57.84 26.98,58.33 26.98,66.77 25.55,68.2 25.55,71.89 26.13,72.47 26.13,78.47 32.83,85.17 33.78,85.17 34.23,85.63 37.76,85.63 v1(40.46,82.93)
  BOTTOM w0.089: v1(40.46,82.93) 40.94,82.45 40.94,81.69 41.63,81 41.95,81 42.54,80.42 44.7,80.42 44.77,80.5 45.03,80.5 45.1,80.57 45.11,80.57 45.94,81.41 45.94,83.11 46.07,83.24 48.82,83.24 51.81,86.23 51.81,86.34 51.85,86.38 51.85,87.23 51.38,87.7 EC5502.1 51.38,88.24 50.67,88.95 R5502.1
DP1_HPD_CPU: length 94
  TOP w0.102: v1(37.38,69.93) 35.05,69.93 v2(34.92,69.8) R7326.2 ; R404.2 101.85,95.2 Q401.5 100.53,95.2 100.37,95.35 100.37,95.89 100.05,96.21 98.79,96.21 95.7,93.12 87.5,93.12 87.17,92.79 86.15,92.79 84.68,91.32 83.35,91.32 82.16,90.13 78.17,90.13 76.37,91.93 70.02,91.93 69.79,92.15 v1(69.79,92.36) 69.79,92.51 70.15,92.87 72.21,92.87 R7236.1
  L3 w0.102: v1(69.79,92.36) 69.49,92.66 67.46,92.66 67,92.2 66.11,92.2 66.01,92.1 49.02,92.1 47.31,90.4 45.61,90.4 42.84,87.63 42.84,84.86 43.25,84.46 43.25,83.16 42.95,82.86 42.66,82.86 42.06,82.25 42.06,80.52 41.22,79.68 41.22,76.51 40.51,75.8 40.51,74.48 37.38,71.35 v1(37.38,69.93)
DP1_HPD_CPU_R: length 48.8
  TOP w0.102: v1(102.8,93.89) 103.3,94.39 R405.2 R403.2 103.3,96.32 103.12,96.5 v2(102.81,96.5) 102.48,96.5 102.38,96.4 R404.1 102.13,95.53 101.81,95.85 Q401.6
  L4 w0.102: v1(102.8,93.89) 103.22,94.31 103.83,94.31 104.62,93.53 105.48,93.53 108.41,90.6 108.41,88.55 107.19,87.34 107.19,84.45 109.44,82.21 109.44,79.73 109.75,79.43 115.63,79.43 115.67,79.47 118.21,79.47 118.9,78.78 120.25,78.78 120.55,79.08 120.55,81.94 121.28,82.66 126.68,82.66 v1(127.48,81.87)
  BOTTOM w0.102: CPU1.CM6 127.69,81.08 127.45,81.32 127.45,81.84 v1(127.48,81.87)
DP2_AUX_C_N: length 3.2
  TOP w0.102: U7301.25 30.09,70.84 31.39,72.14 C7302.1 R7301.2
DP2_AUX_C_P: length 3
  TOP w0.102: R7302.2 31.44,71.4 C7301.1 31.03,71.45 30.02,70.45 U7301.24
DP2_AUX_CPU_N: length 103.7
  TOP w0.102: C7302.2 32.44,72.13 32.97,72.13 33.24,71.86 33.65,71.86 33.88,72.09 33.88,72.11 33.93,72.16 33.93,74.58 33.85,74.66 33.85,76.24 33.15,76.94 29.32,76.94 28.77,76.39 v1(28.77,76.13)
  L4 w0.102: v1(99.57,89.66) 98.95,90.13 97.78,91.29 96.69,91.29 96.01,90.6 95.22,90.6 93.49,92.33 79.27,92.33 78.81,92.79 67.87,92.79 67.46,92.37 67.46,92.35 67.01,91.9 64.65,91.9 63.31,93.25 54.61,93.25 54.21,92.84 47.5,92.84 46.69,92.03 43.82,92.03 43.51,91.72 40.52,91.72 39.32,90.53 38.37,90.53 33.17,85.32 33.17,79.52 30.81,77.17 29.66,77.17 28.77,76.28 v1(28.77,76.13)
  BOTTOM w0.076: 99.2,86.48 99.2,86.46 99.17,86.44 99.17,84.13 99.24,83.58 99.33,83.51 99.33,83.14 99.26,83.07 CPU1.AD4
  BOTTOM w0.102: v1(99.57,89.66) 99.28,89.66 99.18,89.56 99.18,89.06 ; 99.18,89.06 v2(99.36,89.06) ; 99.18,89.06 99.18,86.7 99.2,86.68 99.2,86.48
DP2_AUX_CPU_P: length 103.8
  TOP w0.102: v1(28.75,77.04) 28.85,76.94 29,76.94 29.23,77.17 33.24,77.17 34.08,76.33 34.08,74.75 34.16,74.68 34.16,72.07 34.11,72.02 34.11,71.99 33.74,71.63 33.15,71.63 32.88,71.9 32.68,71.9 32.3,71.53 C7301.2
  L4 w0.102: v1(99.48,90.31) 99.41,90.23 99.32,90.19 99.16,90.22 99.08,90.28 97.87,91.49 96.61,91.49 95.92,90.81 95.3,90.81 93.58,92.53 79.35,92.53 78.89,92.99 67.79,92.99 67.25,92.46 67.25,92.43 66.92,92.1 64.74,92.1 63.39,93.45 54.53,93.45 54.12,93.04 47.42,93.04 46.6,92.23 43.73,92.23 43.43,91.93 40.43,91.93 39.24,90.73 38.29,90.73 32.96,85.41 32.96,79.61 30.73,77.37 29.58,77.37 29.07,76.86 28.85,76.86 28.75,76.97 v1(28.75,77.04)
  BOTTOM w0.076: CPU1.AD3 99.07,83.29 99.07,83.49 99.06,83.56 99,84.12 99,86.44 98.97,86.46 98.97,86.48
  BOTTOM w0.102: 98.97,86.48 98.97,86.59 98.95,86.6 98.95,89.66 99.05,89.76 99.05,90.22 99.14,90.31 v1(99.48,90.31)
DP2_DDI_TX_N0: length 106.9
  TOP w0.102: C7313.1 24.73,65.23 24.61,65.11 24.61,64.86 24.97,64.5 24.97,64.37 ; v1(24.78,63.63) 24.78,63.98 24.97,64.17 24.97,64.37 ; v2(25.14,64.37) 24.97,64.37
  L4 w0.102: v1(97.78,89.71) 98,89.93 98,90.2 97.65,90.55 96.87,90.55 96.31,89.99 94.96,89.99 94.14,90.81 84.42,90.81 84.19,91.04 79.7,91.04 78.62,92.11 71.49,92.11 70.67,91.29 64.4,91.29 63.05,92.64 54.87,92.64 54.46,92.23 48.64,92.23 46.84,90.43 40.08,90.43 39.58,89.92 38.66,89.92 33.78,85.03 33.78,79.05 31.16,76.43 30.46,76.43 29.49,75.47 29.09,75.47 28.37,74.75 28.37,69.9 27.38,68.91 26.62,68.91 25.98,68.27 25.98,67.08 25.24,66.34 25.24,64.26 24.78,63.81 v1(24.78,63.63)
  BOTTOM w0.076: CPU1.AC4 98.29,82.77 98.25,82.82 98.25,82.99 98.07,83.48 98.07,83.72 98.08,83.74 98.1,83.87 98.1,84.01 98.07,84.18 98.07,84.38 98.23,84.83 98.24,84.87 98.24,84.87 98.24,85.23 97.69,85.78 97.66,85.78
  BOTTOM w0.102: v1(97.78,89.71) 96.9,88.82 96.9,86.54 97.66,85.78
DP2_DDI_TX_N1: length 108
  TOP w0.102: v1(28.29,63.66) 27.4,64.54 27.4,64.92 26.78,65.53 26.53,65.53 26.19,65.88 26.19,66.02 26.49,66.32 C7307.1
  L4 w0.102: v1(28.29,63.66) 28.06,63.66 27.98,63.58 27.98,63.28 28.14,63.13 28.14,62.77 28.39,62.51 29.12,62.51 29.65,63.05 30.5,63.05 30.68,63.22 30.68,65.53 31.77,66.63 31.77,67.63 33.04,68.9 33.04,70.51 33.34,70.82 33.34,71.55 33.93,72.14 33.93,73.06 35.22,74.36 35.22,76.28 36.77,77.83 36.77,80.55 37.69,81.47 37.69,82.65 38.04,83.01 38.93,83.01 39.08,83.16 39.08,84.11 38.96,84.24 37.98,84.24 37.76,84.46 37.76,84.83 37.98,85.05 38.96,85.05 39.08,85.18 39.08,85.58 38.97,85.7 38.03,85.7 37.79,85.94 37.79,86.28 38.03,86.52 38.97,86.52 39.08,86.64 39.08,87.96 40.51,89.39 47.24,89.39 47.87,90.02 59.07,90.02 59.19,90.14 59.19,90.38 59.43,90.62 59.77,90.62 60.01,90.38 60.01,90.14 60.13,90.02 62.28,90.02 63.07,89.23 71.83,89.23 71.9,89.31 78.2,89.31 78.63,88.88 93.97,88.88 95.46,87.39 97.77,87.39 97.94,87.56 97.94,87.81 97.83,87.91 v1(97.6,87.91)
  BOTTOM w0.076: 98.26,86.09 98.28,86.07 98.31,86.07 98.62,85.77 98.62,84.83 98.59,84.33 CPU1.AC1
  BOTTOM w0.102: 97.87,87.05 v2(97.68,87.05) ; 97.87,87.05 97.87,87.81 97.77,87.91 v1(97.6,87.91) ; 97.87,87.05 97.87,86.48 98.26,86.09
DP2_DDI_TX_N2: length 107.2
  TOP w0.102: v1(29.59,63.66) 29.36,63.86 29.34,64.36 28.75,64.95 28.23,64.95 28.12,65.05 28.12,65.24 C7308.1
  L4 w0.102: v1(101.54,90.2) 101.34,90 101.34,89.6 100.61,88.88 95.19,88.88 93.99,90.07 83.88,90.07 83.53,90.43 79.44,90.43 78.88,90.99 71.38,90.99 71,90.6 63.9,90.6 62.48,92.03 55.12,92.03 54.71,91.62 48.9,91.62 47.07,89.79 40.31,89.79 36.37,85.85 36.37,79.45 32.73,75.81 32.73,72.54 29.89,69.69 29.89,66.75 30.23,66.42 30.23,65.26 29.59,64.61 v1(29.59,63.66)
  BOTTOM w0.076: CPU1.AE4 99.88,82.86 99.88,83.21 99.99,83.32 100.06,83.47 100.06,83.69 100.03,83.87 100.03,84.02 100.06,84.13 100.06,84.49 99.94,84.61 99.9,84.75 99.9,84.88 99.89,84.97 99.89,85.06 99.89,85.31 100.34,85.75 100.34,86.06 100.65,86.38 100.65,86.97 100.68,87 100.68,87.02
  BOTTOM w0.102: v2(101.47,88.42) 101.27,88.42 ; 101.27,88.42 101.27,89.94 v1(101.54,90.2) ; 101.27,88.42 101.27,87.92 100.68,87.33 100.68,87.02
DP2_DDI_TX_N3: length 104.4
  TOP w0.102: 30.24,64.08 30.77,63.55 31.49,63.55 31.59,63.66 31.59,64.06 31.69,64.16 32.04,64.16 32.11,64.09 v1(32.11,63.86) ; 30.24,64.08 v2(30.37,64.21) ; 30.24,64.08 30.07,64.26 30.07,64.57 30.19,64.7 30.47,64.7 30.6,64.82 C7310.1
  L4 w0.102: v1(32.11,63.86) 32.11,63.8 31.83,63.52 31.59,63.52 31.49,63.62 31.49,65.18 32.58,66.27 32.58,67.28 33.85,68.55 33.85,70.17 34.16,70.48 34.16,71.22 34.74,71.8 34.74,72.72 36.65,74.63 36.65,76.55 37.59,77.49 37.59,80.21 39.9,82.52 39.9,84.77 40.02,84.89 40.6,84.89 40.84,85.13 40.84,85.46 40.6,85.7 40.02,85.7 39.9,85.82 39.9,87.5 40.92,88.52 41.78,88.52 41.9,88.4 41.9,87.36 42.14,87.12 42.48,87.12 42.72,87.36 42.72,88.4 42.83,88.52 47.53,88.52 48.21,89.21 60.31,89.21 61.3,88.22 71.96,88.22 72.24,88.5 77.86,88.5 78.29,88.06 93.8,88.06 95.19,86.67 99.87,86.67 100.2,87 100.2,87.89 100.3,87.99 v1(100.37,87.99)
  BOTTOM w0.076: v1(100.37,87.99) 100.13,87.99 100.07,87.93 100.07,87.68 100.17,87.58 100.17,86.49 99.53,85.85 99.53,85.11 99.54,84.82 99.54,84.45 99.56,84.32 CPU1.AE1
DP2_DDI_TX_P0: length 107
  TOP w0.102: C7312.1 24.23,65.23 24.38,65.07 24.38,64.77 24.74,64.41 24.74,64.26 24.64,64.16 v1(24.35,64.16)
  L4 w0.102: v1(98.42,89.71) 98.2,89.93 98.2,90.29 97.73,90.76 96.79,90.76 96.23,90.2 95.04,90.2 94.23,91.01 84.5,91.01 84.27,91.24 79.78,91.24 78.71,92.31 71.4,92.31 70.58,91.49 64.48,91.49 63.14,92.84 54.78,92.84 54.38,92.43 48.56,92.43 46.76,90.63 40,90.63 39.49,90.12 38.58,90.12 33.57,85.12 33.57,79.13 31.08,76.63 30.37,76.63 29.41,75.67 29,75.67 28.16,74.83 28.16,69.99 27.29,69.12 26.54,69.12 25.78,68.35 25.78,67.16 25.04,66.42 25.04,64.35 24.75,64.06 24.45,64.06 v1(24.35,64.16)
  BOTTOM w0.076: 97.81,85.95 97.81,85.91 98.42,85.31 98.42,84.84 98.41,84.79 98.4,84.77 98.25,84.35 98.25,84.2 98.28,84.04 98.28,83.8 98.25,83.69 98.25,83.51 CPU1.AC3
  BOTTOM w0.102: 97.12,88.39 97.12,88.73 97.7,89.3 97.95,89.3 98.36,89.71 v1(98.42,89.71) ; 97.12,88.39 v2(97.3,88.39) ; 97.12,88.39 97.12,86.64 97.81,85.95
DP2_DDI_TX_P1: length 108.5
  TOP w0.102: 27.26,64.36 27.69,63.94 27.69,63.79 v1(27.56,63.66) ; 27.26,64.36 v2(27.13,64.23) ; 27.26,64.36 27.17,64.45 27.17,64.82 26.69,65.31 26.44,65.31 25.96,65.78 25.96,66.22 C7314.1
  L4 w0.102: v1(27.56,63.66) 27.78,63.44 27.78,63.2 27.93,63.05 27.93,62.68 28.31,62.31 29.2,62.31 29.74,62.84 30.58,62.84 30.88,63.14 30.88,65.45 31.97,66.54 31.97,67.54 33.24,68.81 33.24,70.43 33.55,70.73 33.55,71.47 34.13,72.05 34.13,72.98 35.43,74.27 35.43,76.19 36.98,77.74 36.98,80.47 37.89,81.38 37.89,82.57 38.13,82.81 39.02,82.81 39.29,83.08 39.29,84.2 39.04,84.44 38.07,84.44 37.97,84.54 37.97,84.75 38.07,84.85 39.04,84.85 39.29,85.09 39.29,85.67 39.05,85.91 38.11,85.91 37.99,86.03 37.99,86.19 38.11,86.31 39.05,86.31 39.29,86.55 39.29,87.88 40.59,89.18 47.32,89.18 47.96,89.82 59.16,89.82 59.4,90.06 59.4,90.29 59.52,90.41 59.68,90.41 59.8,90.29 59.8,90.06 60.04,89.82 62.2,89.82 62.99,89.03 71.91,89.03 71.99,89.11 78.12,89.11 78.55,88.67 93.89,88.67 95.37,87.19 97.85,87.19 98.14,87.47 98.14,87.7 v1(98.35,87.91)
  BOTTOM w0.076: CPU1.AC2 98.75,84.16 98.8,84.82 98.8,85.84 98.44,86.2 98.44,86.23 98.43,86.25
  BOTTOM w0.102: v1(98.35,87.91) 98.1,87.66 98.1,86.57 98.43,86.25
DP2_DDI_TX_P2: length 107.2
  TOP w0.102: v1(28.92,63.63) 29.13,63.85 29.12,64.26 28.65,64.72 28.13,64.72 27.9,64.96 27.9,65.24 C7309.1
  L4 w0.102: v1(28.92,63.63) 28.92,64.09 29.03,64.19 29.28,64.19 29.38,64.29 29.38,64.7 30.03,65.34 30.03,66.33 29.69,66.67 29.69,69.78 32.53,72.62 32.53,75.9 36.16,79.53 36.16,85.93 40.23,89.99 46.98,89.99 48.81,91.82 54.63,91.82 55.04,92.23 62.56,92.23 63.98,90.81 70.91,90.81 71.29,91.19 78.96,91.19 79.52,90.63 83.61,90.63 83.97,90.27 94.08,90.27 95.27,89.08 100.53,89.08 101.14,89.69 101.14,90.07 101.01,90.2 v1(100.78,90.2)
  BOTTOM w0.076: 100.45,87.02 100.45,87 100.48,86.97 100.48,86.45 100.16,86.13 100.16,85.83 99.71,85.38 99.71,85.05 99.72,84.97 99.72,84.88 99.72,84.72 99.79,84.51 99.88,84.41 99.88,84.15 99.87,84.1 99.87,84.1 99.86,84.05 99.86,84.04 99.86,83.86 99.86,83.84 99.88,83.68 99.88,83.51 99.84,83.42 99.76,83.34 99.71,83.29 99.71,83.24 CPU1.AE3
  BOTTOM w0.102: 100.45,87.02 100.45,87.42 101.05,88.02 101.05,89.49 ; v2(100.86,89.49) 101.05,89.49 ; 101.05,89.49 101.05,90.1 100.94,90.2 v1(100.78,90.2)
DP2_DDI_TX_P3: length 104.5
  TOP w0.102: 31.03,63.32 32.05,63.32 v1(32.15,63.22) ; 31.03,63.32 30.68,63.32 29.84,64.16 C7311.1 ; 31.03,63.32 v2(31.03,63.12)
  L4 w0.102: v1(32.15,63.22) 32.05,63.31 31.51,63.31 31.29,63.53 31.29,65.26 32.38,66.36 32.38,67.36 33.65,68.63 33.65,70.26 33.95,70.56 33.95,71.3 34.54,71.88 34.54,72.81 36.44,74.71 36.44,76.63 37.38,77.57 37.38,80.29 39.69,82.6 39.69,84.85 39.93,85.09 40.52,85.09 40.63,85.21 40.63,85.38 40.52,85.5 39.93,85.5 39.69,85.74 39.69,87.58 40.84,88.72 41.87,88.72 42.11,88.49 42.11,87.45 42.22,87.33 42.39,87.33 42.51,87.45 42.51,88.49 42.75,88.72 47.44,88.72 48.13,89.41 60.4,89.41 61.39,88.42 71.88,88.42 72.16,88.7 77.95,88.7 78.38,88.27 93.88,88.27 95.28,86.87 99.78,86.87 99.99,87.08 99.99,87.66 v1(99.67,87.99)
  BOTTOM w0.076: CPU1.AE2 99.57,83.67 99.36,84.13 99.36,84.82 99.35,85.1 99.35,85.11 99.35,85.92 99.99,86.56 99.99,87.51 99.89,87.61 99.89,87.76 v1(99.67,87.99)
DP2_DDI_TX_RE_C_N0: length 2.8
  TOP w0.102: U7301.10 24.92,68.44 24.83,68.35 24.83,68.12 24.58,67.88 24.58,66.4 C7313.2
DP2_DDI_TX_RE_C_N1: length 2
  TOP w0.102: C7307.2 26.61,67.44 26.49,67.57 26.16,67.57 26.08,67.64 26.08,67.82 25.95,67.95 25.95,68.15 26.12,68.32 U7301.13
DP2_DDI_TX_RE_C_N2: length 3
  TOP w0.102: U7301.16 27.32,68.23 27.22,68.13 27.22,67.9 27.87,67.25 ; 27.87,67.25 28.11,67.01 28.11,66.7 C7308.2 ; 27.87,67.25 v2(28.01,67.39)
DP2_DDI_TX_RE_C_N3: length 4
  TOP w0.102: C7310.2 30.07,66.55 30.07,66.75 29.67,67.15 ; 29.67,67.15 v2(29.81,67.29) ; 29.67,67.15 29.38,67.44 28.95,67.44 28.52,67.87 U7301.19
DP2_DDI_TX_RE_C_P0: length 2.8
  TOP w0.102: U7301.9 24.52,68.44 24.6,68.36 24.6,68.22 24.35,67.97 24.35,66.42 C7312.2
DP2_DDI_TX_RE_C_P1: length 1.5
  TOP w0.102: C7314.2 25.85,67.73 25.72,67.85 25.72,68.23 U7301.12
DP2_DDI_TX_RE_C_P2: length 2.8
  TOP w0.102: U7301.15 26.92,68.23 26.99,68.16 26.99,67.8 27.88,66.91 27.88,66.68 C7309.2
DP2_DDI_TX_RE_C_P3: length 3.7
  TOP w0.102: C7311.2 29.84,66.66 29.29,67.21 28.86,67.21 28.3,67.77 28.3,68.13 28.12,68.3 U7301.18
DPEQ0_A1: length 3.3
  TOP w0.102: U7301.14 26.52,68.03 v1(26.5,68.01)
  BOTTOM w0.102: v1(26.5,68.01) 26.22,68.01 R7341.2 25.83,68.46 R7342.1 v2(24.91,69.22)
DPEQ1: length 4.3
  TOP w0.102: R7325.2 R7340.1 21.2,71.5 21.84,72.14 v2(22.35,72.14) 22.59,72.14 23.08,71.65 U7301.2
EC_AGND: length 27
  TOP w0.203: R2445.2 39.06,33.89 38.78,34.17 38.78,34.88 38.91,35 39.01,35 39.18,35.18 U2401.112
  TOP w0.305: R2445.2 38.68,33.66 38.45,33.89 v1(38.33,33.89)
  TOP w0.356: v1(38.33,33.89) 38.33,32.41 38.7,32.03
  TOP w0.508: v1(31.08,28.2) 30.88,27.99 28.14,27.99 C2436.2 ; C2431.2 32.27,33.78 32.27,33.06 v1(32.28,33.05) ; v1(35.5,32.87) R2441.2 36.09,33.45 C2407.1
  L3 w0.508: v1(31.08,28.2) 32.86,28.2 34.59,29.92 34.59,31.96 v1(35.5,32.87)
  L4 w0.508: v1(38.33,33.89) 37.31,32.87 v1(35.5,32.87) 34.93,33.44 32.93,33.44 32.53,33.05 v1(32.28,33.05)
  vias: v2(39.95,31.12)
EDP_AUX_CON_N: length 3.5
  BOTTOM w0.102: C5533.2 42.51,89.21 R5529.1 42.21,90.15 42.21,90.96 43.06,91.81 LCD1.11
EDP_AUX_CON_P: length 3.5
  BOTTOM w0.102: LCD1.10 42.56,91.64 41.98,91.06 41.98,90.15 R5528.1 41.88,89.64 41.88,89.33 C5531.2
EDP_AUX_CPU_N: length 76.5
  L6 w0.089: v1(41.31,85.41) 41.39,85.49 44.07,85.49 44.69,84.88 46.22,84.88 49.3,87.96 55.22,87.96 56.26,88.99 60,88.99 61.73,87.26 69.07,87.26 74.85,81.49 77.92,81.49 80.31,83.87 80.31,84.79 81.17,85.65 92.32,85.65 92.58,85.39 102.68,85.39 v1(102.74,85.34)
  BOTTOM w0.102: 42.21,86.21 42.21,87.99 C5533.1 ; 42.21,86.21 v2(42.39,86.21) ; 42.21,86.21 42.21,85.99 41.97,85.75 41.65,85.75 v1(41.31,85.41) ; v1(102.74,85.34) 102.47,85.6 102.19,85.6 101.78,85.2 101.78,83.14 101.51,82.86 CPU1.AH4
EDP_AUX_CPU_P: length 76.6
  L6 w0.089: v1(102.74,86.09) 102.49,86.09 102.33,85.93 102.33,85.69 102.23,85.59 92.66,85.59 92.4,85.84 81.09,85.84 80.12,84.87 80.12,83.95 77.84,81.68 74.93,81.68 69.15,87.45 61.81,87.45 60.08,89.18 56.18,89.18 55.14,88.15 49.23,88.15 46.15,85.07 44.76,85.07 44.15,85.68 41.84,85.68 41.75,85.77 41.75,86.21 41.66,86.3 v1(41.31,86.3)
  BOTTOM w0.102: CPU1.AH3 101.55,83.34 101.55,85.29 102.09,85.83 102.47,85.83 v1(102.74,86.09) ; 41.98,87.48 41.98,88.01 C5531.1 ; 41.98,87.48 41.98,86.08 41.88,85.98 41.62,85.98 v1(41.31,86.3) ; 41.98,87.48 v2(41.8,87.48)
EDP_BKLT_CTRL: length 2.9
  BOTTOM w0.102: D5503.1 46.62,85.03 46.43,85.22 v2(46.27,85.22) 45.49,85.22 R5524.1 R5530.2
EDP_HPD_CONN: length 12.3
  BOTTOM w0.102: RN5504.3 41.58,84.01 43.6,86.03 v2(43.92,86.03) 45.28,86.03 45.84,86.59 45.84,86.59 46.65,87.4 46.65,87.41 46.98,87.74 46.98,88.62 47.06,88.7 LCD1.19
EDP_HPD_CPU: length 153
  TOP w0.102: v1(30.55,77.85) 30.91,78.21 v2(30.91,78.95) 32.15,77.7 34.26,77.7 36.04,75.92 40.76,75.92 41.37,76.53 42.54,76.53 43,76.99 43,77.93 42.62,78.31 42.62,78.49 42.51,78.59 42.51,80.82 v1(42.82,81.13)
  L4 w0.102: v1(30.55,77.85) 30.55,77.96 30.35,78.16 30.35,85.25 33.78,88.67 33.78,90.38 35.71,92.31 39.34,92.31 40,92.97 43,92.97 44.11,94.08 53.56,94.08 53.93,94.45 63.86,94.45 64.99,93.32 66.01,93.32 66.72,94.03 79.93,94.03 80.39,93.58 95.88,93.58 96.84,92.61 98.5,92.61 99.7,91.4 104.63,91.4 105.25,90.78 105.25,87.57 104.83,87.15 104.83,84.45 106.11,83.16 106.11,82.4 105.82,82.1 105.82,79.67 106.34,79.15 107.41,79.15 109.33,77.23 112.39,77.23 112.39,77.23 112.4,77.23 113.22,76.42 118.81,76.42 119.24,75.99 121.67,75.99 122.12,76.43 122.73,76.43 123.29,77 123.29,77.03 124.74,78.48 126.4,78.48 127.04,79.12 127.04,80.17 127.51,80.63 v1(127.51,80.66)
  BOTTOM w0.102: v1(127.51,80.66) 127.65,80.52 CPU1.CM7 ; RN5502.3 44.87,82.25 45.13,81.99 45.13,81.38 44.88,81.13 v1(42.82,81.13) 42.34,81.61 41.8,81.61 41.58,81.84 RN5504.2
EDP_RCOMP_CPU: length 13.8
  TOP w0.305: v2(100.76,69.29) 100.81,69.24 R401.2
  TOP w0.508: R401.2 v1(101.68,69.9)
  L6 w0.508: v1(101.68,69.9) 101.49,70.09 101.49,76.12 103.3,77.92 103.3,80.39 v1(103.51,80.6)
  BOTTOM w0.2: CPU1.AM6 103.6,80.6 v1(103.51,80.6)
EDP_TX_CON_N0: length 2.6
  BOTTOM w0.102: C5508.2 46.07,90.25 46.07,90.71 45.7,91.09 45.7,91.45 45.56,91.59 LCD1.16
EDP_TX_CON_N1: length 2.4
  BOTTOM w0.102: LCD1.13 44.06,91.78 44.33,91.5 44.33,90.03 C5534.2
EDP_TX_CON_P0: length 2.5
  BOTTOM w0.102: C5532.2 46.3,90.17 46.3,90.81 45.92,91.18 45.92,91.45 46.06,91.59 LCD1.17
EDP_TX_CON_P1: length 2.6
  BOTTOM w0.102: C5537.2 45,90.21 44.9,90.31 44.64,90.31 44.56,90.39 LCD1.14
EDP_TX_CPU_N0: length 74.6
  L6 w0.089: v1(102.46,90.25) 102.74,89.97 102.74,89.3 100.09,86.65 94.46,86.65 93.39,87.72 78.05,87.72 77.59,88.18 70.23,88.18 68.84,89.56 64.05,89.56 62.2,91.42 55.72,91.42 55.13,90.82 55.13,90.32 54.13,89.32 48.5,89.32 46.73,87.54 45.7,87.54 v1(45.46,87.79)
  BOTTOM w0.076: CPU1.AG4 100.69,82.88 100.57,83.29 100.57,83.36 100.53,83.44 100.52,83.44 100.52,83.46 100.51,83.48 100.51,83.77 100.53,83.78 100.54,83.87 100.54,84.01 100.51,84.18 100.51,84.37 100.68,84.92 100.68,84.93 100.73,85.08 100.73,85.84 101,86.11 101,86.97 101.84,87.81 101.84,87.85 101.85,87.86
  BOTTOM w0.102: v1(45.46,87.79) 45.68,87.56 45.91,87.56 46.01,87.66 46.01,88.78 C5508.1 ; 101.85,87.86 102.29,88.3 102.72,88.73 102.72,89.99 v1(102.46,90.25)
EDP_TX_CPU_N1: length 75.1
  L6 w0.089: v1(102.75,86.78) 102.48,87.05 102.35,87.05 101.59,87.05 100.41,85.86 92.95,85.86 92.57,86.24 80.93,86.24 79.72,85.03 79.72,84.12 77.68,82.08 75.08,82.08 69.2,87.96 61.86,87.96 60.17,89.65 55.83,89.65 54.71,88.54 49.04,88.54 45.96,85.46 44.94,85.46 43.71,86.69 43.71,87.27 v1(43.4,87.58)
  BOTTOM w0.102: 43.77,88.13 43.63,87.99 43.63,87.81 v1(43.4,87.58) ; 43.77,88.13 44.24,88.6 C5534.1 ; 43.77,88.13 v2(43.65,88.25) ; CPU1.AG2 101.35,84.02 101.35,85.47 101.73,85.85 101.73,86.69 102.08,87.04 102.46,87.04 102.75,86.75 v1(102.75,86.78)
EDP_TX_CPU_P0: length 74.7
  L6 w0.089: v1(103.21,90.25) 102.93,89.97 102.93,89.22 100.17,86.46 94.38,86.46 93.31,87.53 77.97,87.53 77.51,87.99 70.15,87.99 68.76,89.37 63.97,89.37 62.12,91.23 55.8,91.23 55.32,90.74 55.32,90.24 54.21,89.13 48.58,89.13 46.81,87.35 45.69,87.35 v1(45.49,87.15)
  BOTTOM w0.076: 102.01,87.7 102,87.68 101.96,87.68 101.17,86.9 101.17,86.03 100.91,85.77 100.91,85.05 100.87,84.94 100.85,84.87 100.85,84.86 100.69,84.35 100.69,84.2 100.72,84.04 100.72,83.8 100.69,83.7 100.69,83.69 100.69,83.51 100.9,83.05 CPU1.AG3
  BOTTOM w0.102: v1(103.21,90.25) 102.95,89.99 102.95,88.64 102.01,87.7 ; 46.24,88.12 46.24,88.74 C5532.1 ; 46.24,88.12 v2(46.4,88.12) ; 46.24,88.12 46.24,87.57 46,87.33 45.67,87.33 v1(45.49,87.15)
EDP_TX_CPU_P1: length 74.8
  L6 w0.089: v1(44.19,87.58) 43.9,87.29 43.9,86.77 45.02,85.65 45.88,85.65 48.96,88.73 54.64,88.73 55.75,89.84 60.25,89.84 61.94,88.15 69.27,88.15 75.16,82.27 77.6,82.27 79.53,84.2 79.53,85.11 80.85,86.43 92.65,86.43 93.03,86.05 100.33,86.05 101.51,87.24 102.35,87.24 102.48,87.24 v1(102.75,87.51)
  BOTTOM w0.102: v1(102.75,87.51) 102.51,87.27 101.98,87.27 101.5,86.79 101.5,85.95 101.12,85.57 101.12,84.44 CPU1.AG1 ; v1(44.19,87.58) 43.96,87.58 43.86,87.68 43.86,87.9 44.56,88.59 44.81,88.59 45,88.78 C5537.1
EDP_VDD_EN: length 132.3
  TOP w0.127: v1(32.2,80.28) 32.28,80.21 v2(32.28,78.49) 32.8,77.97 34.37,77.97 35.99,76.36 37.89,76.36 37.94,76.41 v1(38.02,76.41)
  L4 w0.127: v1(32.2,80.28) 31.89,79.97 31.11,79.97 30.66,80.41 30.66,85.08 34.03,88.45 34.03,89.94 36.14,92.05 39.44,92.05 40.1,92.71 43.1,92.71 43.4,93.02 45.61,93.02 46.43,93.83 53.65,93.83 54.03,94.21 63.75,94.21 64.88,93.08 66.12,93.08 66.8,93.75 79.65,93.75 80.08,93.32 95.78,93.32 96.82,92.28 98.24,92.28 99.4,91.12 103.46,91.12 104.34,90.24 104.34,88.39 104.63,88.1 104.63,84.33 105.91,83.05 105.91,82.5 105.61,82.2 105.61,79.58 106.25,78.95 107.31,78.95 109.22,77.03 112.3,77.03 113.17,76.16 117.27,76.16 117.91,75.53 119.27,75.53 119.48,75.75 121.66,75.75 121.89,75.52 122.47,75.52 123.07,75.52 123.49,75.93 123.49,76.94 124.82,78.27 125.24,78.27 v1(125.66,77.85)
  BOTTOM w0.127: CPU1.CG11 125.37,78.14 v1(125.66,77.85) ; v1(38.02,76.41) 37.84,76.41 37.34,76.9 D5502.1
EMMC_RCOMP: length 2.5
  TOP w0.508: R2108.1 127.93,75.34 v2(127.93,74.48) 127.36,74.48 v1(127,74.84)
  BOTTOM w0.508: v1(127,74.84) 127.32,75.17 CPU1.CK15
EN1: length 3.7
  TOP w0.127: v2(215.11,42.17) 214.29,42.17 R4019.1 213.53,42.93 212.39,42.93 212.15,42.69 U4003.3
EN2: length 2.6
  TOP w0.127: U4001.5 212,46.36 212.64,45.72 v2(213.05,45.72) R4048.1
EN_VCCSFR_OC: length 8.7
  BOTTOM w0.102: R4039.2 165.69,68.23 v2(165.93,67.98) 166.45,67.46 166.45,65.98 166.36,65.89 166.36,62.18 166.06,61.88 C4047.1 166.05,61.74 U4004.4
EQ0: length 3.8
  TOP w0.102: U7301.38 25.32,73.38 v1(25.24,73.46)
  BOTTOM w0.102: R7321.1 24.78,72.72 v2(24.35,73.15) 24.35,73.31 24.51,73.46 v1(25.24,73.46) 25.29,73.51 R7320.2
EQ1: length 3.5
  TOP w0.102: v1(26.56,73.48) 26.52,73.45 U7301.35
  BOTTOM w0.102: R7319.1 26.87,72.72 v2(26.92,72.77) 26.92,73.13 v1(26.56,73.48) 26.05,73.99 R7318.2
ESPI_ALERT#: length 36.3
  TOP w0.089: v2(133.8,44.15) 133.9,44.05 v1(133.9,43.51) 133.9,42.34 133.39,41.83 133.39,41.15 133.45,41.09 133.45,38.97 R1821.2
  L6 w0.089: v1(133.9,43.51) 132.81,44.61 131.1,44.61 129.41,46.3 129.41,49.35 127.43,51.34 127.43,52.61 126.91,53.13 126.91,53.45 122.89,57.47 122.89,60.71 120.4,63.2 120.4,66.56 120.8,66.96 v1(120.82,66.96)
  BOTTOM w0.089: v1(120.82,66.96) 120.8,66.96 120.52,67.23 CPU1.BV28
ESPI_CLK: length 139.2
  TOP w0.089: v1(61.89,46.69) 60.45,46.69 60.3,46.84 60.3,47.53 60.42,47.65 62.48,47.65 66.01,44.12 66.01,43.59 67.02,42.57 71.42,42.57 73.04,40.95 v2(73.48,40.95) 73.86,40.95 74.05,40.76 74.05,40.65 73.71,40.31 73.71,40.2 73.79,40.12 73.9,40.12 74.24,40.46 74.35,40.46 74.42,40.38 74.42,40.27 74.09,39.94 74.09,39.82 74.17,39.75 74.28,39.75 74.61,40.08 74.72,40.08 74.8,40 74.8,39.89 74.47,39.56 74.47,39.45 74.54,39.37 74.66,39.37 74.99,39.7 75.1,39.7 75.18,39.63 75.18,39.52 74.84,39.18 74.84,39.07 74.92,38.99 75.03,38.99 75.37,39.33 75.48,39.33 75.56,39.25 75.56,39.14 75.22,38.8 75.22,38.69 75.3,38.61 75.41,38.61 75.75,38.95 75.86,38.95 75.93,38.87 75.93,38.76 75.6,38.43 75.6,38.31 75.68,38.24 75.79,38.24 76.12,38.57 76.23,38.57 76.31,38.49 76.31,38.38 75.98,38.05 75.98,37.94 76.05,37.86 76.17,37.86 76.5,38.19 76.61,38.19 76.69,38.12 76.69,38.01 76.35,37.67 76.35,37.56 76.43,37.48 76.54,37.48 76.88,37.82 76.99,37.82 77.07,37.74 77.07,37.63 76.73,37.29 76.73,37.18 76.81,37.1 76.92,37.1 77.25,37.44 77.37,37.44 78.12,36.68 100.55,36.68 101.85,37.98 v2(109.37,37.98) 109.61,37.98 109.7,37.89 109.7,37.26 109.79,37.17 109.97,37.17 110.05,37.25 110.05,37.9 110.13,37.98 110.24,37.98 110.32,37.9 110.32,37.25 110.4,37.17 110.51,37.17 110.59,37.25 110.59,37.9 110.66,37.98 110.77,37.98 110.85,37.9 110.85,37.25 110.93,37.17 111.04,37.17 111.12,37.25 111.12,37.9 111.2,37.98 111.31,37.98 111.39,37.9 111.39,37.25 111.46,37.17 111.57,37.17 111.65,37.25 111.65,37.9 111.73,37.98 111.84,37.98 111.92,37.9 111.92,37.25 112,37.17 121.84,37.17 124.14,39.47 124.14,46.08 124.38,46.31 EC1801.1 124.38,47.35 124,47.73 124,47.93 123.44,48.49 R1805.2 ; v1(41.19,56.86) 39.78,56.86 35.98,53.06 U2401.57
  L3 w0.114: v1(61.89,46.69) 61.89,47.6 59.99,49.51 59.99,49.53 59.89,49.63 59.89,50.7 59.86,50.73 59.86,51.16 58.31,52.71 58.31,54.64 56.97,55.98 54.84,55.98 52.88,57.94 50.79,57.94 v1(50.29,58.43)
  L6 w0.089: v1(50.29,58.43) 49.45,57.59 45.45,57.59 44.6,58.45 43.01,58.45 42.77,58.2 41.69,58.2 41.37,57.88 41.19,57.7 v1(41.19,56.86)
  BOTTOM w0.089: v1(41.19,56.86) 41.59,56.46 DBG1.2
