# Allegro board 17859-1.0710WZS1337.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
1V_CPU_CORE on L5VCC: 103.32,67.43 101.57,69.18 95.04,69.18 94.45,68.6 92.02,68.6 91.02,69.6 91.02,71.63 90.09,72.56 63.83,72.56 63.33,73.06 63.33,81.61 65.35,83.63 70.45,83.63 73.7,80.38 80.77,80.38 84.33,83.95 84.33,84.68 84.83,85.18 93.01,85.18 95.44,82.74 96.46,82.74 96.86,82.35 96.86,81.67 96.43,81.23 96.43,79.93 97.58,78.78 101.29,78.78 101.88,79.37 104.97,79.37 107.97,76.37 111.42,76.37 112.48,75.31 112.48,70.64 112.22,70.39 112.22,68.96 112.88,68.3 112.88,67.49 112.82,67.43
1V_GT_CORE on TOP: 97.96,76.18 97.89,76.25 97.89,77.83 97.78,77.93 96.82,77.93 96.72,78.03 96.72,78.26 96.84,78.39 98.06,78.39 98.17,78.49 98.17,80.17 98.01,80.32 98.01,81.71 95.14,84.58 95.14,84.94 95.45,85.25 102.2,85.25 102.53,84.91 102.84,84.91 102.94,84.81 102.94,84.56 101.31,82.93 101.31,80.83 100.86,80.37 100.86,78.79 100.53,78.46 100.53,77.93 100.63,77.83 102.53,77.83 102.58,77.78 102.58,76.84 102.48,76.74 99.16,76.74 98.95,76.53 98.95,76.23 98.9,76.18
1V_GT_CORE on BOTTOM: 96.77,77.9 96.39,78.29 96.39,79.73 96.49,79.83 99.26,79.83 99.28,79.81 103.93,79.81 104.03,79.71 104.03,79.38 103.22,78.56 102.33,78.56 102.08,78.31 102.08,78.06 101.92,77.9
1V_VCCGT on TOP: outline of 92 points within 60.24,57.2 98.7,85.07 ; 46 cut-outs
1V_VCCGT on BOTTOM: 63.65,57.15 62.61,58.19 60.7,58.19 60.47,58.42 60.47,60.81 61.11,61.45 62.61,61.45 62.73,61.57 62.73,64.54 62.63,64.65 61.08,64.65 60.9,64.82 60.9,66.6 61.39,67.08 69.51,67.08 70.91,68.48 70.91,71.1 78.05,78.23 78.05,78.39 82.23,82.57 85.43,82.57 85.69,82.83 85.69,83.29 86.4,84 86.68,84 86.81,83.87 86.81,83.24 87.32,82.73 87.73,82.73 88.41,82.04 88.41,80.93 88.74,80.6 91.92,80.6 92.42,80.09 93.54,80.09 93.59,80.04 94.48,80.04 94.84,79.68 94.84,79.58 94.89,79.53 95.32,79.53 95.57,79.78 95.63,79.78 95.78,79.63 95.78,79.56 96.03,79.3 96.16,79.3 96.21,79.25 96.21,78.56 95.98,78.34 95.98,78.11 95.63,77.75 90.47,77.75 90.11,77.4 90.11,72.52 89.91,72.32 78.91,72.32 77.9,71.3 77.9,68.84 71.14,62.08 71.14,57.84 70.45,57.15 ; 6 cut-outs
1V_VCCGT on L6: 95.55,79.12 96.82,79.12 98.7,77.24 98.7,71.48 98.27,71.05 90.44,71.05 89.1,72.39 75.97,72.39 67.33,63.76 66.82,63.76 61.72,58.65 60.78,58.65 60.37,59.06 60.37,65.46 62.86,67.95 64.74,67.95 66.26,69.47 66.26,70.23 75.46,79.43 79.19,79.43 79.98,80.22 94.46,80.22
1V_VCCIO on TOP: 157.7,55.93 157.65,55.98 157.65,56.64 157.8,56.8 157.8,57.41 158.08,57.69 158.08,58.42 158.26,58.6 160.85,58.6 160.98,58.47 160.98,57 161.23,56.75 161.23,56.16 161.18,56.11 159.89,56.11 159.71,55.93 ; 3 cut-outs
1V_VCCIO on BOTTOM: 102.66,67.57 102.46,67.77 102.46,70.21 102.64,70.39 103.96,70.39 104.24,70.11 104.24,67.92 103.88,67.57
1V_VCCIO on BOTTOM: 157.6,55.81 157.45,55.96 157.45,57.97 158.06,58.58 161.87,58.58 162,58.45 162,57.38 161.84,57.23 161.61,57.23 161.44,57.05 161.44,56.06 161.18,55.81 ; 4 cut-outs
1V_VCCIO on BOTTOM: 113.43,67.47 113.33,67.57 113.33,70.16 113.42,70.25 113.72,70.25 114.6,69.37 114.6,67.62 114.45,67.47
1V_VCCIO on L2GND: 131.06,48.35 126.11,53.3 110.08,53.3 109.46,53.93 109.46,68.23 109.13,68.56 109.13,70.15 109.57,70.6 116.96,70.6 117.37,71.01 117.94,70.43 117.94,67.21 118.35,66.8 118.35,62.08 120.18,60.24 127.8,60.24 135.83,52.21 153.95,52.21 155.23,53.49 155.23,58.51 160.8,58.51 161.09,58.22 161.09,50.63 159.58,49.11 158.97,49.11 158.21,48.35
1V_VCCIO on L3: 102.43,70.34 102.99,70.34 103.25,70.08 103.25,69.65 103.55,69.34 113,69.34 113.2,69.55 113.2,70.06 113.28,70.13 113.76,70.13 114.34,69.55 114.34,68.84 114.14,68.63 102.31,68.63 102.15,68.79 102.15,70.06
1V_VCCIO on L4: 113.3,70.31 113.99,70.31 114.98,69.32 117.22,69.32 117.76,68.77 118.32,68.77 118.74,68.35 122.14,68.35 122.45,68.05 122.45,64.93 123.34,64.04 124.66,64.04 125.98,62.72 129.84,62.72 130.3,62.26 132.63,62.26 132.73,62.16 132.73,61.47 132.53,61.27 130.78,61.27 130.42,61.62 127.45,61.62 127.32,61.75 125.01,61.75 124.3,62.46 121.79,62.46 120.14,64.11 120.14,65.64 119.83,65.94 118.89,65.94 117.62,67.21 116.96,67.21 116.22,67.95 114.04,67.95 113.15,68.84 113.15,70.16
1V_VCCIO_R on BOTTOM: 160.22,59.34 160.14,59.41 160.14,59.72 160.01,59.85 158.16,59.85 158.01,60 158.01,61.62 158.36,61.98 160.45,61.98 160.5,61.93 160.5,61.22 160.78,60.94 160.78,60.07 160.73,60.02 160.73,59.41 160.65,59.34 ; 2 cut-outs
1V_VCCSA on TOP: 114.57,69.42 112.85,71.15 112.67,71.15 112.44,71.38 112.44,72.06 112.54,72.16 113.43,72.16 113.56,72.04 113.56,71.94 115.49,70.01 115.49,69.62 115.28,69.42 ; 1 cut-out
1V_VCCSA on TOP: 112.31,76.86 112.16,77.02 112.16,77.88 112.64,78.36 112.64,79.2 112.69,79.25 113.23,79.25 113.35,79.38 113.35,79.99 113.48,80.11 114.8,80.11 114.81,80.1 115.65,80.1 115.84,79.91 115.84,78.39 115.69,78.23 115.01,78.23 114.73,78.51 114.09,78.51 113.28,77.7 113.28,76.99 113.15,76.86 ; 1 cut-out
1V_VCCSA on TOP: 104.03,97.69 103.83,97.89 103.83,101.04 103.96,101.17 106.34,101.17 107.36,100.15 107.36,97.89 107.16,97.69 ; 3 cut-outs
1V_VCCSA on BOTTOM: 101.31,97.54 100.98,97.87 100.98,102.31 101.29,102.62 106.27,102.62 106.42,102.47 106.42,101.35 106.43,101.34 106.43,100.9 106.75,100.59 106.75,97.97 106.32,97.54 ; 9 cut-outs
1V_VCCSA on BOTTOM: 112.85,77.98 112.74,78.08 112.74,78.29 113,78.54 113,79.86 113.23,80.09 115.89,80.09 116.1,79.89 116.1,78.13 115.95,77.98
1V_VCCSA on BOTTOM: 114.79,67.71 114.75,67.74 114.75,69.42 114.22,69.95 114.22,70.34 114.27,70.39 116.1,70.39 116.15,70.34 116.15,69.95 116,69.8 115.61,69.8 115.51,69.7 115.51,68.2 115.02,67.71
1V_VCCSA on L3: 113.33,80.09 115.61,80.09 115.87,79.83 115.87,76.02 115.61,75.77 115.61,69.8 115.36,69.55 114.6,69.55 114.22,69.93 114.22,76.02 112.69,77.55 112.69,78.69 113.2,79.2 113.2,79.96
1V_VCCSA on L5VCC: 112.75,75.58 111.58,76.75 108.12,76.75 105.13,79.75 103.46,79.75 103.23,79.97 103.23,82.73 101.58,84.38 101.58,87.6 102.6,88.62 102.6,89.77 102.27,90.1 102.27,99.57 103.58,100.88 106.7,100.88 107.09,100.48 107.09,97 109.07,95.02 109.07,94.52 108.77,94.21 108.77,90.04 108.97,89.84 108.97,87.78 109.07,87.68 109.07,84.15 110.38,82.84 114.67,82.84 114.81,82.7 114.81,80.42 115.18,80.05 115.82,80.05 116.03,79.83 116.03,77.65 113.96,75.58
1V_VCCST_CPU on TOP: 116.54,77 116,77.55 116,78.34 116.25,78.59 117.47,78.59 117.65,78.77 118.92,78.77 118.97,78.72 118.97,78.21 118.89,78.13 117.82,78.13 117.7,78.01 117.7,77.6 117.57,77.47 117.24,77.47 116.77,77 ; 1 cut-out
1V_VCCST_CPU on BOTTOM: 116.45,76.96 116.33,77.09 116.33,77.88 116.96,78.51 118.66,78.51 118.85,78.32 118.85,77.97 118.61,77.73 118.61,77.63 118.49,77.5 117.27,77.5 116.73,76.96
1V_VCCST_CPU_R on BOTTOM: 107.46,103.36 107.33,103.48 107.33,104.57 107.16,104.75 106.85,104.75 106.55,105.06 106.55,105.31 106.75,105.51 109.34,105.51 109.44,105.41 109.44,103.56 109.39,103.51 108.55,103.51 108.4,103.36 ; 1 cut-out
1V_VGA_S0 on BOTTOM: 184.6,93.02 184.45,93.17 184.45,98.15 184.93,98.63 184.93,99.57 184.58,99.93 184.58,103.74 183.69,104.63 183.03,104.63 182.65,104.24 181.65,104.24 181.55,104.14 180.74,104.14 180.51,104.37 180.51,105.54 180.26,105.79 180.26,106.2 180.36,106.3 181.17,106.3 181.6,106.73 185.8,106.73 186.15,106.38 186.15,102.29 185.39,101.53 185.39,99.72 185.49,99.62 185.49,98.35 184.96,97.82 184.96,93.12 184.86,93.02 ; 11 cut-outs
1V_VGA_S0 on BOTTOM: 155.44,83.77 155.07,84.14 155.07,86.27 155.11,86.31 155.11,87.02 155.39,87.3 157.63,87.3 157.88,87.05 157.88,85.02 156.64,83.77
3V3_AON_1D8V_VGA_S0 on BOTTOM: 175.66,94.01 175.3,94.36 175.3,94.69 175.05,94.95 174.8,94.95 173.58,96.17 173.58,96.83 173.65,96.9 174.57,96.9 175,96.47 175.74,96.47 175.81,96.4 175.81,95.61 176.52,94.9 176.52,94.59 175.94,94.01 ; 2 cut-outs
5V_FAN_VCC on TOP: 215.82,64.72 214.93,65.61 214.93,66.88 215.18,67.13 218.74,67.13 219.25,66.63 219.25,64.85 219.12,64.72 ; 2 cut-outs
5V_FAN_VCC on BOTTOM: 215.41,65.69 215.31,65.79 215.31,66.37 215.69,66.75 216.48,66.75 218.79,69.07 221.74,69.07 221.99,69.32 222.52,69.32 222.63,69.22 222.63,68.23 222.52,68.13 219.17,68.13 219.04,68 219.04,66.58 219.12,66.5 219.12,65.86 218.94,65.69
5V_HDD_S0 on TOP: 186.86,11.13 186.73,11.25 186.73,13.54 186.23,14.05 186.23,14.94 186.48,15.19 187.62,15.19 188,14.81 188,14.05 188.26,13.79 188.26,11.38 188,11.13 ; 2 cut-outs
5V_HDD_S0 on BOTTOM: 186.35,12.65 186.23,12.78 186.23,15.57 186.35,15.7 187.24,15.7 187.5,15.45 187.5,14.61 187.7,14.4 187.9,14.4 188.03,14.28 188.03,13.82 187.94,13.73 187.56,13.73 187.5,13.67 187.5,12.78 187.37,12.65
5V_HDMI on BOTTOM: 13.96,68.4 12.9,69.47 12.9,69.52 11.25,71.17 10.31,71.17 10.08,71.4 10.08,72.57 10.2,72.7 10.94,72.7 11.39,72.25 13.24,72.25 13.89,71.61 14.37,71.61 14.38,71.59 14.69,71.59 14.85,71.43 14.85,69.34 14.45,68.94 14.45,68.61 14.24,68.4 ; 2 cut-outs
5V_S0 on TOP: 16.05,23.14 15.92,23.27 15.92,24.36 16.22,24.67 17.44,24.67 17.67,24.44 17.67,23.65 17.16,23.14 ; 1 cut-out
5V_S0 on TOP: 183.36,10.47 183.23,10.59 183.23,13.77 183.59,14.13 185.82,14.13 186.3,13.64 186.3,10.65 186.13,10.47 ; 4 cut-outs
5V_S0 on TOP: 207.92,47.75 207.91,47.77 207.09,47.77 206.8,48.06 206.8,48.54 207.05,48.8 208.81,48.8 209.82,49.81 210.51,49.81 210.92,49.41 210.92,48.47 210.84,48.39 210.05,48.39 209.42,47.75 ; 1 cut-out
5V_S0 on BOTTOM: 15.67,66.7 15.13,67.24 15.13,70.94 15.41,71.22 15.41,71.55 15.51,71.66 16.25,71.66 16.43,71.48 16.43,71.12 16.78,70.77 16.78,68.66 17.04,68.4 17.88,68.4 18.08,68.2 18.08,67.21 17.57,66.7 ; 1 cut-out
5V_S0 on BOTTOM: 29.36,8.11 29.23,8.23 29.23,11.66 29.31,11.74 30.6,11.74 30.68,11.81 33.8,11.81 34,11.61 34,10.09 33.65,9.73 31.85,9.73 30.22,8.11
5V_S0 on BOTTOM: 184.02,11.1 183.61,11.51 183.61,16.61 183.79,16.79 184.47,16.79 184.86,16.41 184.86,14.23 185.46,13.62 185.46,11.33 185.24,11.1 ; 2 cut-outs
5V_S0 on L2GND: 62.35,5.1 60.88,6.57 56.89,6.57 55.64,5.32 51.79,5.32 48.46,8.65 38.35,8.65 37.87,9.13 36.62,9.13 36.36,8.88 35.28,8.88 34.54,9.62 32.64,9.62 32.19,10.06 32.19,11.43 32.31,11.55 48.68,11.55 49.11,11.12 52.11,11.12 53.38,9.85 61.97,9.85 62.33,10.2 80.53,10.2 80.92,9.82 87.8,9.82 88.92,8.7 94.36,8.7 97.13,11.47 113.05,11.47 114.47,12.89 118.11,12.89 121.97,16.75 148.02,16.75 149.75,15.03 153.13,15.03 154.4,16.3 164,16.3 164.67,16.96 182.85,16.96 185.2,14.61 185.2,10.27 184.8,9.87 181.56,9.87 180.64,10.79 172.74,10.79 172.38,10.43 167.59,10.43 165.63,12.39 164.51,12.39 163.85,11.72 162.33,11.72 161.57,12.49 160.6,12.49 160.44,12.33 150.39,12.33 149.2,13.53 144.09,13.53 143.66,13.96 139.46,13.96 138.78,13.27 135.1,13.27 134.34,14.04 128.26,14.04 122.7,8.47 114.47,8.47 114.27,8.27 113.28,8.27 113.03,8.52 100.3,8.52 98.26,6.49 97.37,6.49 96.23,5.35 93.34,5.35 93.21,5.48 91.15,5.48 90.77,5.1
5V_S0 on L3: 184.19,13.44 184.6,13.44 185.41,12.63 191.23,12.63 194.13,15.52 195.98,15.52 196.74,16.28 199.56,16.28 201.06,14.79 202,14.79 203.85,12.93 203.85,9.95 203.6,9.69 203.13,9.69 201.67,11.15 201.67,12.04 199.92,13.79 197.35,13.79 191.69,8.13 184.68,8.13 183.99,8.82 183.99,13.24
5V_S0 on L4: 18.33,27.56 22.09,27.56 26.46,23.19 26.46,22.56 29.5,19.52 29.52,19.52 30.7,18.34 30.7,17.15 34.31,13.54 34.31,10.11 33.83,9.63 30.7,9.63 30.45,9.88 30.45,11.36 30.86,11.76 30.86,12.22 28.44,14.63 28.44,17.91 25.7,20.65 25.7,21.26 25.1,21.86 20.1,21.86 19.93,22.02 16.55,22.02 16.1,22.48 16.1,25.33
5V_S0 on L6: 217.01,15.75 218.79,15.75 220.01,16.97 220.01,25.63 221.02,26.65 221.02,39.8 219.55,41.28 218.89,41.28 218,40.39 215.26,40.39 213.28,42.37 210.74,42.37 207.44,45.67 207.44,47.55 206.8,48.19 206.8,49.02 207.39,49.61 212.9,49.61 215.18,47.32 219.63,47.32 224.2,42.75 224.2,13.54 221.66,11 216.83,11 214.85,9.02 204.03,9.02 203.14,9.91 203.14,11.59 203.88,12.32 213.58,12.32
5V_S5 on TOP: 66.77,94.36 66.15,94.99 66.15,98.02 66.14,98.02 65.75,98.4 65.75,99.47 66.21,99.93 68.45,99.93 68.71,99.66 68.71,99.46 69.92,98.25 69.92,97.18 70.17,96.93 71.06,96.93 72.13,98 73.83,98 74.24,98.4 74.62,98.4 74.7,98.33 74.7,96.65 72.43,94.38 71.91,94.38 71.9,94.38 71.36,94.38 71.34,94.36 ; 5 cut-outs
5V_S5 on TOP: 21.25,30.56 21.13,30.69 21.13,31.19 21.25,31.32 23.26,31.32 23.36,31.22 23.36,30.64 23.29,30.56
5V_S5 on TOP: 89.2,103.79 89.1,103.89 89.1,104.47 89.22,104.6 90.6,104.6 91.08,105.08 91.08,105.31 90.98,105.41 90.34,105.41 90.27,105.49 90.27,106.38 90.34,106.45 91.64,106.45 92.02,106.07 92.02,104.75 91.05,103.79
5V_S5 on TOP: 208.55,44.63 208.4,44.78 208.4,46.15 208.64,46.4 209.63,46.4 209.87,46.64 209.87,46.94 209.95,47.02 210.86,47.02 210.92,46.97 210.92,46.38 210.64,46.1 210.64,44.76 210.51,44.63 ; 2 cut-outs
5V_S5 on BOTTOM: 33.83,98.78 33.47,99.14 33.47,100.15 33.67,100.36 61.97,100.36 62.88,101.27 65.37,101.27 65.59,101.06 67.98,101.06 68.4,100.64 68.4,99.37 68.24,99.22 66.11,99.22 65.6,99.72 63.65,99.72 62.71,98.78 ; 2 cut-outs
5V_S5 on BOTTOM: 14.98,53.93 14.78,54.13 14.78,55.91 14.98,56.11 15.67,56.11 15.77,56.01 18.54,56.01 18.69,55.86 18.69,54.89 17.72,53.93 ; 3 cut-outs
5V_S5 on BOTTOM: 21.76,30.1 21.28,30.58 20.8,30.58 20.72,30.66 20.72,31.24 20.75,31.27 22.24,31.27 22.35,31.17 22.35,30.41 22.04,30.1
5V_S5 on BOTTOM: 187.78,15.55 187.57,15.75 187.57,17.38 187.75,17.55 189.5,17.55 189.77,17.29 189.77,16.22 189.1,15.55
5V_S5 on BOTTOM: 16.15,90.55 15.87,90.83 15.87,91.8 15.31,92.36 15.31,92.92 15.46,93.07 15.64,93.07 16.12,93.55 17.57,93.55 17.7,93.42 17.7,90.91 17.34,90.55
5V_S5 on BOTTOM: 70.91,95.46 70.78,95.58 70.78,96.09 71.16,96.47 71.16,96.98 71.18,96.99 71.18,98.9 73.76,101.48 73.76,102.26 73.91,102.42 75.15,102.42 75.86,101.7 75.86,100.66 75.74,100.54 74.8,100.54 74.1,99.84 72.88,99.84 72.05,99.01 72.05,97.11 72.21,96.95 72.21,95.81 71.85,95.46
5V_S5 on BOTTOM: 15.74,32.41 15.62,32.54 15.62,33.33 17.65,35.36 17.65,36.02 17.7,36.07 18.26,36.07 18.31,36.02 18.31,33.89 17.95,33.53 17.19,33.53 16.96,33.3 16.5,33.3 16.43,33.23 16.43,32.51 16.33,32.41 ; 1 cut-out
5V_S5 on BOTTOM: 36.98,2.31 36.77,2.52 36.77,8.69 37,8.92 38.42,8.92 38.68,8.66 38.68,2.64 38.35,2.31 ; 2 cut-outs
5V_S5 on L2GND: 17.29,50.92 14.76,53.45 14.76,55.93 15.03,56.2 17.9,56.2 19.47,54.63 22.35,54.63 28.73,61.01 28.73,61.75 29.26,62.27 32.38,62.27 34.73,64.62 34.73,70.99 37.17,73.43 37.17,80.09 36.25,81.01 36.25,84.68 36.76,85.19 36.76,94.7 34.85,96.61 28.12,96.61 28.12,99.62 28.6,100.09 37.13,100.09 40.65,96.57 40.65,90.75 41.87,89.53 41.87,84.79 41.31,84.23 41.31,82.58 41.59,82.3 41.59,76.53 42.12,76 42.12,75.6 41.59,75.06 41.59,72.47 40.27,71.15 40.27,69.17 38.01,66.91 38.01,62.18 36,60.18 36,57.97 33.44,55.41 30.01,55.41 26.46,51.86 24.6,51.86 24.07,51.32 22.11,51.32 21.71,50.92
5V_S5 on L3: 14.75,91.93 16.2,91.93 16.71,92.43 16.71,93.47 18.94,95.71 21.48,95.71 22.07,95.13 23.21,95.13 25.44,97.36 34.97,97.36 36.24,98.63 36.24,99.98 35.88,100.33 18.79,100.33 14.57,96.12 14.57,92.1
5V_S5 on L3: 209.16,46.23 211.68,46.23 211.83,46.08 211.83,40.41 211.63,40.21 211.63,38.97 212.36,38.23 212.36,30.25 213.84,28.78 213.84,22.53 213.81,22.51 213.81,19.13 215.11,17.83 215.11,16.16 214.6,15.65 212.41,15.65 210.26,17.81 210.26,25.1 208.05,27.31 208.05,31.09 208.68,31.73 208.68,41.2 208.86,41.38 208.86,43.16 209.29,43.59 209.29,44.55 208.96,44.88 208.96,46.03
5V_S5 on L3: 45.76,1.22 44.75,2.24 37.54,2.24 36.19,3.58 36.19,10.29 36.74,10.84 49,10.84 51.25,8.59 54.68,8.59 55.34,7.93 59.02,7.93 61.54,5.41 70.28,5.41 70.53,5.67 70.53,6.1 70.73,6.3 83,6.3 84.02,7.32 84.04,7.32 85.08,8.36 92.35,8.36 93.42,9.43 93.42,10.72 92.88,11.25 82.82,11.25 82.8,11.28 80.66,11.28 80.08,11.86 77.64,11.86 74.21,15.29 72.51,15.29 72.36,15.45 72.36,15.9 72.46,16 74.54,16 76.6,13.95 87.7,13.95 89.12,15.37 94.28,15.37 94.53,15.12 105.12,15.12 109.14,19.13 174.67,19.13 176.6,17.2 177.79,17.2 179.04,18.44 180.16,18.44 180.84,19.13 184.02,19.13 184.73,18.42 189.07,18.42 189.53,17.96 190.42,17.96 190.9,17.48 190.9,13.76 190.11,12.97 185.25,12.97 184.96,13.26 184.96,13.49 184.78,13.67 183.51,13.67 183.1,13.26 116.83,13.26 112.8,9.22 106.85,9.22 98.85,1.22
5V_S5 on L4: 15.18,29.8 13.89,29.8 13.33,30.36 13.33,32.54 16.22,35.44 16.25,35.44 16.3,35.49 17.19,35.49 18.61,34.06 18.61,33.23
5V_S5 on L4: 33.93,100.05 59.63,100.05 59.99,99.7 61.26,99.7 62.2,100.64 67.58,100.64 68.4,99.82 68.4,99.34 68.02,98.96 65.42,98.96 65.02,98.55 63.67,98.55 63.29,98.17 49.73,98.17 49.71,98.19 35.64,98.19 35.27,98.55 34.39,98.55 33.62,99.32 33.62,99.75
5V_S5 on L4: 91.56,106.17 92.63,106.17 92.73,106.07 92.73,104.02 92.53,103.81 91.82,103.81 91.33,104.3 91.33,105.95
5V_S5 on L5VCC: outline of 96 points within 14.87,1.82 38.92,100.14 ; 1 cut-out
5V_S5 on L6: 16,56.06 16.55,55.5 16.55,55.3 16.94,54.92 16.94,46.38 17.57,45.75 17.57,41.73 17.14,41.3 17.14,37.95 16.78,37.59 16.78,35.92 18.16,34.55 18.16,33.2 17.44,32.49 15.21,32.49 14.27,33.43 14.27,40.29 15.46,41.48 15.46,43.16 14.83,43.79 14.83,47.68 15.08,47.93 15.08,49.69 14.47,50.29 14.47,55.83 14.7,56.06
5V_S5 on L6: 195.62,18.72 214.62,18.72 215.06,18.29 215.06,16.21 214.24,15.4 205.84,15.4 204.49,16.74 194.71,16.74 194.1,17.35 191.05,17.35 189.27,15.57 188.13,15.57 187.62,16.08 187.62,16.72 189.66,18.75 190.16,18.75 190.93,19.51 194.86,19.51 194.86,19.48
5V_S5 on L7GND: 36.8,2.07 36.28,2.6 36.28,9.71 29.8,16.19 29.8,17.88 27.36,20.32 27.36,20.38 27.16,20.58 27.16,23.17 22.92,27.41 22.92,29.64 22.96,29.68 24.22,29.68 24.37,29.54 24.37,28.19 26.51,26.05 28.13,26.05 29.39,24.79 29.39,22.91 31.43,20.88 31.43,18.89 32.1,18.21 32.85,18.21 38.77,12.29 38.77,2.37 38.47,2.07
5V_USB2_S0 on TOP: 209.14,11.84 204.44,16.54 201.92,16.54 201.67,16.79 197.53,16.79 197.38,16.94 194.86,16.94 193.39,15.47 191.21,15.47 190.98,15.7 190.98,17.88 192.15,19.05 202.58,19.05 202.94,18.7 205.66,18.7 209.7,14.66 211.55,14.66 212.69,13.52 212.69,12.3 212.24,11.84
5V_USB2_S0 on TOP: 218.28,38.56 218.13,38.71 218.13,40.19 218.14,40.2 218.14,40.66 218.66,41.18 220.42,41.18 221.1,40.49 221.86,40.49 222.12,40.24 222.12,38.69 221.99,38.56 ; 5 cut-outs
5V_USB2_S0 on BOTTOM: 191.54,15.42 191.28,15.67 191.28,16.36 191.21,16.44 190.27,16.44 190.11,16.59 190.11,17.71 190.34,17.94 191.71,17.94 191.92,17.73 191.92,15.52 191.81,15.42
5V_USB2_S0 on BOTTOM: 218.87,39.4 218.61,39.65 218.61,40.06 218.56,40.11 217.55,40.11 217.47,40.19 217.47,40.36 217.49,40.39 218.36,40.39 218.41,40.44 218.41,40.59 218.38,40.62 217.49,40.62 217.47,40.64 217.47,40.87 217.49,40.9 218.38,40.9 218.41,40.92 218.41,41.07 218.38,41.1 217.49,41.1 217.47,41.13 217.47,41.33 217.52,41.38 219.6,41.38 219.73,41.25 219.73,39.53 219.6,39.4
5V_USB2_S0 on L2GND: 210.03,10.58 209.84,10.78 209.84,13.74 210.46,14.37 216.02,14.37 218.5,16.84 218.5,23.55 218.8,23.85 218.8,25 216.57,27.23 216.57,28.98 217.79,30.2 217.79,40.82 218.23,41.27 221.66,41.27 223.63,39.29 223.63,22.81 222.41,21.6 222.41,13.52 219.47,10.58
5V_USB30_VCCA on TOP: 11.58,47.6 11.42,47.75 11.42,49.38 11.81,49.76 18.05,49.76 18.38,49.43 18.38,47.7 18.28,47.6
5V_USB30_VCCA on BOTTOM: 14.01,47.83 13.89,47.96 12.26,47.96 11.58,48.64 11.58,50.47 11.83,50.73 12.21,50.73 12.62,51.13 15.44,51.13 15.69,50.88 19.6,50.88 19.98,51.26 19.98,51.64 20.77,52.43 20.77,53.93 20.57,54.13 19.43,54.13 19.35,54.21 19.35,54.82 19.48,54.94 21.28,54.94 21.56,54.66 21.56,51.89 20.97,51.31 20.97,47.98 20.95,47.96 17.44,47.96 17.32,47.83 ; 7 cut-outs
5V_USB30_VCCB on TOP: 11.98,28.1 11.5,28.58 11.5,30.23 11.91,30.64 14.62,30.64 14.93,30.33 16.48,30.33 16.66,30.51 16.66,32.77 15.95,33.48 15.36,33.48 15.23,33.61 15.23,34.19 15.72,34.67 15.72,37.47 17.06,38.81 17.65,38.81 18.49,37.98 18.97,37.98 20.67,36.27 21.51,36.27 22.07,35.72 22.07,33.78 21.97,33.68 20.95,33.68 20.72,33.91 20.72,34.95 20.11,35.56 17.6,35.56 17.01,34.98 17.01,34.34 18.26,33.1 18.26,28.73 18.13,28.6 17.7,28.6 17.49,28.4 15.67,28.4 15.36,28.1 ; 5 cut-outs
5V_USB30_VCCB on BOTTOM: 21.86,48.03 21.71,48.19 21.71,51.49 21.79,51.56 23.92,51.56 24.02,51.46 24.15,51.46 24.43,51.18 24.43,48.47 24,48.03
5V_USB30_VCCB on BOTTOM: 17.32,26.37 16.94,26.75 14.78,26.75 13.89,27.64 13.89,29.57 14.01,29.7 14.98,29.7 15.13,29.54 17.93,29.54 18.21,29.26 18.21,28.27 18.51,27.97 19.15,27.97 19.45,28.27 22.68,28.27 22.88,28.07 23.46,28.07 23.62,28.22 23.62,29.42 24,29.8 25.67,29.8 26.03,29.44 26.03,26.67 25.72,26.37 ; 4 cut-outs
5V_USB30_VCCB on BOTTOM: 20.87,33.48 20.75,33.61 20.75,34.62 20.62,34.75 20.62,35.26 20.87,35.51 21.89,35.51 21.99,35.41 21.99,33.61 21.86,33.48 ; 1 cut-out
5V_USB30_VCCB on L3: 23.29,50.12 24.43,50.12 25.13,49.42 25.13,42.57 25.57,42.13 25.57,35.92 25.98,35.51 25.98,32.82 26.23,32.57 26.23,28.83 26.22,28.82 26.22,28.62 25.85,28.25 25.14,28.25 23.34,30.05 23.34,39.5 23.74,39.91 23.74,42.24 23.03,42.95 23.03,49.86
20V_DCBATOUT on TOP: 145.46,5.16 145.21,5.41 145.21,8.51 145.23,8.54 148.94,8.54 149.35,8.94 149.35,10.7 149.4,10.75 153.08,10.75 153.16,10.67 153.16,7.24 152.85,6.94 151.63,6.94 151.53,7.04 150.39,7.04 150.16,6.81 150.16,5.92 150.03,5.79 147.85,5.79 147.7,5.64 147.7,5.21 147.64,5.16 ; 3 cut-outs
20V_DCBATOUT on BOTTOM: 150.92,6.3 150.87,6.35 150.87,7.24 150.54,7.57 148.89,7.57 148.38,7.06 147.87,7.06 147.75,7.19 147.75,7.95 147.87,8.08 148.51,8.08 149.04,8.61 149.04,11.38 149.3,11.64 150.9,11.64 151.02,11.51 151.02,10.54 151.15,10.42 152.06,10.42 152.19,10.29 152.19,8.82 152.39,8.61 152.85,8.61 152.95,8.51 152.95,7.95 153.08,7.83 153.08,6.56 152.83,6.3 ; 1 cut-out
20V_VCCPD_VBUS on TOP: 7.79,86.08 7.13,86.74 5.76,86.74 5.56,86.95 5.56,88.12 5.68,88.24 6.17,88.24 6.39,88.47 6.39,89.77 6.22,89.94 5.73,89.94 5.58,90.1 5.58,90.96 5.91,91.29 6.88,91.29 8,92.41 11.35,92.41 11.5,92.26 12.08,92.26 12.19,92.36 13.2,92.36 13.53,92.03 13.53,90.83 13.33,90.63 12.54,90.63 12.08,91.09 11.88,91.09 11.5,90.71 8.76,90.71 7.94,89.89 7.94,87.61 8.22,87.33 8.81,87.33 9.37,86.77 9.37,86.49 8.96,86.08 ; 2 cut-outs
20V_VCCPD_VBUS on BOTTOM: 12.26,85.42 12.01,85.68 10.81,85.68 10.61,85.88 9.11,85.88 8.1,86.9 8.1,87.18 8.15,87.23 9.29,87.23 9.67,86.85 11.25,86.85 11.47,86.62 12.14,86.62 12.41,86.34 13.25,86.34 13.38,86.21 13.38,85.52 13.28,85.42 ; 1 cut-out
20V_VCCPD_VBUS on BOTTOM: 61.69,96.14 33.5,96.14 33.48,96.15 31.4,96.15 31.19,96.37 31.19,98.2 31.59,98.61 62.86,98.61 63.77,99.52 65.65,99.52 66.14,99.04 68.19,99.04 68.24,98.99 68.24,95.61 68.55,95.3 69.92,95.3 70.28,94.95 70.28,93.93 70.02,93.68 67.18,93.68 66.03,94.82 66.03,96.57 65.81,96.8 62.35,96.8
20V_VCCPD_VBUS on BOTTOM: 10.87,90.96 10.71,91.11 10.71,92.23 10.84,92.36 11.32,92.36 11.5,92.18 11.83,92.18 12.47,92.81 14.07,92.81 14.17,92.71 14.17,91.82 13.94,91.6 12.24,91.6 11.6,90.96 ; 1 cut-out
20V_VCCPD_VBUS on BOTTOM: 17.63,84.65 17.42,84.86 17.42,86.03 17.6,86.21 19.32,86.21 20.01,85.52 20.01,85.12 20.09,85.04 21.41,85.04 21.48,84.97 21.48,84.76 21.41,84.69 19.17,84.69 19.13,84.65
20V_VCCPD_VBUS on L4: 15.35,83.58 13.1,85.83 13.1,90.17 12.24,91.04 11.25,91.04 10.52,90.31 8.95,90.31 8.66,90.02 7.97,90.02 7.84,89.89 7.84,87.76 8.25,87.35 9.21,87.35 9.62,86.95 9.62,86.26 9.34,85.98 7.66,85.98 6.88,86.77 5.68,86.77 5.48,86.97 5.48,88.06 5.63,88.22 6.24,88.22 6.42,88.39 6.42,89.56 6.14,89.84 5.66,89.84 5.51,89.99 5.51,91.06 5.68,91.24 6.88,91.24 13.15,97.51 13.94,97.51 13.98,97.48 15.35,97.48 18.08,100.21 31.46,100.21 33.7,97.97 33.7,97.56 33.22,97.08 26.99,97.08 26.56,96.65 19.25,96.65 16.96,94.36 16.96,90.15 18.59,88.52 18.59,86.62 19.4,85.8 19.4,84.36 18.63,83.58
20V_VCCPD_VBUS on L6: 5.73,88.14 7.26,88.14 8.07,87.33 8.93,87.33 9.14,87.12 10.76,87.12 11.17,87.53 14.78,87.53 15.59,86.72 18.56,86.72 19.27,86.01 19.27,84.31 18.54,83.57 11.7,83.57 11.4,83.87 9.57,83.87 9.14,84.31 9.14,85.45 8.55,86.03 8.12,86.03 7.5,86.65 6.76,86.65 6.17,87.25 5.86,87.25 5.53,87.58 5.53,87.94
20V_VCCPD_VBUS_L on TOP: 74.34,100.13 73.07,101.4 72.69,101.4 72.16,101.93 71.72,101.93 71.62,102.03 71.62,103 71.72,103.1 73.3,103.1 73.79,102.61 73.79,102.25 74.44,101.6 74.44,101.55 75.15,100.84 75.15,100.38 74.9,100.13 ; 1 cut-out
20V_VCCPD_VBUS_L on BOTTOM: 68.88,95.51 68.6,95.79 68.6,100.38 70.68,102.47 73.5,102.47 73.7,102.26 73.7,101.6 70.91,98.81 70.91,96.47 69.95,95.51
+3V_1D8V_DVDD on TOP: 28.09,16.33 27.65,16.77 27.25,16.77 27.17,16.84 27.17,17.1 28.24,18.16 28.24,19.66 28.34,19.76 29.43,19.76 29.51,19.69 29.51,16.54 29.31,16.33 ; 2 cut-outs
+3V_1D8V_DVDD on BOTTOM: 27.05,14.07 26.46,14.66 26.46,17.07 26.69,17.3 27.55,17.3 27.73,17.48 27.73,17.76 27.98,18.01 29.1,18.01 29.38,17.73 29.38,15.8 29.31,15.73 28.7,15.73 28.59,15.62 28.59,15.27 28.47,15.14 28.29,15.14 27.22,14.07 ; 6 cut-outs
+5V_AVDD on TOP: 21.53,18.09 19.72,19.9 18.73,19.9 18.41,20.22 17.16,20.22 16.12,21.26 16.12,22.53 16.25,22.66 17.11,22.66 17.19,22.58 17.19,21.72 17.75,21.16 18.82,21.16 19.09,20.88 19.96,20.88 20.06,20.78 20.06,20.55 21.81,18.8 22.22,18.8 22.27,18.75 22.27,18.14 22.22,18.09 ; 1 cut-out
+5V_KB_BL on BOTTOM: 96.21,10.44 96.13,10.52 96.13,13.01 96.87,13.74 96.87,14.13 97.1,14.35 99.99,14.35 100.15,14.2 100.15,12.96 99.87,12.68 97.3,12.68 96.62,11.99 96.62,10.52 96.54,10.44 ; 2 cut-outs
+5V_PVDD on BOTTOM: 27.73,8.11 27.6,8.23 27.6,8.56 27.45,8.71 26.26,8.71 26.11,8.87 26.11,10.47 27.43,11.79 27.43,12.42 27.73,12.73 27.76,12.73 28.04,13.01 29.86,13.01 29.97,12.91 29.97,12.02 29.84,11.89 29.03,11.89 28.67,11.53 28.67,8.21 28.57,8.11
+5V_PVDD1 on TOP: 23.24,8.79 21.38,10.65 21.38,12.27 21.63,12.52 22.4,12.52 22.78,12.91 23.29,12.91 23.54,12.65 23.54,12.02 23.29,11.76 23.16,11.76 23.03,11.64 22.78,11.64 22.65,11.51 22.65,11.15 22.78,11.03 23.13,11.03 23.24,11.13 24.38,11.13 24.58,10.92 24.58,10.09 24.84,9.83 24.84,8.89 24.73,8.79 ; 2 cut-outs
+5V_PVDD1 on BOTTOM: 23.36,8.82 23.18,8.99 23.18,10.72 23.39,10.92 25.29,10.92 25.55,10.67 25.55,8.92 25.44,8.82
+5V_PVDD1 on BOTTOM: 23.01,11.99 22.75,12.25 22.75,12.68 22.85,12.78 24.68,12.78 25.01,13.11 25.01,13.9 25.11,14 25.55,14 25.81,14.26 25.81,14.57 25.95,14.71 26.26,14.71 26.76,14.21 26.76,14.07 27.05,13.77 27.43,13.77 27.43,13.8 28.32,14.68 29.97,14.68 30.11,14.54 30.11,13.69 29.96,13.54 28.21,13.54 28.17,13.5 28.17,13.25 27.5,12.58 26.36,12.58 26.05,12.27 23.72,12.27 23.44,11.99 ; 3 cut-outs
+5V_PVDD1 on L3: 23.41,13.29 25.8,13.29 25.93,13.41 26.82,13.41 27.05,13.19 27.05,12.8 26.54,12.3 26.54,10.06 26.52,10.05 26.52,9.57 25.8,8.84 23.36,8.84 22.88,9.32 22.88,10.59 23.03,10.75 23.03,11.71 22.73,12.02 22.73,12.45 23.31,13.03 23.31,13.19
GND on TOP: 38.4,64.24 38.16,64.48 38.16,65.12 38.32,65.28 38.32,66.58 39.9,68.15 40.68,68.15 40.94,67.9 40.94,66.88 41.19,66.63 42.46,66.63 42.59,66.5 42.59,65.99 42.46,65.86 41.17,65.86 40.99,65.69 40.99,64.57 40.66,64.24 ; 8 cut-outs
GND on TOP: 185.21,57.36 185.08,57.48 185.08,58.24 186.48,59.64 187.5,59.64 188.39,58.75 189.48,58.75 189.61,58.63 189.61,57.86 189.48,57.74 187.37,57.74 187.12,57.48 185.85,57.48 185.72,57.36 ; 3 cut-outs
GND on TOP: 37.28,89.66 36.8,90.15 35.83,90.15 35.5,90.48 35.5,92.71 35.63,92.84 36.62,92.84 36.75,92.71 36.75,90.96 36.9,90.81 38.91,90.81 40.02,91.93 40.56,91.93 40.79,91.7 40.79,89.94 40.51,89.66 ; 4 cut-outs
GND on TOP: 198.83,45.98 198.29,46.51 197.96,46.51 197.91,46.56 196.74,46.56 196.69,46.61 195.42,46.61 195.37,46.66 195.37,46.97 195.32,47.02 193.57,47.02 193.36,47.22 193.36,47.48 193.47,47.58 193.75,47.58 194.05,47.27 195.29,47.27 195.37,47.35 195.37,47.63 195.42,47.68 196.39,47.68 196.44,47.63 196.44,47.32 196.49,47.27 197.81,47.27 197.91,47.37 197.91,47.6 198.93,48.62 200.96,48.62 200.96,48.59 201.21,48.34 201.21,46.81 201.39,46.64 201.39,46.1 201.26,45.98 ; 3 cut-outs
GND on TOP: 176.22,83.64 175.99,83.87 175.99,84.31 177.72,86.03 177.84,86.03 178.09,85.79 178.09,85.69 178.1,85.68 177.73,85.31 177.73,85.04 177.97,84.8 177.97,84.53 177.08,83.64 ; 1 cut-out
GND on TOP: 175.18,18.42 174.57,19.03 172,19.03 171.8,19.23 164.14,19.23 163.9,19.47 154.69,19.47 154.5,19.66 154.5,20.37 154.65,20.53 155.87,20.53 156.25,20.14 165.09,20.14 165.42,19.81 171.77,19.81 172.38,20.42 172.38,26.37 172.54,26.52 173.86,26.52 174.8,25.58 174.8,25.53 175.03,25.3 177.62,25.3 177.9,25.58 177.9,28.2 177.54,28.55 177.54,29.34 177.29,29.59 172.74,29.59 172.08,28.93 170.58,28.93 169.56,29.95 138.65,29.95 138.47,30.13 138.47,31.24 138.7,31.47 171.6,31.47 172.33,30.74 177.31,30.74 178.53,29.52 178.53,26.22 180.31,24.44 180.31,21.08 179.7,20.48 179.7,20.02 179.52,19.84 178.66,19.84 178.48,20.02 178.48,20.88 179.34,20.88 179.85,21.39 179.85,22.13 177.46,24.51 176.55,24.51 175.51,23.47 175,23.47 174.8,23.27 174.8,21.75 174.97,21.57 174.97,19.51 175.43,19.05 175.66,19.05 175.74,18.98 175.74,18.49 175.66,18.42 ; 28 cut-outs
GND on TOP: 20.29,93.14 19.91,93.53 19.91,95.35 20.01,95.46 22.73,95.46 22.9,95.28 22.9,93.4 22.65,93.14
GND on TOP: 52.88,66.12 52.75,66.25 52.75,69.29 52.57,69.47 52.57,72.65 52.39,72.82 51.18,72.82 51.07,72.93 51.07,74.17 51.15,74.25 52.01,74.25 52.83,73.43 53.49,73.43 53.56,73.51 53.56,74.17 53.64,74.25 54.5,74.25 54.58,74.17 54.58,70.59 55.75,69.42 55.75,67.34 54.53,66.12 ; 4 cut-outs
GND on TOP: 60.83,55.07 60.52,55.37 60.52,56.49 60.75,56.72 69.69,56.72 71.57,58.6 71.57,61.85 75.36,65.64 78.33,65.64 80.56,63.4 80.56,58.55 77.08,55.07 ; 2 cut-outs
GND on TOP: 177.72,89.74 176.83,90.63 176.45,90.63 175.81,91.26 175.81,91.77 176.32,92.28 176.45,92.28 177.21,91.52 177.59,91.52 178.48,92.41 178.48,92.66 178.73,92.92 178.99,92.92 180.37,94.3 180.37,95.06 181.1,95.79 181.58,95.79 181.93,95.43 181.93,95.13 180.72,93.91 180.72,93.58 180.44,93.3 180.44,93.04 178.25,90.86 178.25,90.38 178.33,90.3 178.33,90.22 177.84,89.74 ; 3 cut-outs
GND on TOP: 120.21,74.75 120.14,74.83 120.14,75.26 120.29,75.42 122.47,75.42 122.65,75.59 122.65,76.2 122.78,76.33 124.4,76.33 124.63,76.1 124.63,75.09 124.3,74.75 ; 4 cut-outs
GND on TOP: 15.51,30.53 15.45,30.6 15.45,30.98 15.26,31.17 14.01,31.17 13.89,31.3 13.89,33.99 14.22,34.32 14.95,34.32 15.06,34.22 15.06,32.91 15.31,32.65 16.16,32.65 16.2,32.62 16.2,30.61 16.12,30.53 ; 2 cut-outs
GND on TOP: 218.15,46.28 218.03,46.41 218.03,46.97 219.2,48.14 222.35,48.14 222.52,47.96 222.52,46.41 222.4,46.28 ; 2 cut-outs
GND on TOP: 126.79,15.32 126.66,15.45 126.66,17.53 127.02,17.88 133.29,17.88 133.88,18.47 134.77,18.47 134.84,18.39 134.84,17.66 134.94,17.55 135.4,17.55 135.43,17.53 135.43,17 135.55,16.87 136.54,16.87 136.7,16.72 136.7,15.6 136.62,15.52 136.62,15.45 136.19,15.45 136.06,15.32 ; 9 cut-outs
GND on TOP: 70.1,98.38 69.03,99.44 69.03,101.12 69.54,101.63 69.54,102.87 69.77,103.1 70.81,103.1 70.97,102.94 70.97,99.91 70.99,99.9 70.99,98.48 70.89,98.38 ; 4 cut-outs
GND on TOP: 39.16,8.33 39.03,8.46 39.03,9.91 39.95,10.82 39.95,11.28 40.18,11.51 44.11,11.51 44.24,11.38 44.24,8.84 43.73,8.33 ; 8 cut-outs
GND on TOP: 185.19,94.19 184.93,94.44 184.93,94.69 185.67,95.43 185.67,96.02 186.51,96.85 186.97,96.85 187.73,96.09 187.73,95.84 186.97,95.07 186.46,95.07 185.57,94.19 ; 2 cut-outs
GND on TOP: outline of 484 points within 0.51,0.51 224.8,109.49 ; 60 cut-outs
GND on TOP: 175.28,70.79 171.57,74.5 169.67,74.5 167.49,76.67 167.49,76.71 166.87,77.33 166.87,78.06 168.02,79.2 168.75,79.2 174.75,73.21 175.08,73.21 175.51,73.64 176.3,73.64 178.43,71.5 178.43,71.2 178.02,70.79 ; 9 cut-outs
GND on TOP: 186.05,78.64 185.44,79.25 185.44,79.38 186.07,80.01 186.23,80.01 187.22,81 187.57,81 189.12,79.45 189.12,79.2 188.87,78.95 188.49,78.95 188.36,79.07 188.36,79.58 188.24,79.71 187.85,79.71 186.79,78.64 ; 2 cut-outs
GND on TOP: 104.62,96.45 104.41,96.65 104.41,97.34 104.54,97.46 109.26,97.46 109.49,97.23 109.49,96.6 109.34,96.45
GND on TOP: 95.19,69.45 95.04,69.6 95.04,70.28 95.22,70.46 98.6,70.46 98.83,70.69 98.83,73.76 98.6,73.99 91.38,73.99 90.95,73.56 90.21,73.56 90.14,73.64 90.14,76.46 90.42,76.74 95.96,76.74 96.06,76.63 96.06,76.08 96.29,75.85 98.72,75.85 99,75.57 99,74.98 99.87,74.12 100.43,74.12 100.53,74.02 100.53,70.46 100.68,70.31 100.68,69.6 100.53,69.45 ; 17 cut-outs
GND on TOP: 127.45,68.58 127.07,68.96 127.07,69.76 127.52,70.21 128.18,70.21 128.57,70.6 129.01,70.6 129.15,70.46 129.15,70.04 128.76,69.65 128.76,68.85 128.49,68.58 ; 2 cut-outs
GND on TOP: 54.07,17.99 53.97,18.09 53.97,19.26 54.1,19.38 56.31,19.38 56.81,19.89 63.06,19.89 63.21,19.74 63.21,18.39 62.94,18.11 57.83,18.11 57.42,18.52 55.85,18.52 55.49,18.16 54.63,18.16 54.45,17.99 ; 12 cut-outs
GND on TOP: 147.44,52.61 145.28,54.77 145.28,61.67 145.38,61.78 147.52,61.78 148.15,61.14 148.15,55.96 148.61,55.5 148.61,53.39 148.56,53.34 148.15,53.34 148.03,53.22 148.03,52.68 147.95,52.61 ; 10 cut-outs
GND on TOP: 90.9,10.77 90.29,11.38 90.29,14.63 90.42,14.76 91.41,14.76 91.64,14.53 92.25,14.53 92.37,14.4 92.37,13.77 92.25,13.64 91.87,13.64 91.69,13.46 91.69,11.92 92.2,11.41 93.36,11.41 93.67,11.71 95.68,11.71 95.9,11.48 95.9,11.23 95.45,10.77 ; 4 cut-outs
GND on TOP: 20.95,29.03 20.57,29.42 20.57,30.1 20.77,30.3 23.16,30.3 23.29,30.18 23.29,29.92 22.4,29.03 ; 2 cut-outs
GND on TOP: 43.28,54.26 43.17,54.36 43.17,55.48 44.62,56.92 44.62,58.07 44.72,58.17 46.7,58.17 47.03,58.5 47.44,58.5 47.59,58.65 47.59,59.9 47.7,60 48.25,60 48.36,59.9 48.36,58.52 48.53,58.35 48.53,57.79 48.15,57.41 47.37,57.41 45.66,55.7 44.29,55.7 43.76,55.17 43.76,54.38 43.63,54.26 ; 5 cut-outs
GND on TOP: 155.34,52.33 155.09,52.58 155.09,53.63 155.54,54.09 156.09,54.09 156.25,54.26 156.25,56.44 156.61,56.8 156.99,56.8 157.07,56.87 157.07,58.83 157.14,58.91 157.83,58.91 157.86,58.88 157.86,58.12 157.65,57.91 157.65,56.9 157.42,56.67 157.42,55.83 157.55,55.7 159.79,55.7 159.94,55.86 161.11,55.86 161.23,55.73 161.23,55.43 160.37,54.56 158.21,54.56 156.94,53.29 156.94,52.63 156.64,52.33 ; 8 cut-outs
GND on TOP: 40.91,83.75 40.53,84.13 39.8,84.13 39.62,84.31 39.62,85.83 39.64,85.85 39.64,86.31 39.49,86.46 35.94,86.46 35.66,86.74 35.66,89 35.76,89.11 40.35,89.11 41.93,87.53 41.93,84.15 41.52,83.75 ; 9 cut-outs
GND on TOP: 50.36,16.18 49.83,16.72 39.82,16.72 39.57,16.97 39.57,18.04 39.96,18.43 39.97,18.43 40.04,18.49 44.55,18.49 44.85,18.8 50.54,18.8 51.58,17.76 51.58,16.33 51.43,16.18 ; 10 cut-outs
GND on TOP: 148.58,3.94 148,4.52 148,5.31 148.15,5.46 150.36,5.46 150.69,5.79 150.69,6.78 150.77,6.86 151.43,6.86 151.53,6.76 152.39,6.76 152.67,6.48 152.67,4.45 152.55,4.32 150.13,4.32 149.75,3.94 ; 2 cut-outs
GND on TOP: 92.12,78.9 92.07,78.95 92.07,79.45 92.25,79.63 92.25,80.32 92.32,80.39 92.75,80.39 93.14,80.77 93.64,80.77 93.85,80.57 93.85,79.91 93.34,79.4 93.34,78.95 93.29,78.9 ; 2 cut-outs
GND on TOP: 84.5,70.28 83.51,71.28 79.83,71.28 79.65,71.45 79.65,72.09 79.85,72.29 84.63,72.29 85.13,71.78 88.21,71.78 88.22,71.8 89.75,71.8 89.81,71.73 89.81,70.92 89.63,70.74 89.1,70.74 88.64,70.28 ; 9 cut-outs
GND on TOP: 93.42,43.81 93.31,43.91 93.31,45.47 93.39,45.54 105.86,45.54 108.03,47.72 108.03,50.36 108.15,50.47 110.1,50.47 110.38,50.19 112.34,50.19 112.41,50.12 112.41,49.66 112.34,49.58 110.59,49.58 110.41,49.41 109.98,49.41 109.39,48.82 109.39,45.72 107.47,43.81 ; 16 cut-outs
GND on TOP: 54.71,55.65 54.53,55.83 54.53,59.24 54.02,59.74 53.49,59.74 53.26,59.97 53.26,62.64 53.05,62.84 51.84,62.84 51.76,62.92 51.76,64.16 51.84,64.24 52.83,64.24 52.9,64.16 52.9,63.68 53.18,63.4 54.22,63.4 54.27,63.45 54.27,64.19 54.35,64.26 55.19,64.26 55.26,64.19 55.26,60.45 55.42,60.3 55.42,59.9 56.66,58.65 56.66,56.92 55.39,55.65 ; 4 cut-outs
GND on TOP: 182.19,41.81 179.11,44.88 179.11,47.45 178.61,47.96 178.61,49.61 178.73,49.74 182.54,49.74 182.67,49.86 183.81,49.86 183.94,49.74 183.94,49.23 183.81,49.1 182.29,49.1 181.4,48.21 181.4,46.23 181.06,45.89 181.06,44.92 182.47,43.51 188.94,43.51 189.27,43.18 189.27,42.04 189.05,41.81 ; 8 cut-outs
GND on TOP: 117.79,3.75 117.65,3.89 117.65,5.54 117.14,6.05 117.14,11.51 117.39,11.76 119.04,11.76 119.3,11.51 119.3,11.13 119.04,10.87 119.04,6.05 119.45,5.64 119.45,4.88 119.39,4.82 118.45,4.82 118.28,4.65 118.28,3.94 118.09,3.75 ; 4 cut-outs
GND on TOP: 185.59,87.38 183.56,89.41 183.56,89.49 184.04,89.97 184.22,89.97 184.73,89.46 185.19,89.46 185.36,89.64 185.59,89.64 185.95,89.28 185.95,88.98 186.58,88.34 186.58,88.22 185.75,87.38 ; 2 cut-outs
GND on TOP: 20.11,32.08 19.86,32.34 19.86,33.35 20.11,33.61 21.56,33.61 21.63,33.53 21.63,32.34 21.38,32.08 ; 1 cut-out
GND on TOP: 39.62,1.27 39.41,1.48 39.41,2.24 40.43,3.25 44.75,3.25 45.13,2.87 45.13,1.37 45.03,1.27 ; 4 cut-outs
GND on TOP: 183.99,79.58 183.74,79.83 183.74,81.21 184.5,81.97 184.5,82.58 185.31,83.39 185.31,83.9 184.93,84.28 184.93,84.41 187.35,86.82 187.6,86.82 188.08,87.3 188.08,87.68 187.8,87.96 187.8,88.06 188.03,88.29 188.16,88.29 188.82,87.63 188.82,86.59 190.7,84.71 190.7,84.2 189,82.5 188.41,82.5 188.26,82.35 188.26,81.16 188.18,81.08 187.78,81.08 186.99,81.87 185.95,81.87 184.5,80.42 184.5,79.96 184.12,79.58 ; 7 cut-outs
GND on TOP: 27.63,47.58 27.22,47.98 27.22,48.67 27.35,48.8 28.54,48.8 28.7,48.64 28.7,48.06 28.59,47.96 28.24,47.96 27.86,47.58 ; 1 cut-out
GND on TOP: 118.61,93.58 118.43,93.75 118.43,94.47 118.23,94.67 117.62,94.67 117.16,95.13 117.16,95.25 117.11,95.2 116.5,95.2 116.43,95.28 116.43,95.63 116.66,95.86 118.84,95.86 119.02,96.04 119.04,96.04 119.2,96.19 119.2,97.31 119.32,97.44 119.63,97.44 119.83,97.23 119.83,95.3 120.67,94.47 120.67,93.63 120.62,93.58 ; 2 cut-outs
GND on TOP: 78,105.41 77.81,105.6 77.81,107.08 77.03,107.85 77.03,108.11 77.16,108.23 77.9,108.23 79.37,106.76 79.37,106.33 79.55,106.15 79.98,106.15 80.05,106.07 80.05,105.46 80,105.41 ; 2 cut-outs
GND on TOP: 211.04,52 210.86,52.17 210.86,56.09 211.12,56.34 212.01,56.34 212.26,56.09 212.26,54.18 211.75,53.67 211.75,52.07 211.68,52 ; 2 cut-outs
GND on TOP: 185.87,48.52 185.72,48.67 185.72,49.84 186.63,50.75 192.96,50.75 193.06,50.65 193.06,49.02 192.55,48.52 ; 11 cut-outs
GND on TOP: 124.91,95.33 124.9,95.34 123.68,95.34 123.41,95.61 123.41,96.01 125.04,97.64 125.04,99.37 124.89,99.52 124.05,99.52 123.92,99.65 123.92,100.64 123.91,100.65 123.91,101.16 123.59,101.48 122.75,101.48 122.5,101.73 122.5,102.06 124.15,103.71 124.15,104.88 124.35,105.08 127.83,105.08 128.21,104.7 128.21,100.99 128.54,100.66 133.75,100.66 134.72,101.63 138.96,101.63 139.87,100.71 139.87,98.73 139.36,98.22 128.67,98.22 128.34,97.89 128.34,96.65 128.33,96.64 128.33,95.44 128.21,95.33 ; 12 cut-outs
GND on TOP: 60.42,66.88 60.24,67.06 60.24,67.67 60.65,68.07 60.65,71.4 61.34,72.09 69.01,72.09 69.26,71.83 69.26,70.06 67.86,68.66 67.86,67.26 67.48,66.88 ; 10 cut-outs
GND on TOP: 115.44,50.85 115.21,51.08 115.21,51.59 115.56,51.95 115.56,52.48 115.61,52.53 116.71,52.53 116.81,52.43 116.81,51.03 116.63,50.85
GND on TOP: 134.28,3.46 134.16,3.58 134.16,4.27 134.69,4.8 134.69,6.89 134.79,6.99 134.79,10.24 135.05,10.49 135.81,10.49 136.19,10.11 136.7,10.11 136.95,9.86 136.95,8.33 136.82,8.21 136.19,8.21 135.81,7.83 135.81,6.81 136.32,6.3 137.33,6.3 137.59,6.05 137.59,4.27 136.77,3.46 ; 3 cut-outs
GND on TOP: 110.59,70.49 110.28,70.79 110.28,78.03 110.92,78.67 110.92,79.43 110.99,79.5 111.53,79.5 111.6,79.43 111.6,78.82 111.96,78.46 111.96,76.58 112.11,76.43 113.2,76.43 113.46,76.69 113.46,77.63 114.19,78.36 114.62,78.36 114.75,78.23 114.75,77.98 114.52,77.75 114.52,74.32 114.95,73.89 114.95,73.51 114.88,73.43 114.4,73.43 114.17,73.66 113.25,73.66 113.2,73.61 113.2,73.08 112.16,72.04 112.16,70.56 112.08,70.49 ; 15 cut-outs
GND on TOP: 157.98,64.52 157.58,64.93 157.58,68.18 157.6,68.2 159.2,68.2 162,65.41 162,64.82 161.69,64.52 ; 1 cut-out
GND on TOP: 117.22,76.3 117.11,76.41 117.11,77.09 117.22,77.19 117.62,77.19 117.9,77.47 117.9,77.9 118,78.01 119.17,78.01 119.3,77.88 119.3,77.45 119.2,77.35 118.33,77.35 118.13,77.14 118.13,76.53 117.9,76.3
GND on TOP: 61.72,84.08 61.54,84.25 61.54,86.06 62.53,87.05 62.53,92.79 62.1,93.22 57.65,93.22 57.29,93.59 57.29,96.17 57.8,96.69 62.47,96.69 65.22,93.93 65.22,86.26 65.35,86.13 68.68,86.13 68.88,85.93 68.88,84.41 68.55,84.08 ; 12 cut-outs
GND on TOP: 89,104.8 88.89,104.9 88.89,106.38 89,106.48 89.68,106.48 89.91,106.25 89.91,105.49 90.06,105.34 90.29,105.34 90.42,105.21 90.42,104.96 90.27,104.8 ; 1 cut-out
GND on TOP: 120.67,45.9 120.52,46.05 120.52,46.66 120.62,46.76 120.92,46.76 122.36,48.2 122.36,49.7 122.47,49.81 122.98,49.81 123.06,49.74 123.06,48.54 123.74,47.86 123.74,47.32 123.87,47.2 123.87,46.69 123.74,46.56 123.36,46.56 123.26,46.66 123.26,47.07 123.03,47.3 122.22,47.3 121.76,46.84 121.76,46 121.66,45.9 ; 2 cut-outs
GND on TOP: 54.22,75.75 54.15,75.82 54.15,79.43 53.89,79.68 53.89,83.04 53.72,83.21 52.47,83.21 52.39,83.29 52.39,84.58 52.45,84.64 53.49,84.64 53.54,84.58 53.54,84.1 53.84,83.8 54.86,83.8 54.91,83.85 54.91,84.56 54.99,84.64 55.8,84.64 55.9,84.53 55.9,80.85 56.04,80.71 56.04,79.67 56.05,79.66 56.05,76.66 55.14,75.75 ; 4 cut-outs
GND on TOP: 75.28,98.12 75.08,98.33 75.08,100.23 75.23,100.38 78.23,100.38 78.3,100.31 78.3,98.96 77.46,98.12
GND on TOP: 175.99,93.6 175.69,93.91 175.69,94.06 176.32,94.69 176.32,98.25 177.08,99.01 177.08,100.28 177.34,100.54 178.48,100.54 179.11,99.9 179.11,97.49 178.35,96.73 178.35,95.33 178.86,94.82 178.86,94.57 178.35,94.06 178.23,94.06 177.84,94.44 177.03,94.44 176.19,93.6 ; 1 cut-out
GND on TOP: 66.57,91.01 66.24,91.34 66.24,92.13 66.36,92.26 66.36,93.93 66.52,94.08 71.14,94.08 71.37,93.86 71.37,93.17 71.29,93.09 69.56,93.09 69.39,92.92 69.39,92.41 69.64,92.15 70.81,92.15 71.04,91.93 71.04,91.14 70.91,91.01 ; 4 cut-outs
GND on TOP: 145.61,8.69 145.38,8.92 145.38,9.3 145.51,9.43 147.09,9.43 147.34,9.68 147.34,11.59 147.57,11.81 148.74,11.81 148.91,11.64 148.91,8.87 148.74,8.69
GND on TOP: 193.82,42.83 193.62,43.03 193.62,44.33 194.43,45.14 195.65,45.14 195.75,45.04 195.75,44.25 195.42,43.92 195.42,43 195.24,42.83 ; 2 cut-outs
GND on TOP: 181.88,81.74 181.65,81.97 181.28,81.97 180.84,82.4 180.54,82.4 180.26,82.12 180.13,82.12 179.88,82.37 179.88,82.5 180.08,82.71 181.02,82.71 181.38,83.06 181.38,83.31 181,83.69 181,84.41 180.41,84.99 180.08,84.99 179.52,84.43 179.34,84.43 178.89,84.89 178.89,86.87 182.27,90.25 182.39,90.25 182.9,89.74 182.9,89.61 180.44,87.15 180.44,86.62 180.77,86.29 180.77,86.29 182.27,84.79 182.27,84.15 183.22,83.2 183.22,82.85 182.11,81.74 ; 3 cut-outs
GND on TOP: 144.16,83.57 143.12,84.61 143.12,88.8 143.38,89.06 144.67,89.06 145.21,88.52 145.21,83.67 145.1,83.57 ; 4 cut-outs
GND on TOP: 206.75,44.73 206.65,44.83 206.65,45.85 207.39,46.59 207.39,47.09 207.77,47.48 209.57,47.48 209.67,47.37 209.67,46.74 209.49,46.56 208.43,46.56 208.12,46.26 208.12,44.81 208.05,44.73 ; 2 cut-outs
GND on TOP: 104.21,70.44 103.93,70.72 103.93,77.85 104.13,78.06 106.39,78.06 106.8,77.65 106.8,70.67 106.57,70.44 ; 10 cut-outs
GND on TOP: 50.46,7.57 50.34,7.7 50.34,8.97 50.59,9.22 50.97,9.22 51.23,9.48 51.23,10.24 51.35,10.37 51.86,10.37 52.24,9.98 52.24,7.95 52.11,7.83 51.23,7.83 50.97,7.57 ; 1 cut-out
GND on BOTTOM: 94.15,65.38 93.75,65.79 92.91,65.79 92.73,65.97 92.45,65.97 92.3,66.12 92.3,67.31 92.2,67.41 91.89,67.41 91.84,67.36 91.54,67.36 91.46,67.44 91.03,67.44 90.9,67.31 90.6,67.31 90.44,67.16 90.44,65.81 90.39,65.76 90.19,65.76 89.94,66.02 89.73,66.02 89.58,66.17 89.58,67.34 89.2,67.72 89.2,68 89.3,68.1 90.34,68.1 90.42,68.18 90.42,68.48 90.06,68.84 90.06,69.22 89.61,69.67 89.61,69.9 89.73,70.03 90.57,70.03 90.72,69.88 90.72,68.86 91.48,68.1 93.67,68.1 94.15,68.58 94.15,69.34 94.25,69.45 94.51,69.45 94.61,69.34 94.61,68.63 94.71,68.53 96.46,68.53 96.87,68.13 96.87,67.85 96.36,67.34 96.01,67.34 95.45,67.9 95.19,67.9 94.61,67.31 94.61,66.5 94.71,66.4 94.91,66.4 95.09,66.58 95.47,66.58 95.98,66.07 95.98,65.86 95.83,65.71 95.7,65.71 95.47,65.94 95.14,65.94 94.58,65.38
GND on BOTTOM: 128.39,83.47 128.26,83.59 128.26,83.87 127.98,84.15 127.98,84.38 128.14,84.53 130.4,84.53 130.68,84.25 131.44,84.25 131.67,84.48 131.67,85.35 131.77,85.45 132.15,85.45 132.3,85.3 132.3,84 131.92,83.62 130.47,83.62 130.42,83.57 129.58,83.57 129.48,83.47
GND on BOTTOM: 16.3,46.05 16.05,46.31 16.05,47.32 16.17,47.45 20.36,47.45 20.75,47.83 22.9,47.83 23.03,47.7 23.03,47.32 22.78,47.07 21.25,47.07 20.24,46.05 ; 2 cut-outs
GND on BOTTOM: 177.31,97.95 176.98,98.28 175.43,98.28 175.36,98.35 175.36,99.34 175.41,99.39 176.91,99.39 176.98,99.32 176.98,99.14 177.13,98.99 177.74,98.99 177.82,99.06 177.82,100.41 178,100.59 178.73,100.59 179.09,100.94 179.62,100.94 179.75,100.82 179.75,99.14 179.62,99.01 178.61,99.01 178.4,98.81 178.4,98.07 178.28,97.95 ; 4 cut-outs
GND on BOTTOM: 193.69,58.85 193.49,59.06 193.49,61.95 193.69,62.16 195.24,62.16 195.37,62.03 195.37,59.82 195.45,59.74 195.45,59.11 195.19,58.85
GND on BOTTOM: 104.06,96.5 103.93,96.62 103.93,97.31 104.06,97.44 109.26,97.44 109.47,97.23 109.47,96.62 109.34,96.5
GND on BOTTOM: 164.18,82.04 163.87,82.35 163.87,84.03 163.49,84.41 162.99,84.41 162.86,84.28 162.86,83.52 162.73,83.39 162.35,83.39 162.1,83.14 162.1,82.63 161.92,82.45 161.36,82.45 161.28,82.53 161.28,83.44 161.21,83.52 161.21,84.53 162.73,86.06 163.11,86.06 164.64,84.53 164.64,84.41 164.79,84.25 164.79,83.16 164.89,83.06 165.12,83.06 165.35,83.29 165.35,84 165.45,84.1 165.81,84.1 165.91,84 165.91,83.39 165.07,82.55 165.07,82.15 164.97,82.04 ; 3 cut-outs
GND on BOTTOM: 61.87,67.21 60.85,68.23 60.85,70.41 61.11,70.67 66.34,70.67 66.85,71.17 66.85,71.96 67.23,72.34 70.02,72.34 70.28,72.09 70.28,68 69.49,67.21
GND on BOTTOM: 149.37,4.4 149.07,4.7 145.82,4.7 145.38,5.13 145.38,9.27 145.59,9.48 148.51,9.48 148.76,9.22 148.76,8.84 148.38,8.46 147.75,8.46 147.49,8.21 147.49,6.94 147.62,6.81 148.74,6.81 149.12,7.19 150.62,7.19 150.72,7.09 150.72,6.12 150.92,5.92 152.11,5.92 152.53,5.5 152.53,4.49 152.44,4.4
GND on BOTTOM: 50.59,7.57 50.34,7.83 50.34,9.22 50.51,9.4 52.14,9.4 52.24,9.3 52.24,7.95 52.11,7.83 51.23,7.83 50.97,7.57 ; 1 cut-out
GND on BOTTOM: 136.82,70.67 136.77,70.72 136.77,71.4 136.9,71.53 137.2,71.53 137.36,71.68 137.36,72.93 137.38,72.95 138.07,72.95 138.16,72.86 138.74,72.86 138.81,72.8 138.81,72.11 137.94,71.25 137.94,70.82 137.79,70.67 ; 1 cut-out
GND on BOTTOM: 33.75,86.72 33.65,86.82 33.65,89.46 34.31,90.12 37.15,90.12 37.38,89.89 37.38,87.1 37,86.72 ; 4 cut-outs
GND on BOTTOM: 186.48,58.12 186.24,58.36 186.24,59.38 186.3,59.44 186.81,59.44 187.5,60.12 187.5,60.28 187.88,60.66 188.26,60.66 188.39,60.53 188.39,59.01 188.13,58.75 188.13,58.24 188,58.12 ; 1 cut-out
GND on BOTTOM: 86.28,95.33 85.13,96.47 85.13,97.11 85.39,97.36 86.53,97.36 87.55,96.34 89.58,96.34 89.83,96.6 91.23,96.6 91.36,96.47 91.36,95.46 91.23,95.33
GND on BOTTOM: 204.9,83.52 204.72,83.69 204.72,85.7 204.95,85.93 208.68,85.93 208.96,85.65 208.96,83.9 208.58,83.52 ; 8 cut-outs
GND on BOTTOM: 198.11,66.6 197.84,66.88 197.84,67.13 200.01,69.31 200.26,69.31 200.68,68.89 200.68,67.47 199.82,66.6 ; 3 cut-outs
GND on BOTTOM: 63.42,54.89 63.14,55.17 63.14,56.47 63.39,56.72 69.74,56.72 69.97,56.49 69.97,55.25 69.62,54.89 ; 5 cut-outs
GND on BOTTOM: 161.33,86.06 159.56,87.84 159.56,88.22 159.94,88.6 160.19,88.6 161.59,87.2 162.22,87.2 162.86,87.84 162.99,87.84 163.62,87.2 163.62,87.07 163.11,86.57 162.48,86.57 161.97,86.06
GND on BOTTOM: 66.08,89.36 65.83,89.61 65.83,90.66 65.96,90.78 67.48,90.78 67.66,90.96 67.66,92.43 67.76,92.53 69.26,92.53 69.39,92.41 69.39,91.9 70.28,91.01 70.28,89.49 70.15,89.36
GND on BOTTOM: 121.2,68.58 121.13,68.66 121.13,68.89 121.2,68.96 121.86,68.96 121.94,69.04 121.94,69.27 122.45,69.78 123.84,69.78 124.3,70.23 124.76,70.23 124.86,70.13 124.86,69.9 124.73,69.78 124.73,69.4 123.92,68.58
GND on BOTTOM: 146.55,54.41 146.02,54.94 146.02,61.17 146.2,61.34 147.97,61.34 148.18,61.14 148.18,60.73 147.97,60.53 147.97,54.49 147.9,54.41 ; 3 cut-outs
GND on BOTTOM: 21.28,81.87 21,82.15 19.22,82.15 17.93,83.44 17.93,84.23 18.26,84.56 21.43,84.56 21.51,84.48 21.51,84.31 21.15,83.95 21.15,82.93 21.23,82.86 21.63,82.86 21.86,82.63 21.89,82.63 21.89,82.6 21.99,82.5 22.52,82.5 22.65,82.37 22.65,81.99 22.52,81.87 ; 2 cut-outs
GND on BOTTOM: 57.93,2.59 54.96,5.57 53.61,5.57 53.54,5.49 53.54,5.21 53.49,5.16 52.52,5.16 52.42,5.26 52.42,5.49 52.34,5.57 51.28,5.57 51.23,5.62 51.23,5.79 51.25,5.82 52.34,5.82 52.42,5.9 52.42,6.23 52.47,6.28 54.88,6.28 55.09,6.07 56.03,6.07 56.17,5.93 56.17,5.78 56.38,5.57 57.88,5.57 58.06,5.74 58.06,6.4 58.31,6.66 59.23,6.66 59.61,7.04 59.61,7.83 59.71,7.93 59.71,7.95 61.26,7.95 61.39,7.83 61.39,5.79 61.37,5.78 61.37,4.41 59.56,2.59 ; 1 cut-out
GND on BOTTOM: 54.63,55.68 54.48,55.83 54.48,59.24 53.13,60.58 53.13,62.44 52.75,62.82 52.52,62.82 51.48,63.86 51.48,64.04 51.53,64.09 54.91,64.09 55.16,63.83 55.16,59.92 56.41,58.68 56.41,56.59 55.49,55.68 ; 6 cut-outs
GND on BOTTOM: 164.03,53.9 163.25,54.68 163.25,55.44 165.09,57.28 165.09,58.55 165.25,58.7 169.56,58.7 169.58,58.71 169.59,58.7 172.69,58.7 173.15,58.24 173.15,55.7 172.8,55.36 167.81,55.36 166.35,53.9
GND on BOTTOM: 90.37,70.74 90.01,71.1 87.07,71.1 86.66,71.5 84.7,71.5 84.63,71.58 84.04,71.58 83.97,71.5 83.69,71.5 83.48,71.71 83.48,72.06 83.64,72.21 90.49,72.21 90.7,72.01 90.7,70.87 90.57,70.74
GND on BOTTOM: 31.95,79.48 31.54,79.89 31.54,80.77 31.34,80.98 30.83,80.98 30.75,81.05 30.75,81.49 30.47,81.77 30.47,82.73 30.55,82.81 31.21,82.81 31.67,82.35 33.34,82.35 33.45,82.25 33.45,81.82 33.37,81.74 33.37,79.89 32.96,79.48 ; 1 cut-out
GND on BOTTOM: 179.06,53.34 178.68,53.72 178.68,55.53 179.01,55.86 179.7,55.86 179.8,55.76 179.8,54.26 180,54.05 181.25,54.05 181.35,54.16 181.35,54.31 181.48,54.43 182.47,54.43 182.57,54.33 182.57,54.1 182.62,54.05 183.69,54.05 183.74,54 183.74,53.83 183.69,53.77 182.65,53.77 182.57,53.7 182.57,53.57 182.34,53.34
GND on BOTTOM: 39.9,17.12 39.67,17.35 39.67,18.24 40.1,18.67 49.24,18.67 49.42,18.49 49.42,17.22 49.32,17.12 ; 2 cut-outs
GND on BOTTOM: 78.64,95.36 78.93,95.07 80.21,95.07 80.34,94.95 80.34,94.55 79.9,94.11 79.88,94.09 79.88,94.02 79.88,94.01 79.88,92.64 80.05,92.46 80.05,91.77 79.95,91.67 79.62,91.67 79.55,91.75 79.55,92.56 78.95,93.16 78.95,93.97 77.95,94.97 77.95,95.25 78.06,95.36 ; 1 cut-out
GND on BOTTOM: 51.31,9.77 50.84,10.24 50.84,11 51.02,11.18 53.23,11.18 53.28,11.13 53.28,10.06 52.99,9.77
GND on BOTTOM: 128.54,60.99 128.01,61.52 128.01,61.78 128.14,61.9 129.25,61.9 129.61,62.26 130.12,62.26 130.25,62.13 130.25,61.12 130.12,60.99
GND on BOTTOM: 134.65,81.6 132.79,83.47 132.79,87.1 133.57,87.89 133.57,88.83 133.37,89.03 132.3,89.03 132.23,89.11 132.23,89.82 132.33,89.92 138.63,89.92 141.9,86.64 141.9,83.8 139.71,81.6
GND on BOTTOM: 72.66,76.71 72.51,76.86 72.51,82.2 71.42,83.29 66.67,83.29 66.39,83.57 66.39,86.59 66.14,86.85 65.07,86.85 64.81,86.59 64.81,86.39 64.54,86.11 64.54,85.96 64.46,85.88 64.15,85.88 64.05,85.98 64.05,86.82 65.07,87.84 70.48,87.84 71.9,89.26 80.82,89.26 82.1,87.98 82.1,83.18 75.64,76.71
GND on BOTTOM: 104.06,102.95 103.91,103.1 103.91,104.73 104.06,104.88 106.29,104.88 106.47,104.7 106.47,103.18 106.24,102.95 ; 2 cut-outs
