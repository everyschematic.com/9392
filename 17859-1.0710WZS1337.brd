# Allegro board 17859-1.0710WZS1337.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SM_DRAMRST#_CPU: length 50.1
  TOP w0.127: v1(122.22,54.8) 122.22,55.33 120.64,56.9 120.64,58.88 120.15,59.38 120.15,63.49 119.49,64.15 119.49,64.18 119.47,64.2 119.47,64.54 119.91,64.98 v1(119.91,65.05) ; v1(149.17,45.11) 149.17,44.55 v2(148.94,44.33) 148.38,43.77 R504.1 R505.2 147.05,44.01 ED502.2 ED502.1
  BOTTOM w0.127: CPU1.BU31 119.68,65.28 v1(119.91,65.05) ; v1(149.17,45.11) 148.5,45.11 147.89,45.72 142.28,45.72 141.59,45.02 136.68,45.02 135.97,45.74 131.46,45.74 131.08,46.11 131.08,46.18 129.09,48.17 127.94,48.17 122.22,53.89 v1(122.22,54.8)
SM_INTRUDER#: length 17.4
  TOP w0.102: v1(114.68,48.87) 114.75,48.8 R1730.2 114.83,48.11 v2(115.64,48.11)
  BOTTOM w0.076: CPU1.BR35 118.23,62.84 118.04,62.3 118.04,61.43 117.82,61.22 117.82,60.45 118.08,60.2 118.08,59.64 117.57,59.13 117.57,57.78 116.81,57.03
  BOTTOM w0.102: v1(114.68,48.87) 116.68,50.88 116.68,55.32 116.81,55.45 116.81,57.03
SM_PGCNTL: length 151.2
  TOP w0.127: Q502.G 138.6,38.1 131.17,30.67 56.45,30.67 v1(55.95,31.17) ; v1(58.25,48.61) 61.07,48.61 62.85,50.39 62.85,52.14 64.46,53.75 72.54,53.75 v1(73.37,54.58)
  L4 w0.127: v1(55.95,31.17) 56.05,31.27 57.02,31.27 58.87,33.12 58.87,33.78 58.52,34.14 58.52,43.67 57.02,45.16 57.02,46.82 58.25,48.05 v1(58.25,48.61)
  BOTTOM w0.102: CPU1.C35 86.27,62.61 85.67,62.61 85.49,62.44 85.16,62.44 84.96,62.23
  BOTTOM w0.127: 84.96,62.23 84.4,61.67 84.4,59.41 81.4,56.41 72.69,56.41 72.22,55.94 v2(72.22,55.01) 72.71,54.51 73.3,54.51 v1(73.37,54.58)
SM_PGCNTL_R: length 166.2
  TOP w0.127: v1(169.34,38.05) 167.13,40.26 v2(158.97,40.26) 150.36,40.26 R506.2 149.12,40.8 Q501.D
  L3 w0.127: v1(168.11,35.85) 174.42,29.54 174.42,21.85 173.53,20.96 151.53,20.96 151.48,20.91 150.44,20.91 150.39,20.96 103.96,20.96 103.24,20.24 92.04,20.24 86.51,14.71 79.19,14.71 v1(77.34,16.56)
  BOTTOM w0.127: PR5106.1 58.13,13.92 59.25,15.04 59.25,17.02 59.18,17.1 59.18,17.55 59.63,18.01 61.36,18.01 61.49,17.88 67.43,17.88 67.81,17.5 74.02,17.5 74.65,16.87 77.03,16.87 v1(77.34,16.56) ; v1(168.11,35.85) 168.73,36.46 168.73,37.44 v1(169.34,38.05)
SM_RCOMP_0: length 21.7
  TOP w0.089: 115.13,63.83 115.21,63.91 115.21,64.24 115.77,64.8 115.77,65.23 116.68,66.14 116.68,66.46 v1(117.18,66.95)
  TOP w0.254: 115.13,63.83 115.13,63.19 113.75,61.8 110.81,61.8 109.88,60.87 109.88,60.87 109.23,60.23 109.23,60.22 109.04,60.02 109.04,53.65 v2(108.78,53.39) 108.83,53.34 R501.1
  BOTTOM w0.305: CPU1.BN28 v1(117.18,66.95)
SM_RCOMP_1: length 22.6
  TOP w0.089: 114.84,64.1 114.93,64.18 114.93,66.58 115.16,66.8 115.44,66.8 116.24,67.61 v1(116.26,67.61)
  TOP w0.254: 114.84,64.1 114.73,63.98 114.73,63.27 113.6,62.14 110.67,62.14 109.74,61.21 109.73,61.21 108.89,60.37 108.89,60.36 108.69,60.17 108.69,60.16 107.87,59.34 107.87,53.9 108.07,53.7 v2(108.07,52.07) R502.1
  BOTTOM w0.2: CPU1.BN27 116.46,67.62 116.27,67.62 v1(116.26,67.61)
SM_RCOMP_2: length 22.3
  TOP w0.089: 116.81,63.58 116.81,64.46 116.58,64.69 116.58,65.72 v1(117.18,66.32)
  TOP w0.254: R503.1 109.58,51.05 109.58,51.94 v2(109.49,52.02) 109.58,52.1 109.58,60.09 110.02,60.53 111.59,60.53 111.71,60.65 113.75,60.65 113.84,60.56 114.3,60.56 115.06,61.32 115.06,62.23 115.54,62.72 116.46,62.72 116.81,63.07 116.81,63.58
  BOTTOM w0.305: v1(117.18,66.32) 116.72,66.58 CPU1.BN29
SMBC_THERM_NV: length 22.9
  TOP w0.089: v1(187,75.16) 186.48,75.16 185.47,74.15 185.47,71.01 185.55,70.94 185.55,67.9 184.47,66.83 184.47,65.69 183.31,64.52 183.31,62.97 182.85,62.52 RN7901.1 180.26,61.72 v2(179.85,61.32) v1(179.11,60.58)
  BOTTOM w0.089: Q7901.1 177.32,60.06 177.66,60.4 178.94,60.4 v1(179.11,60.58) ; GPU1.D9 187.05,75.21 v1(187,75.16)
SMBD_THERM_NV: length 25.3
  TOP w0.089: RN7901.2 180.9,63.17 181.12,62.94 182.28,62.94 182.37,63.03 v1(182.37,63.05) 182.37,63.12 182.14,63.35 182.14,63.75 184.19,65.8 184.19,66.93 185.28,68.02 185.28,70.75 185.06,70.97 185.06,74.87 185.85,75.67 v1(186.45,75.67)
  L3 w0.089: v1(180.97,59.06) 181.01,59.06 181.1,59.15 181.1,59.36 181.32,59.58 181.32,61.99 182.37,63.03 v1(182.37,63.05)
  BOTTOM w0.089: v1(180.97,59.06) 180.62,58.71 v2(180.09,58.71) 179.18,57.8 Q7901.4 ; GPU1.D8 v1(186.45,75.67)
SPI_CLK_CPU: length 38.7
  TOP w0.089: v1(155.49,50.17) 155.52,50.17 156.84,48.85 157.98,48.85 v2(158.54,49.41)
  BOTTOM w0.089: v1(155.49,50.17) 154.91,50.75 147.5,50.75 143.26,54.98 134.01,54.98 132.14,56.85 131.97,56.85 129.61,59.21 127.52,59.21 125.88,60.85 CPU1.CH37
SPI_CLK_ROM: length 67.5
  TOP w0.089: R1814.1 157.12,50.19 v1(156.13,50.19) ; R9138.1 196.54,36.52 195.71,35.69 v2(194.51,35.69) 193.01,35.69 v1(192.39,35.08) 191.48,34.17 R2568.2
  L4 w0.114: v1(156.13,50.19) 156.13,50.65 156.03,50.75 155.19,50.75 154.98,50.55 154.98,49.41 155.44,48.95 155.6,48.95 157.04,50.4 157.22,50.4 157.4,50.22 157.4,50.07 155.97,48.64 155.97,48.42 156.25,48.14 157.37,48.14 157.47,48.24 157.47,49.43 157.59,49.54 157.77,49.54 157.88,49.43 157.88,48.99 158.04,48.82 158.2,48.82 158.31,48.93 158.31,49.58 158.57,49.84 160.95,49.84 161.69,49.1 163.42,49.1 163.82,48.69 164.61,48.69 167.18,46.13 169.34,46.13 170.07,45.39 171.16,45.39 178.99,37.57 180.49,37.57 181.35,36.71 184.07,36.71 184.65,37.29 190.23,37.29 190.34,37.18 190.34,36.39 190.46,36.27 190.7,36.27 190.81,36.38 190.81,37.13 190.92,37.24 191.14,37.24 191.26,37.12 191.26,36.38 191.36,36.27 191.57,36.27 191.69,36.39 191.69,37.12 191.8,37.24 192.09,37.24 192.39,36.94 v1(192.39,35.08)
SPI_CLK_ROM_R: length 5.8
  TOP w0.089: v1(188.92,34.39) 189.37,34.39 189.49,34.51 189.49,35.89 189.58,35.98 189.95,35.98 190.04,35.89 v2(190.04,35.38) R2568.1
  BOTTOM w0.089: v1(188.92,34.39) 189.48,34.95 SKT251.6
SPI_CLK_ROM_TPM: length 5.5
  TOP w0.089: R9138.2 197.78,37.39 198.38,37.39 198.49,37.28 198.49,36.86 198.6,36.76 198.75,36.76 198.86,36.86 198.86,37.28 198.97,37.39 199.33,37.39 199.42,37.3 v2(199.42,36.83) 199.42,36.59 200.13,35.88 U9101.19
SPI_CS2#_IC: length 28.5
  TOP w0.089: R9122.2 205.42,41.02 206.59,41.02 206.96,40.64 v1(207.15,40.44) ; v1(199.28,35.82) 198.88,36.22 R9148.2 R9130.2 198.42,35.21 R9140.2 199.08,34.67 v2(199.73,35.32) 199.79,35.38 U9101.20
  L3 w0.114: v1(199.28,35.82) 199.28,36.48 199.39,36.59 200.11,36.59 200.22,36.7 200.22,36.9 200.11,37.01 199.39,37.01 199.28,37.12 199.28,37.54 199.97,38.23 200.44,38.23 200.54,38.12 200.54,37.42 200.65,37.32 200.95,37.32 201.06,37.43 201.06,38.12 201.17,38.23 201.4,38.23 201.52,38.12 201.52,37.43 201.63,37.32 201.98,37.32 202.09,37.43 202.09,39.15 202.19,39.25 202.78,39.25 202.89,39.13 202.89,38.14 203,38.03 203.29,38.03 203.4,38.13 203.4,39.04 203.53,39.17 203.85,39.17 203.98,39.04 203.98,38.06 204.1,37.95 204.35,37.95 204.46,38.06 204.46,39.14 204.57,39.25 205,39.25 205.09,39.33 205.09,39.72 205.33,39.96 206.67,39.96 v1(207.15,40.44)
SPI_CS_ROM_N0: length 111.3
  TOP w0.089: R2501.2 189.02,35.63 188.61,35.21 187.95,35.21 v1(187.55,35.61) ; v1(159.23,48.29) 159.28,48.34 v2(159.84,48.34)
  L4 w0.114: v1(187.55,35.61) 187.55,36.08 187.64,36.17 189.33,36.17 189.56,35.94 189.56,35.77 189.33,35.54 189.33,35.38 189.45,35.26 189.61,35.26 189.85,35.5 190,35.5 190.16,35.34 190.16,35.18 189.92,34.94 189.92,34.79 190.06,34.65 190.22,34.65 190.45,34.88 190.61,34.88 190.82,34.67 190.82,34.29 190.72,34.19 189.45,34.19 189.38,34.27 189.38,34.72 189.23,34.87 187.2,34.87 187.09,34.98 187.09,36.36 186.98,36.47 186.75,36.47 186.64,36.36 186.64,34.98 186.52,34.87 186.33,34.87 186.22,34.98 186.22,35.86 186.11,35.97 185.88,35.97 185.77,35.85 185.77,34.98 185.66,34.87 185.37,34.87 185.26,34.98 185.26,35.53 185.16,35.64 184.94,35.64 184.83,35.52 184.83,34.98 184.72,34.87 184.49,34.87 184.37,34.98 184.37,35.48 184.22,35.64 184.06,35.64 183.94,35.52 183.94,35.02 183.83,34.9 183.6,34.9 183.48,35.02 183.48,35.52 183.37,35.64 183.19,35.64 183.08,35.52 183.08,35 182.95,34.87 182.79,34.87 182.67,34.98 182.67,35.52 182.54,35.66 182.35,35.66 182.24,35.55 182.24,35.17 182.12,35.05 181.9,35.05 181.79,35.17 181.79,35.79 181.71,35.87 181.06,35.87 180.27,36.65 178.78,36.65 170.86,44.58 169.77,44.58 169.03,45.32 166.83,45.32 165.78,46.36 164.79,46.36 163.14,48.01 159.51,48.01 v1(159.23,48.29)
  BOTTOM w0.089: CPU1.CG36 125.32,61.87 125.32,60.68 127.6,58.4 128.07,58.4 128.61,57.85 128.61,57.52 128.31,57.22 128.31,55.46 131.63,52.14 134.41,52.14 134.81,51.74 136.85,51.74 139.2,49.39 150.44,49.39 151.21,48.62 158.89,48.62 v1(159.23,48.29) ; v1(187.55,35.61) 186.23,36.93 182.7,36.93 182.29,36.53 182.29,32.61 182.48,32.41 U2501.1
SPI_CS_ROM_N2: length 86.3
  TOP w0.089: v1(158.01,50.4) 157.7,50.7 v2(157.47,50.7) ; v1(196.89,35.33) 196.95,35.38 197.15,35.38 197.2,35.44 R9130.1
  L4 w0.114: v1(158.01,50.4) 160.98,50.4 161.87,49.51 163.57,49.51 163.98,49.1 164.76,49.1 167.33,46.54 169.49,46.54 170.22,45.8 171.32,45.8 179.14,37.98 182.7,37.98 183.56,37.11 183.92,37.11 184.78,37.98 192.63,37.98 193.49,37.11 193.49,36.38 194.53,35.33 v1(196.89,35.33)
  BOTTOM w0.089: CPU1.CH34 126.14,63.32 126.14,61.43 126.09,61.38 126.09,60.89 126.52,60.46 129.41,59.39 129.79,59.39 130.45,59.04 132.17,57.32 132.33,57.32 134.21,55.45 143.59,55.45 147.83,51.22 155.11,51.22 155.88,50.91 156.76,50.4 v1(158.01,50.4)
SPI_HOLD_CPU: length 12.1
  TOP w0.089: R1845.2 129.86,54.69 128.72,55.83 128.72,56.04 128.21,56.54 v1(128.21,57.69)
  BOTTOM w0.089: CPU1.CG34 124.97,63 124.97,61.81 125.14,61.64 125.14,60.52 v2(127.69,57.97) 127.97,57.69 v1(128.21,57.69)
SPI_HOLD_ROM: length 82.3
  TOP w0.089: v1(128.71,57.05) 128.71,56.38 130.73,54.36 R1845.1 130.73,53.06 130.42,52.76 R1511.1 131.22,52.58 R1510.1 ; v2(159.15,47.27) 158.89,47.01 v1(158.59,47.01) ; v1(188.31,33.05) 186.73,34.62 R2570.2
  L4 w0.114: v1(188.31,33.05) 187.9,33.45 186.71,33.45 186.68,33.48 186.66,33.48 186.16,33.98 181.43,33.98 180,35.41 178.89,35.41 171.83,42.47 171.44,42.47 170.15,43.77 169.16,43.77 168.45,44.48 166.29,44.48 165.32,45.44 164.59,45.44 162.88,47.15 158.72,47.15 v1(158.59,47.01)
  BOTTOM w0.089: v1(128.71,57.05) 128.71,55.58 131.69,52.61 134.92,52.61 135.38,52.15 137.03,52.15 137.86,51.32 142.98,51.32 143.18,51.52 144.16,51.52 145.9,49.77 151.49,49.77 152.15,49.12 159,49.12 159.65,48.46 159.65,48.08 v1(158.59,47.01)
SPI_HOLD_ROM_R: length 8.6
  TOP w0.089: RN2501.2 187.31,36.79 187.52,36.58 v2(187.52,36.25) 187.24,35.97 186.94,35.97 186.73,35.77 R2570.1 187.65,34.67 v1(187.65,34.37)
  BOTTOM w0.089: SKT251.7 188.4,33.68 188.19,33.47 187.01,33.47 186.92,33.56 186.92,34.27 187.02,34.37 v1(187.65,34.37)
SPI_IRQ#_TPM2: length 6
  TOP w0.089: v2(196.62,38.71) R9152.1 R9153.2 198.24,38.69 R9154.1 199.36,37.92 199.79,37.49 199.79,36.81 200.22,36.38 U9101.18
SPI_SI_CPU: length 19.2
  TOP w0.089: R1823.2 132.86,48.72 v1(133.34,49.2) 133.8,49.66 v2(133.8,49.71)
  BOTTOM w0.076: CPU1.CF36 124.58,62.23 124.43,61.96 124.43,61.95 124.32,61.75 124.32,61.49 124.53,61.27 124.53,61.26
  BOTTOM w0.089: v1(133.34,49.2) 129.92,52.63 128.77,52.63 128.4,53 128.4,54.14 127.88,54.66 127.88,57.03 124.63,60.28 124.63,61.16 124.53,61.26
SPI_SI_ROM: length 84
  TOP w0.089: R9133.1 195.45,33.59 193,33.59 v1(192.37,34.21) 192.29,34.21 191.46,33.38 R2569.2 ; R1823.1 133.73,48.24 133.34,47.86 R1507.1 133.67,47.35 134.31,47.98 134.31,48.99 v1(134.08,49.22) 134.65,49.79 135.12,49.79 v2(135.17,49.84) 136.37,49.84 R1506.2
  L4 w0.114: v1(157.72,47.58) 158.72,48.57 158.72,49.11 158.81,49.2 159.09,49.2 159.2,49.09 159.2,48.83 159.28,48.75 159.52,48.75 159.63,48.86 159.63,49.14 159.75,49.26 160.02,49.26 160.13,49.14 160.13,48.83 160.25,48.71 160.51,48.71 160.62,48.83 160.62,49.09 160.74,49.2 161.03,49.2 161.18,49.05 161.18,48.66 161.3,48.54 163.16,48.54 164.81,46.89 165.86,46.89 167.02,45.72 169.18,45.72 169.92,44.99 171.01,44.99 178.84,37.16 180.33,37.16 181.2,36.3 184.22,36.3 184.8,36.88 189.25,36.88 191.02,35.11 191.14,35.11 191.46,35.43 191.61,35.43 191.85,35.2 191.85,35.04 191.5,34.69 191.5,34.53 191.81,34.21 v1(192.37,34.21)
  BOTTOM w0.089: v1(134.08,49.22) 134.08,49.74 135.03,50.69 136.63,50.69 139.83,47.49 147.77,47.49 148.3,46.96 157.11,46.96 v1(157.72,47.58)
SPI_SI_ROM_R: length 5.8
  TOP w0.089: R2569.1 190.02,33.4 188.56,33.4 188.28,33.68 v2(188.28,33.81) v1(188.28,34.39)
  BOTTOM w0.089: v1(188.28,34.39) 188.28,34.67 189.02,35.41 189.02,36.07 189.17,36.22 SKT251.5
SPI_SI_ROM_TPM: length 5.8
  TOP w0.089: U9101.21 199.92,34.88 198.77,33.73 v2(198.5,33.73) 198.27,33.73 198.16,33.84 198.16,34.11 198.05,34.22 197.9,34.22 197.79,34.11 197.79,33.84 197.69,33.73 197.53,33.73 197.43,33.84 197.43,34.11 197.32,34.22 196.95,34.22 R9133.2
SPI_SO_CPU: length 54.3
  TOP w0.089: v1(157.07,47.53) 156.89,47.53 v2(156.56,47.2) 156.56,46.38 R1819.2
  BOTTOM w0.089: CPU1.CF37 124.89,61.33 124.89,60.28 128.06,57.11 128.06,55.19 131.97,51.28 132.75,51.28 132.86,51.18 132.86,50.43 132.96,50.32 133.12,50.32 133.22,50.43 133.22,51.18 133.33,51.28 133.48,51.28 133.59,51.18 133.59,50.43 133.7,50.32 133.85,50.32 133.96,50.43 133.96,51.18 134.07,51.28 136.79,51.28 139.12,48.95 144.71,48.95 145.69,47.97 146.68,47.97 146.79,48.08 146.79,48.91 146.9,49.02 147.05,49.02 147.16,48.91 147.16,48.08 147.26,47.97 147.42,47.97 147.52,48.08 147.52,48.91 147.63,49.02 147.79,49.02 147.89,48.91 147.89,48.08 148,47.97 148.15,47.97 148.26,48.08 148.26,48.91 148.37,49.02 148.52,49.02 148.63,48.91 148.63,48.08 148.74,47.97 148.89,47.97 149,48.08 149,48.91 149.11,49.02 149.26,49.02 149.37,48.91 149.37,48.08 149.47,47.97 149.63,47.97 149.73,48.08 149.73,48.91 149.84,49.02 149.99,49.02 150.1,48.91 150.1,48.08 150.21,47.97 156.62,47.97 v1(157.07,47.53)
SPI_SO_ROM: length 54.1
  TOP w0.089: R9132.1 194.22,31.5 v2(193.95,31.77) v1(192.37,33.35) 192.34,33.35 191.59,32.59 R2507.1 ; v1(157.72,46.94) 157.72,46.43 R1819.1
  L4 w0.114: v1(192.37,33.35) 191.74,32.72 191.5,32.72 191.38,32.83 191.38,33.67 191.27,33.78 190.99,33.78 190.88,33.67 190.88,32.84 190.76,32.72 190.46,32.72 190.35,32.83 190.35,33.67 190.24,33.78 190.01,33.78 189.93,33.7 189.93,32.83 189.81,32.72 189.59,32.72 189.48,32.83 189.48,33.61 189.22,33.86 186.86,33.86 186.25,34.47 181.88,34.47 180.16,36.2 178.66,36.2 170.69,44.17 169.59,44.17 168.85,44.91 166.66,44.91 165.65,45.92 164.67,45.92 163.04,47.55 158.33,47.55 v1(157.72,46.94)
SPI_SO_ROM_R: length 8.1
  TOP w0.089: v1(188.94,32.97) 188.94,32.36 v2(189.02,32.29) 189.73,32.29 R2507.2
  BOTTOM w0.089: SKT251.2 184.09,33.68 185.36,32.42 188.39,32.42 v1(188.94,32.97)
SPI_SO_ROM_TPM: length 5.4
  TOP w0.089: R9132.2 198.5,30.67 198.63,30.53 199.03,30.53 199.43,30.94 v2(199.43,31.24) 199.43,31.47 199.71,31.75 200.5,31.75 200.73,31.98 U9101.24
SPI_WP_CPU: length 14.5
  TOP w0.089: R1824.2 132.02,54.1 130.14,55.98 v1(130.14,56.62)
  BOTTOM w0.089: CPU1.CF34 125.34,63.59 125.52,63.4 125.52,60.89 127.65,58.75 129.03,58.75 v2(129.48,58.3) 130.14,57.64 v1(130.14,56.62)
SPI_WP_ROM: length 78.5
  TOP w0.089: v1(131.08,56.59) 131.08,55.91 132.89,54.11 132.89,52.63 R1509.1 R1508.1 ; v1(158.67,46.38) 159.1,45.95 v2(159.1,45.88) ; R2571.2 185.97,34.7 v1(187.67,33)
  L4 w0.114: v1(187.67,33) 186.59,33 186.56,33.02 186.56,33.02 186,33.58 181.17,33.58 179.75,35 178.73,35 171.67,42.07 170.94,42.07 169.64,43.36 168.83,43.36 168.12,44.07 166.14,44.07 165.17,45.04 164.43,45.04 162.79,46.68 158.97,46.68 v1(158.67,46.38)
  BOTTOM w0.089: v1(131.08,56.59) 131.52,56.16 132.17,56.16 133.82,54.51 142.97,54.51 147.34,50.14 151.72,50.14 152.23,49.64 159,49.64 160.02,48.62 160.02,47.74 v1(158.67,46.38)
SPI_WP_ROM_R: length 9
  TOP w0.089: v1(185.77,36.43) 185.45,36.11 185.45,35.73 185.59,35.59 R2571.1 186.33,35.94 186.33,36.58 185.85,37.06 v2(185.85,37.16) 185.87,37.19 RN2501.1
  BOTTOM w0.089: v1(185.77,36.43) 186.21,36.43 186.38,36.26 186.38,35.09 186.24,34.95 SKT251.3
SPKR: length 166.4
  TOP w0.254: v1(29.15,29.11) 28.67,28.63 27.65,28.63 26.99,29.29 26.28,29.29 26.03,29.03 26.03,28.36 22.41,24.74 22.41,24.14 22.91,23.65 v1(23.36,23.65) ; v1(139.55,46.18) 139.55,45.86 140.18,45.24 140.18,42.8 139.08,41.71 v2(139.08,40.9) 139.08,40.18 130.02,31.12 56.94,31.12 56.28,31.78 55.82,31.78 55.52,31.48 55.52,31.45 54.94,30.86 53.49,30.86 v1(52.93,30.3)
  BOTTOM w0.083: 124.48,59.92 124.37,60.03 124.37,61.19 124.15,61.41 124.15,61.78 124.26,61.99 124.26,62.62 CPU1.CF35
  BOTTOM w0.254: 124.48,59.92 126.56,57.84 R1501.2 126,57.43 125.14,56.57 125.14,55.51 127.81,52.85 127.81,51.5 128.6,50.7 129.45,50.7 132.02,48.14 134.51,48.14 135.15,48.78 135.15,49.38 135.44,49.68 136.1,49.68 139.55,46.23 v1(139.55,46.18) ; v1(23.36,23.65) 23.79,23.22 R2741.1 ; v1(29.15,29.11) 30.55,29.11 30.8,29.37 30.8,30.03 31.06,30.28 33.73,30.28 34.31,29.7 38.68,29.7 39.92,30.94 40.79,30.94 41.29,30.43 47.14,30.43 47.29,30.28 48.25,30.28 49.27,31.3 50.48,31.3 51.27,30.51 52.72,30.51 v1(52.93,30.3)
SRTC_RST#: length 34.5
  TOP w0.127: v2(127.98,40.87) 127.98,41.47 v1(127.96,41.5) 127.96,41.61 126.99,42.57 C1805.1 ; RN1801.3 117.11,48.91 ED1801.2 117.33,50.3 v1(117.49,50.47)
  BOTTOM w0.076: CPU1.BR37 118.23,61.54 118.23,61.37 118,61.14 118,60.53 118.26,60.28 118.26,59.54 117.8,59.08
  BOTTOM w0.127: v1(127.96,41.5) 127.47,41.01 126.02,41.01 124.51,42.52 122.68,42.52 120.48,44.72 118.8,44.72 116.97,46.55 116.97,49.95 v1(117.49,50.47) 116.9,51.07 116.9,55.18 117.01,55.3 117.01,56.92 117.8,57.71 117.8,59.08
SSD_CLK_CPU_N: length 172.8
  L3 w0.102: v1(207.19,9.62) 206.86,9.29 206.71,9.29 206.55,9.45 206.55,12.31 209.49,15.26 209.49,24.19 208,25.68 203.37,25.68 197.05,32.01 196.3,32.01 194.38,33.93 194.38,36.08 190.68,39.78 186.13,39.78 185.19,40.72 184.89,40.72 176.93,48.68 176.93,62.27 174.24,64.96 174.24,66.91 173.56,67.59 172.99,67.59 171.88,68.71 171.88,70.98 170.13,72.72 168.6,72.72 167.58,73.74 167.58,75.08 164.64,78.02 164.64,79.78 163.47,80.95 162.91,80.95 152.55,91.32 146.41,91.32 146,91.72 134.73,91.72 133.11,90.1 128.65,90.1 125.24,93.5 111.96,93.5 110.71,92.26 110.71,91.25 108.68,89.22 108.68,87.65 109.05,87.28 109.75,87.28 109.97,87.07 v1(109.97,86.89)
  BOTTOM w0.102: SSD1.53 208.51,9.45 208.38,9.32 207.48,9.32 v1(207.19,9.62) ; CPU1.BA1 109.34,84.31 109.34,86.97 109.62,87.25 109.77,87.25 109.97,87.05 v1(109.97,86.89)
SSD_CLK_CPU_P: length 173
  L3 w0.102: v1(109.97,87.64) 109.82,87.49 109.13,87.49 108.88,87.73 108.88,89.13 110.92,91.16 110.92,92.17 112.04,93.3 125.16,93.3 128.56,89.89 133.19,89.89 134.82,91.52 145.92,91.52 146.32,91.11 152.46,91.11 162.83,80.75 163.38,80.75 164.43,79.7 164.43,77.94 167.38,74.99 167.38,73.65 168.52,72.52 170.05,72.52 171.67,70.9 171.67,68.63 172.91,67.39 173.48,67.39 174.03,66.83 174.03,64.87 176.73,62.18 176.73,48.59 184.8,40.52 185.11,40.52 186.05,39.58 190.6,39.58 194.18,35.99 194.18,33.84 196.22,31.8 196.96,31.8 203.29,25.48 207.92,25.48 209.29,24.11 209.29,15.34 206.34,12.4 206.34,9.37 206.63,9.08 206.86,9.08 v1(207.19,8.75)
  BOTTOM w0.102: 109.12,86.77 109.12,87.07 109.52,87.47 109.8,87.47 v1(109.97,87.64) ; 109.12,86.77 v2(108.93,86.77) ; 109.12,86.77 109.12,83.89 CPU1.BA2 ; SSD1.55 208.53,8.95 208.38,9.1 207.53,9.1 v1(207.19,8.75)
SSD_CLKREQ_CPU_N: length 149.7
  TOP w0.102: v1(124.41,65.61) 124.41,65.4 125.19,64.62 125.19,63.47 127.25,61.41 127.25,56.59 127.83,56.01 v1(127.83,53.97) 127.17,53.31 RN1813.6 ; ED7307.1 215.21,8.16 v1(215.13,8.08) v2(214.73,7.67)
  L3 w0.102: v1(215.13,8.08) 215.13,8.84 216.05,9.76 216.05,22.25 216.25,22.46 216.25,27.67 216.05,27.87 216.05,31.04 v1(216.45,31.45)
  L6 w0.102: v1(127.83,53.97) 127.83,53.5 128.77,52.56 135.67,52.56 137.97,50.26 137.97,41.32 141.91,37.38 166.36,37.38 167.06,38.08 168.17,38.08 168.88,38.79 175.48,38.79 178.23,36.05 179.55,36.05 180.41,35.18 189.66,35.18 191.93,32.91 194.06,32.91 195.49,31.48 199.9,31.48 200.81,32.39 202.71,32.39 203.07,32.03 205.99,32.03 206.88,31.14 210.99,31.14 211.98,32.13 215.03,32.13 215.54,31.63 215.94,31.63 216.07,31.75 216.15,31.75 v1(216.45,31.45)
  BOTTOM w0.102: CPU1.CE30 124.34,65.61 v1(124.41,65.61) ; SSD1.52 216.11,9.7 215.13,8.73 v1(215.13,8.08)
SSD_DEVSLP: length 152
  TOP w0.102: R6303.2 219.07,5.56 219.22,5.56 R6304.1 219.68,6.02 R6301.1 219.25,6.81 v1(218.87,7.19) ; v2(210.79,7.57) 210.99,7.57 v1(211.37,7.95)
  L3 w0.102: v1(218.87,7.19) 218.61,6.94 212.39,6.94 v1(211.37,7.95)
  L4 w0.102: v1(127.45,79.95) 128.5,78.9 133.87,78.9 135.5,77.27 136.98,77.27 137.38,76.86 142.55,76.86 143.25,77.57 143.25,79.51 144.09,80.35 149.08,80.35 149.88,79.56 151.44,79.56 151.7,79.3 151.73,79.3 152.98,78.06 152.98,78.02 157.04,73.96 157.04,71.9 160.57,68.37 160.57,67.32 161.35,66.55 164.01,66.55 166.92,63.64 166.92,63.15 175.46,54.61 175.46,51.9 v1(178,49.35)
  BOTTOM w0.102: v1(127.45,79.95) CPU1.CM8 ; v1(178,49.35) 178.4,48.95 178.4,48.54 178.12,48.26 178.12,47.16 184.11,41.18 187.61,41.18 191.92,36.87 191.92,32.49 194.77,29.64 201.68,29.64 203.05,31.02 205.81,31.02 207.99,28.83 207.99,27.16 208.83,26.32 210.51,26.32 211.42,25.4 211.42,24.92 213.58,22.76 213.58,18.09 212.82,17.33 212.82,11.81 211.37,10.37 v1(211.37,7.95)
SSD_DEVSLP_R: length 8.6
  TOP w0.102: R6301.2 220.69,8.69 AFTP6301.1 220.39,9.17 220.39,11.36 218.55,13.2 v1(218.23,13.2)
  BOTTOM w0.102: SSD1.38 v1(218.23,13.2)
SSD_LED#: length 275.1
  TOP w0.102: v1(19.37,51.34) 19.35,51.36 18.36,51.36 18.21,51.51 18.21,52.66 16.63,54.23 14.83,54.23 13.99,55.07 v1(11.88,55.07)
  L3 w0.102: v1(22.75,34.42) 23.01,34.42 23.39,34.8 23.39,38.59 22.7,39.27 22.7,40.44 23.39,41.13 23.39,42.09 22.32,43.16 22.32,43.84 20.52,45.65 20.52,49.86 19.37,51.01 v1(19.37,51.34)
  L6 w0.102: v1(178.86,26.27) 180.31,27.71 187.39,27.71 190.38,24.72 197.02,24.72 197.22,24.51 197.78,24.51 201.01,21.29 203.7,21.29 203.85,21.14 207.84,21.14 208.6,21.9 213.99,21.9 v1(215.21,20.68) ; v1(11.88,55.07) 12.24,55.43 12.24,56.21 12.62,56.59 12.62,63.1 12.69,63.17 12.69,63.58 12.67,63.6 12.67,64.01 12.69,64.04 12.69,66.83 13.61,67.74 13.61,68.53 13.37,68.77 13.37,79.1 17.19,82.92 19.68,82.92 20.16,83.4 20.16,85.19 18.43,86.92 18.43,88.12 v1(18.21,88.34)
  BOTTOM w0.102: v1(22.75,34.42) 22.73,34.39 22.73,34.22 22.83,34.11 23.18,34.11 24.1,33.2 v2(24.96,33.2) 26.03,33.2 27.76,31.47 28.54,31.47 28.72,31.3 28.72,28.88 28.92,28.68 31.39,28.68 31.72,29.01 155.37,29.01 155.83,29.47 175.65,29.47 v1(178.86,26.27) ; R6402.2 20.14,88.06 19.44,88.76 D6401.2 18.62,88.76 v1(18.21,88.34) ; SSD1.10 215.69,20.2 v1(215.21,20.68)
SSD_PCIE_RX_N1: length 151.7
  L3 w0.102: v1(114.54,81.14) 115.03,81.63 115.03,82.27 115.88,83.11 128.21,83.11 129.53,81.78 129.53,80.9 130.04,80.39 130.98,80.39 131.67,79.71 132.66,79.71 132.94,79.43 134.33,79.43 135.1,78.67 136.54,78.67 138.14,77.07 144.33,77.07 146.03,78.77 148.46,78.77 148.79,79.1 153,79.1 159.76,72.34 159.76,70.46 160.34,69.88 160.34,62.76 163.77,59.33 163.77,57.86 164.65,56.97 168.52,56.97 169.46,56.04 169.46,50.93 169.08,50.55 169.08,45.99 184.4,30.68 184.4,29.94 190.16,24.18 190.16,21.21 192.25,19.13 195.04,19.13 196.01,18.16 201.64,18.16 202.31,17.5 206.66,17.5 207.13,17.98 207.13,21.23 205.02,23.35 v1(204.16,23.35)
  BOTTOM w0.102: CPU1.BK6 v1(114.54,81.14) ; v2(206.85,22.1) 206.73,21.98 ; 206.73,21.98 207.27,21.45 SSD1.5 ; 206.73,21.98 205.37,23.35 v1(204.16,23.35)
SSD_PCIE_RX_N2: length 147.8
  L3 w0.102: v1(113.61,81.14) 114.03,81.55 114.03,81.85 115.7,83.52 128.39,83.52 128.62,83.29 133.54,83.29 135.47,81.36 139.34,81.36 142.21,84.23 143.55,84.23 144.27,83.52 144.27,82.52 146.47,80.32 151.96,80.32 152.37,80.72 153.64,80.72 161.51,72.85 161.51,68.02 162.94,66.6 162.94,63.58 166.52,60 168.52,60 170.73,57.79 170.73,48.78 169.72,47.76 169.72,46.23 170.73,45.21 170.73,45.21 185.03,30.91 185.21,30.73 185.21,30.04 190.77,24.48 190.77,21.49 192.53,19.74 195.29,19.74 196.26,18.77 201.94,18.77 202.55,18.16 206.04,18.16 206.42,18.54 206.42,19.66 206.1,19.98 205.26,19.98 v1(205.01,20.23)
  BOTTOM w0.102: v1(205.01,20.23) 205.25,19.99 206.14,19.99 207.08,19.05 ; 207.08,19.05 207.68,18.45 SSD1.17 ; 207.08,19.05 v2(207.18,19.15) ; CPU1.BJ6 v1(113.61,81.14)
SSD_PCIE_RX_N3: length 145.2
  L3 w0.102: v1(203.78,19) 203.2,19.59 197.12,19.59 196.16,20.55 196.16,24.01 195.17,25 192.73,25 191.75,25.97 190.43,25.97 186.04,30.37 186.04,31.07 171.56,45.55 171.56,58.13 168.87,60.82 166.86,60.82 163.76,63.92 163.76,66.93 162.33,68.36 162.33,73.21 153.98,81.56 152.06,81.56 151.63,81.13 146.81,81.13 145.1,82.84 145.1,83.83 143.89,85.04 141.83,85.04 138.96,82.17 135.73,82.17 134,83.9 128.9,83.9 128.62,84.18 114.7,84.18 113.02,82.5 113.02,82.12 v1(112.69,81.78)
  BOTTOM w0.102: v1(112.69,81.78) 112.91,81.57 CPU1.BG5 ; v1(203.78,19) 203.5,18.72 203.5,18.65 204.87,17.27 206.08,17.27 208.06,15.3 208.3,15.32 208.43,15.45 SSD1.29
SSD_PCIE_RX_P1: length 151.7
  L3 w0.102: v1(114.54,81.78) 114.73,81.78 114.83,81.89 114.83,82.35 115.79,83.31 128.29,83.31 129.74,81.87 129.74,80.99 130.13,80.6 131.07,80.6 131.75,79.91 132.74,79.91 133.02,79.63 134.42,79.63 135.18,78.87 136.63,78.87 138.23,77.27 144.24,77.27 145.94,78.97 148.37,78.97 148.7,79.3 153.09,79.3 159.96,72.43 159.96,70.55 160.55,69.96 160.55,62.84 163.98,59.41 163.98,57.94 164.74,57.18 168.61,57.18 169.67,56.12 169.67,50.85 169.29,50.46 169.29,46.08 184.6,30.76 184.6,30.03 190.37,24.26 190.37,21.3 192.33,19.33 195.13,19.33 196.09,18.37 201.73,18.37 202.39,17.71 206.57,17.71 206.93,18.06 206.93,21.15 204.94,23.14 204.59,23.14 204.49,23.04 204.49,22.81 204.39,22.71 v1(204.16,22.71)
  BOTTOM w0.102: 205.7,22.7 205.28,23.12 204.57,23.12 204.49,23.04 204.49,22.81 204.39,22.71 v1(204.16,22.71) ; 205.7,22.7 207.17,21.22 208.16,21.22 208.25,21.13 208.25,21.01 208.31,20.95 SSD1.7 ; 205.7,22.7 v2(205.58,22.58) ; v1(114.54,81.78) 114.54,81.67 114.7,81.51 114.94,81.51 CPU1.BK5
SSD_PCIE_RX_P2: length 147.8
  L3 w0.102: v1(205.01,19.37) 205.01,19.68 205.11,19.78 206.02,19.78 206.22,19.58 206.22,18.63 205.95,18.37 202.64,18.37 202.03,18.98 196.34,18.98 195.38,19.94 192.61,19.94 190.98,21.58 190.98,24.56 185.41,30.13 185.41,30.81 185.24,30.99 170.94,45.29 170.94,45.3 169.92,46.32 169.92,47.68 170.94,48.69 170.94,57.87 168.61,60.2 166.6,60.2 163.14,63.66 163.14,66.69 161.72,68.11 161.72,72.93 153.72,80.93 152.28,80.93 151.88,80.52 146.55,80.52 144.47,82.6 144.47,83.6 143.64,84.43 142.12,84.43 139.25,81.56 135.55,81.56 133.62,83.49 128.7,83.49 128.48,83.72 115.61,83.72 113.68,81.78 v1(113.61,81.78)
  BOTTOM w0.102: SSD1.19 208.36,17.95 208.09,18.22 207.59,18.22 206.87,18.94 206.05,19.76 205.11,19.76 205.01,19.66 v1(205.01,19.37) ; v1(113.61,81.78) 113.61,81.87 113.76,82.02 113.99,82.02 114.13,81.88 114.13,81.62 CPU1.BJ5
SSD_PCIE_RX_P3: length 145.4
  L3 w0.102: v1(202.99,19) 202.61,19.38 197.04,19.38 195.96,20.47 195.96,23.92 195.08,24.79 192.65,24.79 191.67,25.77 190.35,25.77 185.83,30.28 185.83,30.99 171.36,45.46 171.36,58.05 168.78,60.62 166.77,60.62 163.56,63.84 163.56,66.84 162.12,68.28 162.12,73.13 153.89,81.36 152.14,81.36 151.71,80.93 146.73,80.93 144.9,82.76 144.9,83.75 143.81,84.84 141.91,84.84 139.04,81.97 135.65,81.97 133.92,83.7 128.81,83.7 128.54,83.98 114.78,83.98 113.23,82.42 113.23,82.03 113.1,81.91 113.1,81.41 112.83,81.14 v1(112.69,81.14)
  BOTTOM w0.102: CPU1.BG6 v1(112.69,81.14) ; 204.48,17.34 203.27,18.55 203.27,18.72 v1(202.99,19) ; 204.48,17.34 204.78,17.05 205.98,17.05 207.96,15.07 208.07,15.07 208.32,15.09 208.32,15.09 208.46,14.95 SSD1.31 ; 204.48,17.34 v2(204.34,17.2)
SSD_PCIE_TX_CON_N1: length 5.3
  BOTTOM w0.102: 207.03,20.58 206.1,21.5 205.29,21.5 C6312.1 ; 207.03,20.58 207.79,19.81 208.37,19.81 208.51,19.95 SSD1.11 ; 207.03,20.58 v2(207.16,20.7)
SSD_PCIE_TX_CON_N2: length 4.1
  BOTTOM w0.102: SSD1.23 208.41,16.95 208.27,16.82 207.79,16.82 207.21,17.4 207.21,17.96 206.89,18.28 206.48,18.28 C6314.1
SSD_PCIE_TX_CON_N3: length 4.8
  BOTTOM w0.102: SSD1.35 208.58,13.95 208.45,13.82 208.27,13.82 206.95,15.14 206.95,15.34 206.5,15.8 ; 206.5,15.8 206.32,15.98 206.05,15.98 C6316.1 ; 206.5,15.8 v2(206.6,15.9)
SSD_PCIE_TX_CON_P1: length 5.3
  BOTTOM w0.102: v2(205.84,21.11) 205.84,21.28 ; 205.84,21.28 206.01,21.28 207.7,19.59 208.38,19.59 208.51,19.45 SSD1.13 ; 205.84,21.28 205.26,21.28 C6311.1
SSD_PCIE_TX_CON_P2: length 4.2
  BOTTOM w0.102: 207.1,17.19 207.7,16.59 208.27,16.59 208.4,16.46 208.46,16.46 208.47,16.45 SSD1.25 ; 207.1,17.19 v2(207,17.1) ; 207.1,17.19 206.98,17.31 206.98,17.87 206.8,18.05 206.48,18.05 C6313.1
SSD_PCIE_TX_CON_P3: length 4.8
  BOTTOM w0.102: 207.2,14.57 206.72,15.05 206.72,15.25 206.22,15.75 206.04,15.75 C6315.1 ; 207.2,14.57 208.18,13.59 208.43,13.59 208.57,13.45 SSD1.37 ; 207.2,14.57 v2(207.08,14.46)
SSD_PCIE_TX_N1: length 137.4
  L3 w0.102: v1(200.07,21.49) 200.36,21.2 200.53,21.2 200.65,21.32 200.65,21.76 199.26,23.16 199.26,24.99 195.49,28.76 194.91,28.76 192.65,31.02 191.96,31.02 189.39,33.58 186.8,33.58 173.63,46.76 173.63,60.9 170.99,63.55 170.99,63.8 165.04,69.74 165.04,71.57 164.15,72.46 164.15,73.71 154.2,83.67 147.89,83.67 144.89,86.67 141.45,86.67 139.69,88.42 136.16,88.42 134.03,86.29 133.34,86.29 133.14,86.08 129.23,86.08 128.59,85.45 122.6,85.45 120.52,87.53 116.18,87.53 115.69,87.04 115.69,86.72 115.54,86.57 115.54,86.01 115.36,85.83 v1(115.16,85.83)
  BOTTOM w0.076: v1(115.16,85.83) 115.18,85.83 115.23,85.78 115.46,85.78 115.54,85.7 115.54,85.44 115.79,85.19 115.79,85.04 116.03,84.8 116.03,83.58 115.83,83.37 115.83,83.11 116.15,82.79 CPU1.BM4
  BOTTOM w0.102: 203.12,21.5 200.84,21.5 200.53,21.19 200.38,21.19 v1(200.07,21.49) ; 203.12,21.5 v2(203.12,21.69) ; 203.12,21.5 203.79,21.5 C6312.2
SSD_PCIE_TX_N2: length 148.4
  L3 w0.102: v1(203.3,20.81) 203.02,21.09 203.02,24.14 196.37,30.79 195.76,30.79 193.14,33.41 193.14,35.37 189.99,38.51 185.52,38.51 184.56,39.47 184.37,39.47 175.66,48.19 175.66,61.78 173.02,64.42 173.02,64.65 167.08,70.59 167.08,72.48 166.36,73.19 166.36,74.55 161.74,79.17 161.74,80.33 151.97,90.1 145.89,90.1 145.49,90.5 135.25,90.5 133.45,88.7 126.88,88.7 124.34,91.24 121.89,91.24 120.21,89.56 113.91,89.56 112.88,88.53 112.19,88.53 v1(112.02,88.71)
  BOTTOM w0.102: v2(114.15,87.75) 114.06,87.66 ; 114.06,87.66 114.48,87.24 arc(114.66,86.96) 114.73,86.64 114.73,85.63 115.86,84.5 115.86,83.88 CPU1.BL2 ; 114.06,87.66 113.18,88.53 112.19,88.53 v1(112.02,88.71) ; C6314.2 205.04,18.28 204.88,18.28 204.57,18.59 204.57,20.25 204.29,20.53 203.58,20.53 v1(203.3,20.81)
SSD_PCIE_TX_N3: length 167.4
  L3 w0.102: v1(204.21,16.31) 203.98,16.08 203.77,16.08 203.22,15.53 203.22,14.61 203.68,14.15 206.02,14.15 208.58,16.71 208.58,17.18 208.58,17.19 208.58,17.71 208.58,17.72 208.58,23.66 207.42,24.82 203.37,24.82 196.79,31.4 196.03,31.4 193.77,33.66 193.77,35.65 190.27,39.14 185.88,39.14 184.93,40.09 184.63,40.09 176.27,48.45 176.27,62.05 173.63,64.7 173.63,64.9 167.68,70.84 167.68,72.73 166.97,73.44 166.97,74.81 162.43,79.36 162.43,80.5 152.22,90.71 146.15,90.71 145.74,91.11 135,91.11 133.19,89.31 127.3,89.31 124.76,91.85 119.34,91.85 119.06,91.57 113.55,91.57 111.88,89.9 111.88,89.84 111.27,89.23 111.27,86.18 111.64,85.8 112.52,85.8 113.13,86.41 v1(113.58,86.41)
  BOTTOM w0.076: 114.07,85.95 114.07,85.93 114.09,85.91 114.09,85.42 114.95,84.56 115.03,84.46 115.12,84.24 115.19,84.02 115.19,83.87 115.16,83.71 115.16,83.7 115.16,83.5 115.19,83.41 115.19,83.4 115.35,82.83 115.39,82.76 CPU1.BL4
  BOTTOM w0.102: C6316.2 204.72,16.11 204.71,16.11 204.69,16.08 204.42,16.08 204.21,16.29 v1(204.21,16.31) ; 114.07,85.95 114.07,86.19 113.84,86.41 v1(113.58,86.41)
SSD_PCIE_TX_P1: length 137.4
  L3 w0.102: v1(115.13,86.46) 115.49,86.82 115.49,87.13 116.1,87.73 120.6,87.73 122.68,85.65 128.51,85.65 129.15,86.29 133.06,86.29 133.26,86.49 133.95,86.49 136.08,88.62 139.78,88.62 141.53,86.87 144.98,86.87 147.97,83.87 154.28,83.87 164.36,73.8 164.36,72.55 165.25,71.66 165.25,69.83 171.19,63.88 171.19,63.63 173.83,60.99 173.83,46.84 186.89,33.78 189.48,33.78 192.04,31.22 192.73,31.22 194.99,28.96 195.57,28.96 199.46,25.07 199.46,23.24 200.86,21.85 200.86,21.24 200.62,21 200.36,21 v1(200.07,20.7)
  BOTTOM w0.076: v1(115.13,86.46) 115.18,86.41 115.46,86.41 115.72,86.15 115.72,85.52 115.97,85.26 115.97,85.12 116.21,84.88 116.21,83.35 CPU1.BM3
  BOTTOM w0.102: 200.76,21.1 200.94,21.28 203.82,21.28 C6311.2 ; 200.76,21.1 200.62,20.96 200.33,20.96 v1(200.07,20.7) ; 200.76,21.1 v2(200.86,21.01)
SSD_PCIE_TX_P2: length 148.4
  L3 w0.102: v1(112.02,87.95) 112.02,88.13 112.22,88.33 112.97,88.33 114,89.36 120.3,89.36 121.97,91.04 124.25,91.04 126.79,88.5 133.53,88.5 135.33,90.3 145.4,90.3 145.81,89.89 151.89,89.89 161.54,80.24 161.54,79.09 166.16,74.47 166.16,73.1 166.87,72.39 166.87,70.51 172.82,64.56 172.82,64.33 175.46,61.69 175.46,48.1 184.29,39.27 184.47,39.27 185.44,38.31 189.91,38.31 192.93,35.28 192.93,33.33 195.68,30.58 196.29,30.58 202.81,24.06 202.81,20.2 202.99,20.02 v1(203.3,20.02)
  BOTTOM w0.102: CPU1.BL1 115.59,84.44 114.5,85.53 114.5,86.64 arc(114.45,86.88) 114.32,87.08 113.09,88.31 112.12,88.31 112.02,88.2 v1(112.02,87.95) ; v1(203.3,20.02) 203.3,20.2 203.4,20.3 204.19,20.3 204.34,20.15 204.34,18.62 ; C6313.2 205.04,18.05 204.78,18.05 204.34,18.49 204.34,18.62 ; 204.34,18.62 v2(204.21,18.62)
SSD_PCIE_TX_P3: length 167.3
  L3 w0.102: v1(113.55,87.14) 113.22,87.14 113.05,86.97 113.05,86.62 112.44,86.01 111.73,86.01 111.47,86.26 111.47,89.15 112.08,89.76 112.08,89.82 113.63,91.37 119.15,91.37 119.42,91.65 124.67,91.65 127.21,89.11 133.28,89.11 135.08,90.91 145.66,90.91 146.06,90.5 152.14,90.5 162.22,80.42 162.22,79.28 166.77,74.73 166.77,73.36 167.48,72.65 167.48,70.76 173.43,64.82 173.43,64.61 176.07,61.97 176.07,48.36 184.54,39.89 184.85,39.89 185.8,38.94 190.19,38.94 193.57,35.56 193.57,33.57 195.95,31.19 196.71,31.19 203.29,24.62 207.33,24.62 208.37,23.58 208.37,17.63 208.38,17.63 208.38,17.27 208.37,17.27 208.37,16.79 205.94,14.35 203.76,14.35 203.42,14.69 203.42,15.45 203.85,15.88 204.44,15.88 204.57,15.75 204.57,15.52 204.46,15.41 v1(204.22,15.41)
  BOTTOM w0.076: CPU1.BL3 115.35,83.48 115.35,83.48 115.34,83.53 115.34,83.69 115.36,83.86 115.36,84.04 115.29,84.3 115.19,84.55 115.09,84.68 114.27,85.5 114.27,85.91 114.29,85.93 114.29,85.95
  BOTTOM w0.102: v1(113.55,87.14) 113.64,87.23 113.81,87.23 114,87.04 114,86.58 114.29,86.29 114.29,85.95 ; C6315.2 204.86,15.61 204.62,15.85 204.32,15.85 204.22,15.75 v1(204.22,15.41)
SSD_SATA_C_TX_N: length 1.8
  BOTTOM w0.102: R6313.1 200.23,18.77 R6317.1 199.16,18.48 199.16,18.27 C6303.2
SSD_SATA_C_TX_P: length 1.8
  BOTTOM w0.102: R6314.1 R6318.1 198.91,18.47 198.91,18.33 C6302.2
SSD_SATA_RX_CON_N: length 12.9
  BOTTOM w0.102: R6316.1 200.9,18 R6311.1 202.1,17.47 202.1,16.94 ; 202.1,16.94 v2(201.95,16.94) ; 202.1,16.94 202.1,16.66 201.9,16.45 201.9,15.66 203.46,14.1 204.3,14.1 204.31,14.09 ED6301.9 ED6301.2 205.88,14.09 206.11,14.33 206.22,14.33 207.59,12.96 207.59,12.58 207.95,12.22 208.2,12.22 208.47,11.95 SSD1.43
SSD_SATA_RX_CON_P: length 12.2
  BOTTOM w0.102: R6315.1 203.03,18 R6312.1 202.33,16.56 202.13,16.36 202.13,15.75 202.84,15.04 ; 202.84,15.04 v2(202.97,15.17) ; 202.84,15.04 203.55,14.33 204.21,14.33 204.47,14.59 ED6301.10 ED6301.1 205.88,14.59 205.91,14.56 206.32,14.56 207.82,13.06 207.82,12.68 208.04,12.45 SSD1.41
SSD_SATA_RX_N: length 141.1
  L3 w0.102: v1(201.43,20.73) 201.75,20.73 201.85,20.83 201.85,20.93 202,21.08 202,21.31 199.92,23.4 199.92,25.22 195.77,29.37 195.16,29.37 192.9,31.63 192.21,31.63 191.08,32.76 191.08,33.94 187.98,37.04 184.96,37.04 183.94,38.05 183.73,38.05 174.24,47.54 174.24,61.16 171.6,63.8 171.6,64.05 165.65,70 165.65,71.83 164.87,72.62 164.87,73.96 154.04,84.79 147.82,84.79 145.33,87.28 141.7,87.28 139.95,89.03 135.88,89.03 134.11,87.25 125.88,87.25 125.65,87.02 122.07,87.02 120.54,88.55 114.95,88.55 114.22,87.81 114.22,85.96 113.53,85.27 112.61,85.27 111.47,84.13 111.47,81.89 111.58,81.78 v1(111.77,81.78)
  BOTTOM w0.102: v1(201.43,20.73) 201.43,20.72 201.72,20.42 201.72,19.77 202.03,19.47 202.03,19.32 R6311.2 ; CPU1.BE5 111.98,81.57 v1(111.77,81.78)
SSD_SATA_RX_N1: length 132.3
  L3 w0.089: v1(115.46,80.52) 115.93,80.99 115.93,81.07 116.03,81.17 116.03,82.08 116.06,82.11 116.06,82.11
  L3 w0.102: v1(201.44,16) 201.55,16.11 201.55,17.39 201.39,17.55 199.85,17.55 199.84,17.55 195.52,17.55 194.56,18.52 191.97,18.52 189.3,21.19 189.3,24 183.79,29.51 183.79,30.36 167.63,46.51 167.63,48.29 164.86,51.06 164.86,55.61 163.11,57.36 163.11,59.06 159.73,62.44 159.73,69.63 159.14,70.21 159.14,72.07 152.8,78.41 148.99,78.41 148.69,78.11 147.85,78.11 147.47,77.73 145.85,77.73 144.58,76.46 137.88,76.46 136.28,78.06 135.15,78.06 134.18,79.02 132.79,79.02 132.51,79.3 129.88,79.3 128.87,80.31 128.87,81.33 127.5,82.71 116.66,82.71 116.06,82.11
  BOTTOM w0.102: CPU1.BL6 115.86,80.92 v1(115.46,80.52) ; v1(201.44,16) 200.81,16.64 R6316.2
SSD_SATA_RX_P: length 141.9
  L3 w0.102: v1(202.28,20.73) 202.2,20.81 202.2,21.4 200.12,23.48 200.12,25.3 195.85,29.57 195.24,29.57 192.98,31.83 192.3,31.83 191.28,32.84 191.28,34.02 188.06,37.24 185.04,37.24 184.03,38.26 183.81,38.26 174.44,47.63 174.44,61.24 171.8,63.88 171.8,64.14 165.86,70.08 165.86,71.92 165.07,72.71 165.07,74.04 154.12,84.99 147.91,84.99 145.42,87.48 141.79,87.48 140.03,89.23 135.8,89.23 134.02,87.45 125.79,87.45 125.56,87.23 122.15,87.23 120.63,88.75 114.87,88.75 114.01,87.9 114.01,86.04 113.45,85.47 112.53,85.47 111.27,84.22 111.27,81.63 v1(111.77,81.14)
  BOTTOM w0.102: R6312.2 202.25,18.94 202.25,19.56 201.95,19.87 201.95,20.4 v1(202.28,20.73) ; CPU1.BE6 v1(111.77,81.14)
SSD_SATA_RX_P1: length 133.1
  L3 w0.089: 115.88,82.22 115.87,82.21 115.87,82.19 115.84,82.16 115.84,81.25 115.75,81.16 v1(115.46,81.16)
  L3 w0.102: v1(202.56,15.98) 202.13,15.98 201.75,16.36 201.75,17.47 201.48,17.75 199.93,17.75 199.93,17.76 195.61,17.76 194.64,18.72 192.05,18.72 189.5,21.27 189.5,24.08 183.99,29.59 183.99,30.44 167.84,46.59 167.84,48.37 165.06,51.15 165.06,55.69 163.31,57.45 163.31,59.15 159.93,62.53 159.93,69.72 159.35,70.3 159.35,72.15 152.88,78.62 148.91,78.62 148.6,78.31 147.76,78.31 147.38,77.93 145.76,77.93 144.49,76.66 137.97,76.66 136.37,78.26 135.23,78.26 134.27,79.23 132.87,79.23 132.59,79.5 129.96,79.5 129.08,80.39 129.08,81.42 127.59,82.91 116.57,82.91 115.88,82.22
  BOTTOM w0.102: CPU1.BL5 115.86,81.57 115.46,81.17 v1(115.46,81.16) ; v1(202.56,15.98) 202.56,16.15 203.09,16.69 R6315.2
SSD_SATA_TX_CON_N: length 14.5
  BOTTOM w0.102: 200.02,16.26 200.37,16.26 203.81,12.82 204.18,12.82 204.45,13.09 ED6301.7 ED6301.4 206.08,13.09 206.21,12.96 206.62,12.96 207.21,12.37 207.21,11.64 207.99,10.85 208.45,10.85 208.55,10.95 SSD1.47 ; 200.02,16.26 v2(200.02,16.44) ; 200.02,16.26 199.1,16.26 198.85,16.51 198.85,16.69 199.28,17.12 C6303.1
SSD_SATA_TX_CON_P: length 14.5
  BOTTOM w0.102: C6302.1 198.62,16.41 199,16.03 200.28,16.03 203.48,12.83 ; v2(203.37,12.73) 203.48,12.83 ; 203.48,12.83 203.72,12.59 ED6301.6 ED6301.5 206.08,12.59 206.21,12.73 206.53,12.73 206.98,12.28 206.98,11.54 207.9,10.62 208.38,10.62 208.55,10.45 SSD1.49
SSD_SATA_TX_N: length 145.8
  L3 w0.102: v1(112.04,87.18) 112.69,87.18 114.67,89.16 120.67,89.16 122.07,90.55 124.15,90.55 126.61,88.09 133.7,88.09 135.5,89.89 143.53,89.89 144.82,88.6 145.16,88.6 145.7,88.06 151.95,88.06 158.93,81.08 160.12,81.08 161.13,80.07 161.13,78.9 161.14,78.89 161.14,78.87 165.75,74.26 165.75,72.91 166.47,72.2 166.47,70.34 172.41,64.39 172.41,64.14 175.05,61.5 175.05,47.89 184.08,38.86 184.28,38.86 185.27,37.87 188.39,37.87 191.89,34.38 191.89,33.11 192.43,32.57 193.11,32.57 195.5,30.18 196.11,30.18 202.1,24.18 v1(202.1,23.22)
  BOTTOM w0.076: CPU1.BJ4 114.51,82.82 114.52,82.84 114.67,83.37 114.7,83.45 114.73,83.52 114.73,83.6 114.68,83.87 114.68,84.01 114.7,84.15 114.71,84.16 114.71,84.53 113.83,85.4 113.48,85.4 113.46,85.42 113.44,85.42
  BOTTOM w0.102: v2(201.67,22.15) 201.56,22.27 ; 201.56,22.27 201.9,22.61 201.9,23.02 v1(202.1,23.22) ; 201.56,22.27 201.24,21.95 199.77,21.95 199.13,21.31 199.13,19.97 R6317.2 ; v1(112.04,87.18) 112.12,87.1 112.55,87.1 112.66,86.99 ; 113.44,85.42 112.98,85.42 112.78,85.63 112.78,86.86 112.66,86.99 ; 112.66,86.99 v2(112.8,87.12)
SSD_SATA_TX_N1: length 130.9
  L3 w0.102: v1(116.22,85.61) 116.12,85.71 115.93,85.71 115.78,85.56 115.78,85.18 116.33,84.64 128.91,84.64 129.19,84.36 134.31,84.36 135.88,82.78 138.7,82.78 141.57,85.65 144.17,85.65 147.17,82.65 153.75,82.65 162.94,73.47 162.94,68.67 164.79,66.81 164.79,65.8 172.21,58.38 172.21,45.8 186.66,31.35 186.66,30.71 190.67,26.7 191.94,26.7 192.27,26.37 197.28,26.37 198.76,24.89 198.76,20.42 198.86,20.32 v1(199.56,20.32)
  BOTTOM w0.076: CPU1.BN2 116.72,83.83 116.41,84.13 116.41,85.4 116.22,85.59 v1(116.22,85.61)
  BOTTOM w0.102: v1(199.56,20.32) 199.62,20.32 200.25,19.69 R6313.2
SSD_SATA_TX_P: length 145.5
  L3 w0.102: v1(112.04,86.43) 112.31,86.43 112.42,86.54 112.42,86.89 112.51,86.98 112.78,86.98 114.75,88.95 120.75,88.95 122.15,90.35 124.07,90.35 126.53,87.89 133.78,87.89 135.59,89.69 143.45,89.69 144.74,88.39 145.08,88.39 145.61,87.86 151.86,87.86 158.85,80.88 160.04,80.88 160.93,79.99 160.93,78.79 165.55,74.17 165.55,72.82 166.26,72.11 166.26,70.25 172.21,64.31 172.21,64.05 174.85,61.41 174.85,47.81 183.99,38.66 184.19,38.66 185.19,37.67 188.31,37.67 191.69,34.29 191.69,33.02 192.35,32.36 193.03,32.36 195.41,29.97 196.02,29.97 201.9,24.1 201.9,23.65 201.47,23.22 v1(201.31,23.22)
  BOTTOM w0.076: 113.44,85.19 113.46,85.19 113.48,85.22 113.76,85.22 114.53,84.45 114.53,84.18 114.5,84.02 114.5,83.85 114.53,83.67 114.53,83.53 114.53,83.51 CPU1.BJ3
  BOTTOM w0.102: 113.44,85.19 112.89,85.19 112.55,85.53 112.55,86.77 112.45,86.87 112.32,86.87 112.15,86.69 112.14,86.69 112.04,86.59 v1(112.04,86.43) ; 198.9,21.08 198.9,19.95 R6318.2 ; 198.9,21.08 198.9,21.4 199.67,22.18 201.14,22.18 201.67,22.7 201.67,23.12 201.57,23.22 v1(201.31,23.22) ; 198.9,21.08 v2(198.72,21.08)
SSD_SATA_TX_P1: length 130.9
  L3 w0.102: v1(116.13,86.24) 116.13,86.2 115.58,85.65 115.58,85.1 116.24,84.43 128.82,84.43 129.1,84.15 134.23,84.15 135.8,82.58 138.78,82.58 141.65,85.45 144.09,85.45 147.09,82.45 153.66,82.45 162.73,73.38 162.73,68.58 164.59,66.73 164.59,65.71 172,58.3 172,45.71 186.46,31.26 186.46,30.63 190.59,26.49 191.86,26.49 192.19,26.16 197.19,26.16 198.55,24.8 198.55,20.48 198.45,20.37 v1(197.83,20.37)
  BOTTOM w0.076: v1(116.13,86.24) 116.14,86.24 116.37,86 116.38,86 116.61,85.77 116.61,85.45 116.61,85.44 116.6,85.18 116.59,85.17 116.59,84.39 CPU1.BN1
  BOTTOM w0.102: v1(197.83,20.37) R6314.2
SSD_SCP#: length 241.1
  TOP w0.102: v1(222.19,24.54) 221.43,23.78 R2430.2 ; U2401.21 47.71,45.31 48.41,46 48.41,46.21 48.76,46.56 51.28,46.56 R2490.2 51.91,45.37 v1(52.04,45.24)
  L3 w0.102: v1(92.98,10.42) 92.98,9.63 92.65,9.3 91.76,9.3 90.79,10.28 83.88,10.28 82.82,9.22 79.5,9.22 78.23,10.49 76.65,10.49 76.35,10.19 76.35,9.58 76.07,9.3 74.62,9.3 74.24,9.68 74.24,10.01 73.86,10.39 73.66,10.39 70.72,13.34 67.85,13.34 63.3,17.89 63.3,19.35 61.5,21.15 61.5,31.87 57.83,35.54 56.88,35.54 56.18,36.24 56.18,40.19 54.68,41.68 54.68,42.22 53.79,43.11 53.36,43.11 52.04,44.43 v1(52.04,45.24) ; v1(104.92,19.87) 105.53,20.48 150.18,20.48 150.24,20.42 151.78,20.42 151.84,20.48 173.73,20.48 175.28,22.02 176.07,22.02 176.47,22.43 178.15,22.43 178.76,23.04 180.49,23.04 184.8,18.72 189.1,18.72 189.58,18.24 190.93,18.24 191.54,17.63 194.2,17.63 195.14,16.69 199.18,16.69 200.96,14.91 201.64,14.91 204.08,12.47 204.08,8.77 205.84,7.01 209.98,7.01 210.46,6.53 210.48,6.53 210.74,6.28 219.3,6.28 222.22,9.2 222.22,24.51 v1(222.19,24.54)
  BOTTOM w0.102: v1(104.92,19.87) 103.67,21.12 102.88,21.12 99.72,17.96 v2(99.72,17.63) 99.72,17.42 98.03,15.73 96.39,15.73 95.63,14.96 95.63,14.39 95.93,14.08 95.93,12.87 93.48,10.42 v1(92.98,10.42)
SSD_SCP#_M2: length 10.1
  TOP w0.102: v1(215.23,21.31) 215.23,21.47 v2(215.68,21.91) 216.4,22.64 216.4,24.03 216.91,24.54 217.29,24.54 218.51,23.32 219.2,23.32 219.6,22.91 R2430.1
  BOTTOM w0.102: SSD1.8 215.85,20.7 v1(215.23,21.31)
SSEQ0_A0: length 8.4
  TOP w0.102: U7301.11 25.32,68 25.01,67.69 v1(25.01,67.24) 25.42,66.83 25.42,65.71 25.62,65.5 25.62,63.81 24.99,63.17 v2(24.99,62.97) 25.11,62.84 R7324.1
  BOTTOM w0.102: v1(25.01,67.24) 24.99,67.26 R7323.2
SSEQ1: length 4.4
  TOP w0.102: R7322.1 R7327.2 21.69,69.93 21.69,70.54 22.07,70.92 v2(22.09,70.92) 22.42,71.24 U7301.3
STRAP0: length 8
  BOTTOM w0.127: R7919.2 178.33,67.92 R7908.1 178.01,68.83 178.07,68.83 178.07,68.84 178.53,68.84 179.22,69.52 179.22,70.08 v2(179.06,70.23) 179.06,70.34 179.57,70.84 180.36,70.84 181.1,70.11 181.45,70.11 181.71,70.36 181.71,70.38 GPU1.D1
STRAP1: length 6.2
  BOTTOM w0.127: GPU1.D2 182.96,71.09 181.72,69.85 180.94,69.85 180.49,70.31 v2(180.28,70.31) 179.6,69.62 R7911.1 R7909.2
STRAP2: length 9
  TOP w0.127: R7915.1 v2(179.89,66.87) 180.51,67.49 R7914.2 180.54,67.77 182.29,69.52 182.29,69.9 182.8,70.41 182.8,72.13 v1(183.49,72.82)
  BOTTOM w0.127: GPU1.E4 v1(183.49,72.82)
STRAP3: length 8.4
  TOP w0.127: R7925.2 178.33,67.92 R7926.1 178.04,68.86 178.76,68.86 v2(178.8,68.9) 180.44,70.54 v1(181.27,70.54)
  BOTTOM w0.127: GPU1.E3 182.92,72.13 182.04,71.25 182.04,71.21 181.72,70.89 181.63,70.89 v1(181.27,70.54)
STRAP4: length 9.5
  TOP w0.127: v1(183.52,71.64) 183.52,70.8 182.52,69.8 182.52,69.37 181.1,67.95 181.1,66.94 180.31,66.16 R7929.1 R7928.2 181.07,65.26 v2(181.07,64.37)
  BOTTOM w0.127: v1(183.52,71.64) 183.52,71.65 GPU1.D3
STRAP5: length 4.4
  BOTTOM w0.089: GPU1.C1 181.58,69.12 181.58,68.43 v2(181.1,67.95) 180.46,67.31 R7976.2
STRAP5_L: length 3.2
  BOTTOM w0.089: R7939.1 177.29,66.42 177.76,65.98 178.02,65.71 v2(178.15,65.71) 178.43,65.71 178.81,66.09 179.07,66.09 R7938.2 179.14,66.14 R7976.1
STRAP_REF0_GND_N9: length 8.1
  TOP w0.102: v1(183.48,75.14) 183.48,74.65 182.57,73.74 181.53,73.74 R7907.2 v2(178.26,70.48)
  BOTTOM w0.102: v1(183.48,75.14) 183.51,75.17 GPU1.F6
SUS_CLK: length 227.5
  TOP w0.089: R2428.2 46.22,33.94 46.6,34.32 v1(46.73,34.32) ; v1(73.27,42.22) 78.33,37.16 100.35,37.16 101.66,38.46 112.36,38.46 v2(112.77,38.06) 113.15,37.68 121.5,37.68 123.18,39.36 123.18,45.75 v1(122.8,46.13) 122.78,46.15 EC1803.2 ; FC1801.2 118.89,53.55 118.31,54.13 118.31,55.81 119.1,56.6 v1(119.1,56.88) 119.07,56.85 118.76,56.85 117.91,57.7 117.91,59.32 118.08,59.49 118.08,63.66 118.98,64.56 v1(118.98,64.98) ; R6135.1 201.85,50.12 202.03,49.94 v1(202.03,48.95)
  L3 w0.114: v1(46.73,34.32) 46.12,34.93 46.12,38.46 45.4,39.18 45.4,40.2 44.59,41 44.59,42.11 45.95,43.47 v1(45.95,44.09)
  L6 w0.089: v1(194.89,34.85) 194.89,35.36 191.58,38.66 183.15,38.66 182.6,39.21 179.81,39.21 176.07,42.95 168.17,42.95 167.4,42.19 163.7,42.19 162.81,43.07 160.92,43.07 159.81,44.18 v1(159.81,44.61)
  BOTTOM w0.089: v1(73.27,42.22) 67.36,42.22 66.67,42.91 58.87,42.91 58.49,43.28 58.49,43.31 58.06,43.74 58.03,43.74 57.6,44.17 55.84,44.17 54.93,43.26 53.72,43.26 53.38,43.6 51.83,43.6 51.76,43.52 50.18,43.52 49.61,44.09 v1(45.95,44.09) ; v1(202.03,48.95) 202.03,47.25 194.41,39.63 194.41,35.33 v1(194.89,34.85) ; CPU1.BT32 118.82,64.91 118.91,64.91 v1(118.98,64.98) ; v1(119.1,56.88) 118.31,56.09 118.31,54.29 120.57,52.03 120.57,51.13 120.67,51.03 120.67,50.22 120.85,50.04 120.85,49.34 120.85,49.33 120.85,47.94 121.62,47.17 121.77,47.17 122.8,46.14 v1(122.8,46.13) 122.8,45.42 123.28,44.94 129.95,44.94 130.09,44.81 135.59,44.81 136.4,44 149.75,44 150.91,45.16 157.28,45.16 158.03,44.41 159.72,44.41 159.81,44.5 v1(159.81,44.61)
SUSACK#_R: length 18.6
  TOP w0.127: v1(121.36,51.64) 121.15,51.84 R1708.2 ; v1(123.65,51.21) 123.82,51.38 v2(123.82,52.35) 123.82,52.48 124.3,52.96 124.3,57.46 122.6,59.16 122.6,61.78 121.88,62.5 121.88,64.18 121.71,64.34 v1(121.71,64.35)
  BOTTOM w0.127: v1(121.36,51.64) 121.65,51.94 122.92,51.94 v1(123.65,51.21) ; v1(121.71,64.35) 121.69,64.37 121.69,64.38 121.44,64.63 CPU1.BY32
SUSCLK_WLAN: length 3.7
  TOP w0.254: v1(201.85,52.2) 202.15,52.2 202.48,51.87 v2(202.48,51.79) 202.48,51.64 R6135.2
  BOTTOM w0.254: WLAN1.50 201.46,52.79 201.85,52.4 v1(201.85,52.2)
SVID_ALERT#_CPU: length 94.6
  TOP w0.089: PR4605.2 40.2,61.52 39.69,61.01 39.67,61.01 39.01,60.35 v1(38.81,60.35) v2(38.34,59.88)
  L3 w0.127: v1(38.81,60.35) 38.81,63.38 36.67,65.51 36.67,71.4 40,74.73 40,76 40.55,76.55 40.55,77.1 39.46,78.19 39.46,78.87 39.85,79.25 39.85,80.01 41.45,81.61 41.45,84.2 42.31,85.07 42.31,87.95 46.97,92.61 65.81,92.61 66.59,93.4 71.62,93.4 72.13,92.89 72.16,92.89 72.21,92.84 79.7,92.84 80.77,93.91 93.76,93.91 v1(96.05,91.61)
  BOTTOM w0.089: PR4623.1 39.06,60.91 38.81,60.66 v1(38.81,60.35) ; v1(96.05,91.61) 96.17,91.49 R728.1 R727.2
SVID_ALERT#_CPU_R: length 9.3
  BOTTOM w0.076: 97.41,85.04 97.53,84.6 97.54,84.58 97.6,84.39 97.61,84.33 97.61,84.13 97.57,84.05 97.45,83.54 CPU1.AA3
  BOTTOM w0.089: v2(97.78,90.55) 97.71,90.63 R728.2 96.74,89.79 96.94,89.59 96.94,89.24 96.71,89 96.71,86.46 97.41,85.76 97.41,85.04
SVID_CLK_CPU: length 91.3
  TOP w0.089: v1(40.02,60) 40.13,59.9 40.13,59.62 39.83,59.32 v2(39.59,59.32) 38.41,59.32 37.99,59.74 37.99,60.25 38.77,61.04 38.96,61.04 39.44,61.52 PR4606.2
  L3 w0.127: v1(40.02,60) 40.02,63.63 37.69,65.97 37.69,66.75 39.19,68.25 39.19,71.33 41.69,73.83 41.69,74.85 42.28,75.44 42.28,75.98 42.27,75.98 42.27,79.16 44.32,81.21 44.32,83.87 45,84.56 45,85.14 49.8,89.94 54.73,89.94 55.39,90.61 55.39,90.76 55.42,90.78 55.42,90.81 55.67,91.06 64.26,91.06 64.56,90.76 80,90.76 81.12,91.87 81.12,91.98 81.98,92.84 93.21,92.84 93.57,92.48 v1(93.57,91.62)
  BOTTOM w0.089: v1(40.02,60) 40.02,59.69 39.72,59.39 38.78,59.39 PR4624.1 ; R732.2 93.17,90.35 R723.2 93.17,91.23 v1(93.57,91.62)
SVID_CLK_CPU_R: length 7.6
  BOTTOM w0.089: CPU1.AA1 97,84.46 97,85.63 96.35,86.27 96.35,88.31 95.21,89.44 94.82,89.44 94.74,89.52 v2(94.74,89.54) 94.05,90.22 R732.1
SVID_DATA_CPU: length 90.7
  TOP w0.089: v1(39.29,59.87) 39.29,59.9 40,60.61 40.23,60.61 40.53,60.3 v2(40.63,60.3) 40.96,60.63 PR4604.2
  L3 w0.127: v1(95.48,91.32) 93.45,93.35 80.94,93.35 79.93,92.33 71.36,92.33 70.77,91.75 69.39,91.75 69.36,91.72 69.01,91.72 68.98,91.75 67.25,91.75 67.13,91.62 66.24,91.62 66.21,91.6 49.22,91.6 48.97,91.34 48.97,91.33 46.04,88.41 46.04,86.92 44.16,85.04 44.16,84.69 43.81,84.33 43.81,81.44 41.73,79.35 41.73,76.3 41.02,75.59 41.02,74.12 38.6,71.71 38.6,70.74 38.13,70.27 38.13,69.59 38.13,69.59 38.13,67.94 37.18,66.98 37.18,65.74 39.31,63.6 39.31,59.89 v1(39.29,59.87)
  BOTTOM w0.089: R709.2 95.64,91.15 95.48,91.31 v1(95.48,91.32) ; PR4622.1 40.02,60.45 39.82,60.45 39.29,59.93 v1(39.29,59.87)
SVID_DATA_CPU_R: length 8.6
  BOTTOM w0.076: CPU1.AA2 97.44,84.16 97.44,84.32 97.44,84.36 97.39,84.52 97.26,84.74
  BOTTOM w0.089: R726.2 94.84,90.33 95.37,89.79 R709.1 96.13,89.79 v2(96.54,89.39) 96.53,89.38 96.53,86.39 97.2,85.72 97.2,84.94 97.26,84.74
