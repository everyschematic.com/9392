# Allegro board 17859-1.0710WZS1337.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_DQM0: length 16.2
  L6 w0.112: v1(193.45,81.57) 194.7,80.32 195.92,80.32 199.35,76.89 202.03,76.89 203.14,78.01 v1(206.07,78.01)
  BOTTOM w0.114: GPU1.D19 193.43,81.54 v1(193.45,81.57) ; v1(206.07,78.01) VRAM1.D2
FBA_DQM1: length 24.5
  L6 w0.112: v1(206.08,69.21) 206.08,68.06 205.57,67.56 202.77,67.56 199.94,70.39 196.66,70.39 192.7,74.34 192.7,74.73 189.99,77.45 189.99,78.29 189.68,78.6 v1(189.38,78.6)
  BOTTOM w0.114: v1(206.08,69.21) 206.46,69.6 VRAM1.D13 ; GPU1.D14 189.41,78.63 v1(189.38,78.6)
FBA_DQM2: length 32
  L3 w0.112: v1(192.64,76.77) 194.48,76.77 199.82,71.43 200.16,71.43 203.16,68.44 203.16,68.14 203.4,67.9 203.7,67.9 204.58,67.01 213.42,67.01 214.09,67.69 214.09,68.46 v1(214.83,69.19)
  BOTTOM w0.114: GPU1.C17 192.28,79.19 192.78,78.69 192.78,78.66 193.19,78.25 193.19,77.31 v1(192.64,76.77) ; v1(214.83,69.19) 214.83,69.23 VRAM1.P13
FBA_DQM3: length 26.4
  L3 w0.112: v1(214.6,80.22) 212.78,82.03 203.56,82.03 201.29,79.77 v1(201.29,78.72)
  BOTTOM w0.114: VRAM1.P2 214.46,78.43 214.83,78.79 214.83,79.99 v1(214.6,80.22) ; GPU1.C22 195.19,82.2 196.17,81.23 197.32,81.23 200.04,78.51 201.08,78.51 v1(201.29,78.72)
FBA_DQM4: length 18.7
  L6 w0.112: v1(206.08,90.2) 205.53,89.65 196.45,89.65 196.24,89.44 192.82,89.44 191.49,90.77 191.49,91.06 191.24,91.3 190.9,91.3 190.57,90.98 v1(189.97,90.98)
  BOTTOM w0.114: v1(189.97,90.98) 189.96,90.97 GPU1.P24 ; v1(206.08,90.2) 206.08,90.22 VRAM4.P2
FBA_DQM5: length 23.4
  L6 w0.112: v1(187,93.9) 187.29,93.9 188.83,95.44 195.2,95.44 199.08,99.32 206.5,99.32 v1(206.83,98.99)
  BOTTOM w0.114: v1(206.83,98.99) 206.46,99.36 VRAM4.P13 ; GPU1.W24 187.05,93.85 v1(187,93.9)
FBA_DQM6: length 38.6
  L6 w0.112: v1(215.24,101.52) 215.24,101.57 213.99,102.82 211.34,102.82 210.82,103.34 198.41,103.34 194.09,99.03 190.67,99.03 190.34,99.36 189.93,99.36 189.08,100.21 188.21,100.21 187.87,99.87 187.87,99.21 v1(188.05,99.04)
  BOTTOM w0.114: VRAM4.D13 214.83,99.77 214.83,101.11 v1(215.24,101.52) ; GPU1.AA25 186.42,95.59 187.36,96.53 187.36,96.85 187.8,97.28 187.8,98.79 v1(188.05,99.04)
FBA_DQM7: length 34.2
  L3 w0.112: v1(198.64,93.95) 199.34,93.25 200.89,93.25 202.36,91.78 202.36,89.76 205.02,87.1 213.56,87.1 214.14,87.68 v1(214.14,87.91)
  BOTTOM w0.114: v1(214.14,87.91) 214.14,88.7 214.04,88.8 214.04,90.18 VRAM4.D2 ; GPU1.U25 188.94,92.85 188.94,93.38 189.38,93.82 189.55,93.82 189.9,94.17 189.9,94.17 190.4,94.67 197.91,94.67 v1(198.64,93.95)
FBA_EDC0: length 17.1
  L6 w0.112: v1(202.43,78.01) 201.77,77.35 200.3,77.35 198.08,79.57 198.08,79.87 196.99,80.95 194.66,80.95 192.91,82.7 v1(192.31,82.7)
  BOTTOM w0.114: VRAM1.C2 205.27,78.79 203.21,78.79 v1(202.43,78.01) ; v1(192.31,82.7) 192.31,82.7 GPU1.E19
FBA_EDC1: length 22.4
  L6 w0.112: v1(190.53,77.5) 191.13,77.5 191.58,77.04 191.58,76.42 193.16,74.84 193.16,74.4 196.8,70.77 200.12,70.77 203.12,67.77 204.54,67.77 v1(204.97,68.2)
  BOTTOM w0.114: VRAM1.C13 205.66,69.47 205.25,69.07 205.25,68.48 v1(204.97,68.2) ; v1(190.53,77.5) 190.95,77.92 190.95,78.49 GPU1.C15
FBA_EDC2: length 32.7
  L3 w0.112: v1(214.85,70.01) 215.24,69.62 215.24,68.66 215.06,68.48 215.06,67.93 213.93,66.8 204.2,66.8 199.95,71.05 199.66,71.05 194.96,75.75 v1(193.55,75.75)
  BOTTOM w0.114: v1(214.85,70.01) 215.26,69.6 VRAM1.R13 ; v1(193.55,75.75) 192.95,75.75 192.19,76.51 192.19,76.94 192.62,77.37 192.62,77.71 192.25,78.08 GPU1.B16
FBA_EDC3: length 25.1
  L3 w0.112: v1(215.18,80.48) 213.24,82.41 203.4,82.41 200.67,79.68 v1(200.4,79.68)
  BOTTOM w0.114: GPU1.B22 195.9,82.02 196.57,82.02 196.71,81.88 196.98,81.88 198.79,80.07 199.03,80.07 199.65,79.44 200.16,79.44 v1(200.4,79.68) ; VRAM1.R2 215.67,78.81 215.67,79.36 215.68,79.37 215.68,80.01 215.21,80.48 v1(215.18,80.48)
FBA_EDC4: length 17.1
  L6 w0.112: v1(190.49,91.52) 190.51,91.53 191.34,91.53 191.72,91.15 191.72,90.86 192.91,89.67 195.88,89.67 196.24,90.02 205.08,90.02 v1(205.26,90.2)
  BOTTOM w0.114: v1(190.49,91.52) 190.48,91.53 GPU1.R25 ; v1(205.26,90.2) VRAM4.R2
FBA_EDC5: length 25.8
  L6 w0.112: v1(186.44,93.3) 187,93.3 188.77,95.07 195.4,95.07 198.43,98.11 198.61,98.11 199.62,97.1 199.81,97.1 199.94,97.23 199.94,97.41 198.93,98.42 198.93,98.61 199.19,98.87 v1(201.42,98.87)
  BOTTOM w0.114: v1(201.42,98.87) 201.44,98.87 202.37,99.8 205.3,99.8 205.66,99.44 VRAM4.R13 ; GPU1.W23 186.48,93.27 v1(186.44,93.3)
FBA_EDC6: length 38.9
  L6 w0.112: v1(215.9,101.57) 214.27,103.2 211.47,103.2 210.97,103.71 198.26,103.71 193.94,99.39 190.61,99.39 190.43,99.57 190.02,99.57 188.75,100.84 v1(187.98,100.84)
  BOTTOM w0.114: GPU1.AB26 186.61,96.36 186.61,96.89 186.98,97.25 186.98,97.25 187.52,97.8 187.52,99.14 187.87,99.49 187.87,100.73 v1(187.98,100.84) ; VRAM4.C13 215.26,99.42 215.67,99.82 215.67,101.34 v1(215.9,101.57)
FBA_EDC7: length 33.6
  L3 w0.112: v1(197.32,93.93) 198.82,92.43 201.16,92.43 201.98,91.62 201.98,89.57 204.83,86.72 213.78,86.72 214.97,87.92 v1(214.97,88.54)
  BOTTOM w0.114: v1(197.32,93.93) 197.11,94.14 191.45,94.14 190.91,93.6 190.34,93.6 189.93,93.19 GPU1.T26 ; VRAM4.C2 214.85,90.19 214.85,89.59 214.97,89.47 v1(214.97,88.54)
FBA_PLL_AVDD: length 25.9
  TOP w0.508: 197,74.44 193.75,77.7 193.75,78.42 194.01,78.68 194.01,79.57 190.86,82.72 190.11,82.72
  L3 w0.508: v1(189.4,80.94) 189.38,80.96 189.38,81.9 191.76,84.28 v1(191.76,85.7) 190.39,85.7 189.25,86.85 188.24,86.85 187.72,87.36 187.72,88.23 v1(187.61,88.33)
  BOTTOM w0.356: GPU1.H22 v1(191.76,85.7) ; v1(187.61,88.33) 187.92,88.33 GPU1.P22 ; GPU1.F16 189.4,80.95 v1(189.4,80.94)
  vias: v2(188.84,80.47)
FBA_VREF_FET_L: length 7.5
  TOP w0.508: R8105.1 210.9,102.13 210.9,104.01 210.28,104.63 R8102.1 209.29,104.73 207.74,104.73 v2(207.11,104.09) 206.93,103.92 Q8101.D
FBA_WCK01: length 25.5
  L6 w0.112: v1(206.86,76.43) 206.79,76.36 206.79,75.89 206.6,75.69 206.6,75.1 206.93,74.76 206.93,73.6 206.68,73.36 205.4,73.36 205.16,73.6 205.16,74.66 205.03,74.78 204.69,74.78 204.54,74.63 204.54,73.53 204.26,73.26 202.62,73.26 202.21,73.67 197.84,73.67 193.63,77.88 193.22,77.88 192.1,79 192.1,79.99 192.32,80.22 v1(192.32,80.4)
  BOTTOM w0.114: v1(206.86,76.43) 206.83,76.43 VRAM1.D4 ; v1(192.32,80.4) 192.32,80.96 GPU1.D18
FBA_WCK01#: length 25.6
  L6 w0.112: v1(192.82,79.87) 192.82,79.92 192.7,80.04 192.55,80.04 192.49,79.98 192.41,79.98 192.32,79.9 192.32,79.1 193.32,78.11 193.72,78.11 197.93,73.9 202.3,73.9 202.72,73.48 204.17,73.48 204.31,73.63 204.31,74.72 204.6,75.01 205.12,75.01 205.38,74.75 205.38,73.7 205.5,73.59 206.59,73.59 206.7,73.7 206.7,74.67 206.37,75 206.37,75.78 206.57,75.98 206.57,76.14 206.29,76.42 v1(206.06,76.42)
  BOTTOM w0.114: GPU1.C18 192.91,80.41 193.1,80.22 193.1,80.06 192.91,79.87 v1(192.82,79.87) ; v1(206.06,76.42) 206.12,76.48 206.28,76.48 206.46,76.3 VRAM1.D5
FBA_WCK23: length 33.4
  L3 w0.112: v1(191.14,80.35) 191.7,80.35 192.6,79.45 194.06,79.45 194.31,79.2 195.87,79.2 201.18,73.89 206.36,73.89 209.89,70.36 211.87,70.36 212.49,70.99 212.49,73.43 213.99,74.92 213.99,75.74 214.48,76.23 214.67,76.23 v1(214.86,76.41)
  BOTTOM w0.114: v1(191.14,80.35) 191.17,80.38 GPU1.D17 ; v1(214.86,76.41) 214.47,76.8 VRAM1.P4
FBA_WCK23#: length 33.3
  L3 w0.112: v1(191.66,79.79) 191.94,79.8 192.51,79.23 193.96,79.23 194.22,78.97 195.78,78.97 201.09,73.66 206.27,73.66 209.8,70.13 211.96,70.13 212.72,70.9 212.72,73.33 214.22,74.83 214.22,75.64 214.57,76 214.76,76 214.88,75.89 v1(214.88,75.61)
  BOTTOM w0.114: v1(191.66,79.79) 191.47,79.6 191.31,79.6 GPU1.D16 ; VRAM1.P5 214.46,75.73 214.57,75.61 v1(214.88,75.61)
FBA_WCK45: length 26.5
  TOP w0.114: v1(188.2,91.52) 189.1,91.52 189.22,91.41 189.64,91.41 191.33,93.1 191.77,93.1 192.15,93.48 192.15,95.81 192.34,96 193.13,96 193.34,95.79 193.34,93.34 193.59,93.1 201.14,93.1 202.38,94.34 204.85,94.34 205.54,93.64 205.54,93.33 206.07,92.8 v1(206.07,92.6)
  BOTTOM w0.114: GPU1.T24 188.2,91.53 v1(188.2,91.52) ; VRAM4.P4 206.46,92.21 v1(206.07,92.6)
FBA_WCK45#: length 26.9
  TOP w0.114: v1(188.78,92.09) 188.85,92.16 189.1,92.16 189.21,92.04 189.21,91.75 189.32,91.65 189.54,91.65 191.23,93.34 191.67,93.34 191.91,93.58 191.91,95.91 192.24,96.25 193.23,96.25 193.58,95.89 193.58,93.44 193.69,93.34 201.04,93.34 202.28,94.58 204.95,94.58 205.78,93.74 205.78,93.43 206.07,93.14 206.29,93.14 206.43,93.28 v1(206.43,93.62)
  BOTTOM w0.114: GPU1.U24 188.75,92.12 v1(188.78,92.09) ; VRAM4.P5 206.43,93.03 v1(206.43,93.62)
FBA_WCK67: length 35.9
  TOP w0.114: v1(214.06,92.6) 214.72,92.6 215.04,92.92 215.04,94.03 214.39,94.68 211.68,94.68 211.22,94.22 208.63,94.22 207.37,95.48 201.38,95.48 200.86,94.96 197.35,94.96 195.39,96.92 191.11,96.92 187.19,93 187.19,92.57 187.41,92.35 187.41,92.35 v1(187.61,92.14)
  BOTTOM w0.114: v1(187.61,92.14) GPU1.V24 ; v1(214.06,92.6) 214.06,92.6 VRAM4.D4
FBA_WCK67#: length 36
  TOP w0.114: v1(214.07,93.42) 214.07,93.18 214.4,92.84 214.62,92.84 214.8,93.02 214.8,93.93 214.29,94.44 211.78,94.44 211.32,93.98 208.73,93.98 208.53,93.98 207.27,95.24 201.48,95.24 200.96,94.72 197.25,94.72 195.29,96.68 191.21,96.68 187.43,92.9 187.43,92.67 187.55,92.55 188.04,92.55 v1(188.18,92.69)
  BOTTOM w0.114: GPU1.V25 188.28,93.28 188.39,93.17 188.39,92.8 188.28,92.69 v1(188.18,92.69) ; VRAM4.D5 214.6,93.14 214.6,93.3 214.35,93.54 214.19,93.54 v1(214.07,93.42)
FFS_INT1: length 54.8
  TOP w0.102: v1(141.19,58.47) 148.27,51.4 154.34,51.4 155.01,50.73 155.01,50 156.64,48.37 157.39,48.37 157.4,48.36 158.19,48.36 159.02,49.2 159.02,49.23 159.66,49.86 v2(159.81,49.86) 160.45,49.86 163.09,52.5 163.14,52.5 163.16,52.53 163.9,52.53 R7011.1
  L6 w0.102: v1(141.19,58.47) 140.48,59.18 140.48,63.22 138.75,64.95 136.85,64.95 135.22,66.58 135.22,66.72 134.96,66.98 134.47,66.98 133.72,66.23 130.54,66.23 128.44,68.33 128.44,69 127.18,70.26 125.48,70.26 v1(125.07,70.68)
  BOTTOM w0.089: CPU1.CG22 125.37,70.99 v1(125.07,70.68)
FFS_INT2: length 166.8
  TOP w0.102: v1(215.41,58.3) 215.77,58.65 R7008.2 216.53,58.42 v2(216.53,57.71)
  L6 w0.102: v1(219.37,29.92) 219.37,33.25 218.23,34.39 217.52,34.39 217.24,34.67 216.76,34.67 215.9,33.82 213.4,33.82 211.6,35.61 207.59,35.61 205.86,37.34 199.02,37.34 197.66,38.7 197.66,39.48 196.12,41.02 184.19,41.02 183.51,41.71 181.18,41.71 174.39,48.5 170.03,48.5 170.02,48.49 169.16,48.49 168.83,48.82 162.24,48.82 154.02,57.05 154.02,67.73 151.26,70.49 147.47,70.49 145.03,72.93 145.03,74.21 144.12,75.11 141.36,75.11 140.52,74.27 v1(140.52,74.07) 140.02,74.57 137.71,74.57 137.33,74.2 135.73,74.2 135.05,74.88 133.96,74.88 132.78,76.06 131.99,76.06 131.06,76.99 128.8,76.99 128.19,76.38 125.95,76.38 125.55,76.79 v1(125.52,76.79)
  BOTTOM w0.089: v1(125.52,76.79) 125.55,76.81 125.61,76.81 126.02,77.23 CPU1.CH12
  BOTTOM w0.102: D7001.3 216.65,58.95 214.62,58.95 214.33,58.67 214.33,58.31 214.58,58.05 215.17,58.05 v1(215.41,58.3) 215.74,57.97 215.74,56.8 216.92,55.62 217.82,55.62 221.2,52.23 221.2,32.58 219.5,30.88 219.5,30.05 v1(219.37,29.92) ; R2044.2 140.86,73.38 140.52,73.72 v1(140.52,74.07)
FFS_INT2_Q: length 104.3
  TOP w0.102: Q7001.6 217.48,62.35 218.14,61.69 v2(218.14,61.32) 218.14,60.27 v1(218.36,60.05) ; R6016.1 189.76,11.23 189.45,10.92 v1(189.4,10.92)
  L3 w0.102: v1(206.93,5.06) 207,4.98 207.16,4.98 207.59,5.41 220.92,5.41 223.79,8.28 223.79,38.69 218.38,44.1 218.38,53.24 221.18,56.04 221.18,57.66 218.79,60.05 v1(218.36,60.05)
  L6 w0.102: v1(189.4,10.92) 192.2,10.92 196.2,14.93 199.89,14.93 202,12.82 202,9.78 203.78,8 204.72,8 205.81,6.91 205.81,6.17 v1(206.93,5.06)
FFS_INT2_Q_R: length 5.4
  TOP w0.102: R6016.2 188.89,11.23 v2(188.44,10.77) 188.22,10.77 187.99,11 186.86,11 v1(186.8,10.94)
  BOTTOM w0.102: HDD1.12 185.86,11.88 v1(186.8,10.94)
FP_USB20_N: length 130
  TOP w0.102: v2(211.44,44.54) 211.86,44.12 211.86,43.69 v1(212.19,43.36)
  L6 w0.089: v1(212.19,43.36) 212.3,43.36 212.51,43.15 212.51,42.91 209.58,39.98 205.1,39.98 204.41,39.3 202.66,39.3 198.65,43.31 185.76,43.31 183.88,45.19 183.88,49.09 182.01,50.96 177.98,50.96 175.34,53.6 162.16,53.6 156.51,59.25 156.51,68.55 153.93,71.13 153.93,71.58 151.82,73.69 150,73.69 149.77,73.47 148.48,73.47 145.05,76.9 145.05,79.58 144.42,80.2 140,80.2 139.77,80.43 138.78,80.43 137.3,78.96 135.71,78.96 133.1,81.56 133.1,81.82 131.44,83.48 126.95,83.48 125.89,82.42 125.89,81.96 125.8,81.87 v1(125.68,81.87)
  BOTTOM w0.102: CPU1.CG5 125.47,81.88 125.67,81.88 v1(125.68,81.87) ; IOBD1.15 217.54,45.75 217.41,45.89 215.85,45.89 215.44,45.48 215.44,43.95 214.03,42.55 212.86,42.55 212.62,42.79 212.62,43.03 212.29,43.36 v1(212.19,43.36)
FP_USB20_P: length 129.1
  TOP w0.102: v2(212.49,43.84) 212.85,43.48 v1(212.85,43.41)
  L6 w0.089: v1(125.62,81.18) 126.08,81.64 126.08,82.34 127.03,83.29 131.36,83.29 132.91,81.74 132.91,81.49 135.63,78.77 137.38,78.77 138.86,80.24 139.69,80.24 139.92,80.01 144.34,80.01 144.86,79.5 144.86,76.83 148.4,73.28 149.85,73.28 150.08,73.5 151.74,73.5 153.74,71.5 153.74,71.05 156.32,68.47 156.32,59.17 162.08,53.41 175.26,53.41 177.9,50.76 181.93,50.76 183.69,49.01 183.69,45.11 185.68,43.12 198.57,43.12 202.58,39.11 204.49,39.11 205.18,39.79 209.66,39.79 212.7,42.83 212.7,43.26 v1(212.85,43.41)
  BOTTOM w0.102: CPU1.CG6 125.45,80.92 125.62,81.09 v1(125.62,81.18) ; v1(212.85,43.41) 212.85,42.89 212.96,42.78 213.94,42.78 215.21,44.05 215.21,45.57 215.75,46.11 217.4,46.11 217.54,46.25 IOBD1.14
FPR_SCAN#: length 242.2
  TOP w0.102: v1(41.83,49.61) 41.98,49.76 U2401.42 41.98,51.72 42.28,52.02 42.72,52.02 43.78,53.09 44.32,53.09 44.77,53.55 R2429.1 45.03,53.44 v2(45.03,52.63)
  L3 w0.102: v1(41.83,49.61) 41.83,49.66 42.54,50.37 42.81,50.37 43.15,50.04 43.15,49.56 43.86,48.85 43.86,48.67 44.47,48.06 44.47,45.09 44.42,45.04 44.42,44.99 43.91,44.48 43.91,39.75 44.39,39.27 44.39,38.92 45.36,37.95 45.36,36.5 44.77,35.92 44.72,35.92 42.64,33.84 42.64,30.74 43.05,30.33 43.84,30.33 v1(44.27,29.9)
  L6 w0.102: v1(214.29,24.39) 214.27,24.41 212.37,24.41 211.28,23.32 209.72,23.32 207.74,21.34 203.96,21.34 203.75,21.54 201.06,21.54 198.8,23.8 198.8,24.44 197.86,25.38 190.04,25.38 187.5,27.92 180.13,27.92 179.14,26.93 v1(178.89,26.93)
  BOTTOM w0.102: v1(178.89,26.93) 178.61,26.93 175.86,29.68 155.65,29.68 155.22,29.24 108.91,29.24 108.88,29.21 98.34,29.21 98.32,29.24 44.93,29.24 v1(44.27,29.9) ; IOBD1.1 219.54,52.75 220.39,51.9 220.39,33.17 218.63,31.41 217.94,31.41 217.28,30.75 217.28,29.91 214.29,26.93 v1(214.29,24.39)
GC6_FB_EN: length 89.3
  TOP w0.102: v1(169.16,42.52) 169.13,42.5 169.13,42.32 168.97,42.15 v2(160.83,42.15) 160.03,42.15 154.81,47.38 154.81,50.65 154.36,51.09 148.27,51.09 143.41,55.96 135.84,55.96 131.44,60.35 131.44,61.3 128.9,63.84 128.9,66.14 128.7,66.35 R2004.1
  BOTTOM w0.102: R7940.2 181.72,64.48 Q7907.3 181.72,63.37 181.6,63.25 179.52,63.25 178.75,64.02 D8601.1 178.61,62.99 179.45,62.16 R7953.2 179.39,61.32 178.02,61.32 176.73,60.02 176.73,54.38 176.63,54.28 176.63,54.26 176.5,54.13 176.5,54.03 171.37,48.9 170.86,48.9 170.83,48.87 170.5,48.87 170.07,48.44 168.54,48.44 167.95,47.84 167.95,46.53 168.55,45.92 168.55,45.31 169.13,44.73 169.13,42.55 v1(169.16,42.52)
GC6_FB_EN_GPU: length 5.1
  BOTTOM w0.127: R7958.2 R7959.2 181.5,65.76 180.94,65.76 180.82,65.89 v2(180.33,65.89) 180.33,65.18 R7927.1 R7940.1 181.07,64.7 Q7907.2
GC6_FB_EN_GPU_L: length 6.6
  BOTTOM w0.102: Q7907.6 180.42,62.88 180.51,62.97 180.92,62.97 181.07,62.82 Q7907.5 181.07,60.81 v2(181.39,60.49) 182.29,59.59 182.29,58.85 182.26,58.83 R7952.1
GC6_FB_EN_MCP: length 7
  TOP w0.127: v1(124.5,67.59) 124.5,68.35 v2(124.96,68.81) 125.01,68.81 125.05,68.85 126.28,68.85 126.75,68.38 128.34,68.38 128.7,68.02 R2004.2
  BOTTOM w0.127: CPU1.CE28 124.01,67.41 124.18,67.57 124.46,67.57 124.48,67.59 v1(124.5,67.59)
GC6_PWR_EN: length 4.1
  BOTTOM w0.102: R8648.2 156.2,91.9 v2(156.28,91.82) 156.28,91.39 156.15,91.26 155.65,91.26 155.49,91.11 155.49,90.53 155.85,90.17 U8605.2
GC6_THM_DIS#: length 165.5
  TOP w0.102: R2480.2 57.63,47.5 57.27,47.86 57.27,48.39 57.93,49.05 61.17,49.05 62.61,50.49 62.61,52.25 64.36,54 70.89,54 v2(71.01,54.13) v1(71.44,54.56)
  BOTTOM w0.076: 134.09,57.55 133.78,57.86 132.39,57.86 130,60.26 129.15,60.26 127.89,61.52 127.89,61.77 127.91,61.79 127.91,62.18 127.52,62.57 CPU1.CL35
  BOTTOM w0.102: v1(71.44,54.56) 71.44,52.96 79.46,44.94 79.55,44.94 79.67,44.81 108.86,44.81 108.91,44.76 108.93,44.76 109.62,44.07 112.85,44.07 112.9,44.02 115.51,44.02 116.94,42.59 116.94,42.19 116.96,42.17 116.96,42.17 117.27,41.86 120.26,41.86 122.58,39.55 143.54,39.55 145.6,41.61 153,41.61 153.71,42.32 160.98,42.32 162.22,43.56 162.22,44.48 161.28,45.42 161.28,45.77 161.06,46 161.06,49.61 160.83,49.84 160.83,50.58 159.13,52.28 147.87,52.28 143.81,56.34 135.3,56.34 134.09,57.55
GC6_THM_DIS#_EC: length 12.2
  TOP w0.102: U2401.23 47.7,46.11 47.85,46.26 47.85,46.71 48.76,47.63 52.09,47.63 v2(52.39,47.32) 52.4,47.32 53.21,46.51 R2426.2 56,46.51 R2480.1 R2477.1
GFX_CLK_CPU_N: length 102.7
  TOP w0.102: v1(110.7,89.95) 110.7,89.77 110.91,89.56 111.83,89.56 112.18,89.91 112.79,89.91 113.09,89.62 113.59,89.62 113.86,89.35 113.86,88.51 114.01,88.35 114.23,88.35 114.35,88.47 114.35,89.14 114.6,89.39 114.96,89.39 115.21,89.14 115.21,88.47 115.33,88.35 116.29,88.35 119.2,85.45 127.88,85.45 130.8,88.37 134.28,88.37 135.96,90.05 145.64,90.05 145.87,89.82 151.25,89.82 153.21,87.86 153.21,85.91 153.33,85.78 153.74,85.78 153.86,85.91 153.86,86.61 154.35,87.1 154.72,87.1 154.97,86.85 154.97,86.23 155.09,86.11 155.26,86.11 155.38,86.23 155.38,86.85 155.63,87.1 155.99,87.1 156.24,86.85 156.24,86.23 156.36,86.11 156.53,86.11 156.65,86.23 156.65,86.85 156.9,87.1 159.45,87.1 160.66,85.89 161.06,85.89 161.31,85.64 161.31,85.34 161.43,85.22 161.6,85.22 161.72,85.34 161.72,85.93 161.96,86.16 162.3,86.16 162.58,85.87 162.58,85.34 162.7,85.22 162.87,85.22 162.99,85.34 162.99,85.97 163.23,86.2 163.58,86.2 163.85,85.93 163.85,85.34 163.97,85.22 164.14,85.22 164.26,85.34 164.26,85.94 164.51,86.19 164.87,86.19 165.12,85.94 165.12,85.34 165.24,85.22 165.41,85.22 165.53,85.34 165.53,85.64 165.78,85.89 167.37,85.89 167.47,85.99 v1(167.47,86.22)
  L6 w0.089: v1(174.14,86.86) 174.29,86.71 174.29,86.54 174.07,86.32 173.54,86.32 173.45,86.41 173.45,87.22 173.22,87.45 172.59,87.45 172.39,87.25 172.39,86.01 172.28,85.91 171.87,85.91 171.75,86.02 171.75,87.13 171.52,87.36 171.2,87.36 170.98,87.13 170.98,86.02 170.86,85.91 170.7,85.91 170.58,86.02 170.58,87.13 170.35,87.36 170.03,87.36 169.81,87.13 169.81,86.02 169.69,85.91 169.53,85.91 169.41,86.02 169.41,87.13 169.19,87.36 168.87,87.36 168.64,87.13 168.64,86.02 168.52,85.91 167.56,85.91 167.47,85.99 v1(167.47,86.22)
  BOTTOM w0.102: GPU1.AD8 v1(174.14,86.86) ; v1(110.7,89.95) 110.7,89.79 110.53,89.63 108.87,89.63 108.35,89.11 108.35,86.52 108.6,86.27 108.6,83.79 108.43,83.62 CPU1.AW2
GFX_CLK_CPU_P: length 102.7
  TOP w0.102: v1(110.7,89.2) 110.83,89.33 111.93,89.33 112.28,89.69 112.7,89.69 112.99,89.4 113.49,89.4 113.63,89.26 113.63,88.41 113.92,88.13 114.32,88.13 114.58,88.38 114.58,89.04 114.7,89.16 114.86,89.16 114.98,89.04 114.98,88.38 115.24,88.13 116.2,88.13 119.1,85.22 127.98,85.22 130.9,88.14 134.38,88.14 136.06,89.82 145.54,89.82 145.77,89.59 151.16,89.59 152.98,87.77 152.98,85.81 153.24,85.55 153.83,85.55 154.09,85.81 154.09,86.52 154.44,86.87 154.62,86.87 154.74,86.75 154.74,86.13 154.99,85.88 155.35,85.88 155.61,86.13 155.61,86.75 155.72,86.87 155.89,86.87 156.01,86.75 156.01,86.13 156.26,85.88 156.62,85.88 156.88,86.13 156.88,86.75 156.99,86.87 159.35,86.87 160.56,85.66 160.97,85.66 161.09,85.55 161.09,85.25 161.34,85 161.7,85 161.95,85.25 161.95,85.83 162.05,85.93 162.2,85.93 162.36,85.78 162.36,85.25 162.61,85 162.97,85 163.22,85.25 163.22,85.87 163.32,85.97 163.49,85.97 163.63,85.83 163.63,85.25 163.88,85 164.24,85 164.49,85.25 164.49,85.84 164.61,85.96 164.78,85.96 164.9,85.84 164.9,85.25 165.15,85 165.51,85 165.76,85.25 165.76,85.55 165.88,85.66 167.16,85.66 v1(167.47,85.36)
  L6 w0.089: v1(167.47,85.36) 167.82,85.72 168.6,85.72 168.83,85.94 168.83,87.05 168.94,87.17 169.11,87.17 169.22,87.05 169.22,85.94 169.45,85.72 169.77,85.72 170,85.94 170,87.05 170.11,87.17 170.28,87.17 170.39,87.05 170.39,85.94 170.62,85.72 170.94,85.72 171.17,85.94 171.17,87.05 171.28,87.17 171.44,87.17 171.56,87.05 171.56,85.94 171.79,85.72 172.36,85.72 172.58,85.93 172.58,87.17 172.67,87.26 173.14,87.26 173.26,87.14 173.26,86.33 173.46,86.13 174.15,86.13 174.57,86.56 174.57,87.3 v1(174.69,87.43)
  BOTTOM w0.102: v1(110.7,89.2) 110.5,89.4 108.96,89.4 108.58,89.01 108.58,86.62 108.83,86.36 108.83,83.69 108.83,83.69 CPU1.AY3 ; GPU1.AE8 v1(174.69,87.43)
GFX_PCIE_RX_C_N0: length 17.4
  TOP w0.102: C7602.2 162.1,79.99 163.47,79.99 163.72,80.24 164.78,80.24 166.68,82.15 169.59,82.15 172.53,85.09 174.41,85.09 174.82,85.5 174.82,85.86 175.4,86.43 175.78,86.43 v1(175.92,86.3)
  BOTTOM w0.102: v1(175.92,86.3) GPU1.AB9
GFX_PCIE_RX_C_N1: length 18.8
  TOP w0.102: v1(175.89,87.46) 175.99,87.35 176.14,87.35 176.32,87.54 176.32,87.71 176.04,87.99 174.08,87.99 170.15,84.06 170.15,83.54 169.39,82.78 166.42,82.78 165.73,82.1 162.55,82.1 162.45,82 162.45,81.67 162.35,81.56 C7604.2
  BOTTOM w0.102: GPU1.AC10 v1(175.89,87.46)
GFX_PCIE_RX_C_N2: length 22.2
  TOP w0.102: v1(177.03,88.65) 177.03,88.91 177.18,89.06 177.18,89.66 176.73,90.12 175.72,90.12 175.08,89.49 172.9,89.49 168,84.59 C7606.2
  BOTTOM w0.102: v1(177.03,88.65) 177.03,88.64 177.03,88.05
GFX_PCIE_RX_C_N3: length 21.8
  TOP w0.102: v1(178.18,88.6) 177.55,88.6 177.2,88.24 176.76,88.24 176.14,88.85 173.31,88.85 168.36,83.9 166.31,83.9 165.65,83.24 161.04,83.24 160.76,82.96 C7608.2
  BOTTOM w0.102: GPU1.AB12 v1(178.18,88.6)
GFX_PCIE_RX_C_P0: length 17.2
  TOP w0.102: v1(175.33,86.84) 175.33,86.68 174.6,85.95 174.6,85.59 174.32,85.32 172.44,85.32 169.5,82.37 166.59,82.37 164.68,80.47 163.63,80.47 163.37,80.22 162.35,80.22 162.02,80.55 C7601.2
  BOTTOM w0.102: v1(175.33,86.84) 175.82,86.84 GPU1.AC9
GFX_PCIE_RX_C_P1: length 19.1
  TOP w0.102: C7603.2 165.64,82.33 166.32,83.01 169.29,83.01 169.92,83.64 169.92,84.15 173.99,88.22 176.14,88.22 176.55,87.8 176.55,87.44 176.3,87.2 176.3,87.05 v1(176.45,86.91)
  BOTTOM w0.102: v1(176.45,86.91) 176.5,86.86 GPU1.AB10
GFX_PCIE_RX_C_P2: length 22.6
  TOP w0.102: C7605.2 159.43,83.74 159.54,83.84 159.54,84.26 159.64,84.36 168.1,84.36 172.99,89.26 175.18,89.26 175.81,89.89 176.63,89.89 176.96,89.57 176.96,89.16 176.79,89 176.65,88.99 v1(176.47,89.16)
  BOTTOM w0.102: GPU1.AD11 176.65,88.8 176.65,89.06 176.55,89.16 v1(176.47,89.16)
GFX_PCIE_RX_C_P3: length 21.9
  TOP w0.102: v1(177.62,88.01) 177.62,88.01 176.66,88.01 176.05,88.62 173.41,88.62 168.46,83.67 166.41,83.67 165.75,83.01 161.13,83.01 160.85,82.73 160.37,82.73 160.27,82.63 160.27,82.35 160.04,82.12 159.83,82.12 C7607.2
  BOTTOM w0.102: v1(177.62,88.01) 177.57,88.01 177.38,88.2 177.38,88.44 177.59,88.64 GPU1.AC12
GFX_PCIE_RX_N0: length 47
  TOP w0.102: v1(120.08,79.19) 120.83,78.44 123.5,78.44 124.72,77.22 127.86,77.22 129.05,76.02 129.82,76.02 130.25,75.59 132.68,75.59 133.19,75.08 134.1,75.08 134.33,75.32 134.33,75.97 134.44,76.08 136.52,76.08 136.75,75.85 145.67,75.85 145.67,75.85 146.34,75.85 149.57,79.07 153.3,79.07 154.16,78.21 154.91,78.21 157.07,80.37 160.73,80.37 161.11,79.99 C7602.1
  BOTTOM w0.102: v1(120.08,79.19) 120.33,79.19 CPU1.BW9
GFX_PCIE_RX_N1: length 49.4
  TOP w0.102: v1(120.08,81.14) 120.3,81.38 120.53,81.38 120.77,81.62 120.77,82.25 121.84,83.31 131.42,83.31 133.27,81.47 133.27,79.43 135.22,77.47 136.04,77.47 137.03,76.48 146.08,76.48 149.36,79.76 152.02,79.76 153.29,81.03 159.86,81.03 160.73,81.89 161.02,81.89 161.12,81.79 C7604.1
  BOTTOM w0.102: v1(120.08,81.14) 119.85,81.14 CPU1.BU6
GFX_PCIE_RX_N2: length 51.3
  TOP w0.102: C7606.1 154.74,84.59 151.4,81.26 139.54,81.26 137.74,79.45 135.55,79.45 134.82,80.19 134.82,82.32 132.63,84.51 132.63,85.22 131.9,85.96 129.33,85.96 128.19,84.81 119.96,84.81 117.55,82.4 117.55,81.61 117.8,81.36 117.8,80.97 v1(118.22,80.56)
  BOTTOM w0.102: v1(118.22,80.56) 118.51,80.27 CPU1.BT7
GFX_PCIE_RX_N3: length 52.6
  TOP w0.102: v1(119.16,79.19) 118.69,79.65 118.69,82.17 120.69,84.18 131.97,84.18 134.18,81.97 134.18,79.83 135.6,78.41 137,78.41 138.07,77.35 142.5,77.35 142.69,77.54 142.69,80.13 143.18,80.62 151.67,80.62 153.24,82.2 157.17,82.2 157.93,82.96 C7608.1
  BOTTOM w0.102: CPU1.BU9 119.38,78.97 v1(119.16,79.19)
GFX_PCIE_RX_P0: length 47.3
  TOP w0.102: v1(120.08,79.84) 120.26,79.84 120.49,79.6 120.49,79.1 120.92,78.67 123.59,78.67 124.81,77.45 127.95,77.45 129.15,76.25 129.91,76.25 130.35,75.82 132.78,75.82 133.28,75.31 134,75.31 134.11,75.42 134.11,76.07 134.34,76.3 136.61,76.3 136.84,76.08 145.68,76.08 145.72,76.08 146.25,76.08 149.47,79.3 153.4,79.3 154.26,78.44 154.82,78.44 156.97,80.6 161,80.6 C7601.1
  BOTTOM w0.102: v1(120.08,79.84) 120.3,79.62 CPU1.BW8
GFX_PCIE_RX_P1: length 49.2
  TOP w0.102: v1(120.06,81.82) 120.06,81.82 120.28,81.61 120.43,81.61 120.54,81.72 120.54,82.34 121.74,83.54 131.52,83.54 133.5,81.56 133.5,79.52 135.32,77.7 136.13,77.7 137.12,76.71 145.98,76.71 149.26,79.99 151.93,79.99 153.2,81.26 159.77,81.26 160.63,82.12 160.91,82.12 C7603.1
  BOTTOM w0.102: CPU1.BU5 119.87,81.82 v1(120.06,81.82)
GFX_PCIE_RX_P2: length 51
  TOP w0.102: v1(118.22,81.21) 118.15,81.21 118.05,81.31 118.05,81.44 117.77,81.71 117.77,82.31 120.05,84.58 128.28,84.58 129.43,85.73 131.8,85.73 132.4,85.13 132.4,84.41 134.59,82.23 134.59,80.1 135.46,79.23 137.83,79.23 139.64,81.03 151.5,81.03 154.83,84.36 157.67,84.36 157.77,84.26 157.77,83.83 157.86,83.74 C7605.1
  BOTTOM w0.102: CPU1.BT6 118.7,81.15 118.52,81.32 118.33,81.32 v1(118.22,81.21)
GFX_PCIE_RX_P3: length 52.6
  TOP w0.102: C7607.1 158.69,82.04 158.49,82.04 158.39,82.14 158.39,82.63 158.29,82.73 158.03,82.73 157.26,81.97 153.34,81.97 151.76,80.39 143.28,80.39 142.92,80.04 142.92,77.45 142.59,77.12 137.97,77.12 136.91,78.18 135.5,78.18 133.95,79.73 133.95,81.87 131.88,83.95 120.79,83.95 118.92,82.08 118.92,79.94 119.02,79.84 v1(119.16,79.84)
  BOTTOM w0.102: v1(119.16,79.84) 119.16,79.91 119.26,80.01 119.48,80.01 119.67,79.81 119.67,79.67 CPU1.BU8
GFX_PCIE_TX_C_N0: length 6.6
  BOTTOM w0.076: 120.21,85.59 120.21,85.58 120.24,85.55 120.24,85.16 120.08,84.63 120.04,84.46 120.04,84.14 120.07,84.01 120.07,83.87 120.04,83.71 120.04,83.47 120.08,83.38 120.23,82.83 CPU1.BW4
  BOTTOM w0.102: 120.21,85.59 120.21,86.62 119.87,86.96 C1606.2
GFX_PCIE_TX_C_N1: length 7.1
  BOTTOM w0.076: 119.2,86.66 119.2,86.64 119.22,86.62 119.22,86.25 119.19,85.51 119.42,84.81 119.42,84.41 119.41,84.18 119.38,84.02 119.38,83.86 119.41,83.7 119.41,83.51 119.38,83.44 119.32,83.37 119.3,83.36 118.98,83.21 118.92,83.1 118.9,83.04 118.9,82.86 CPU1.BU4
  BOTTOM w0.102: 119.2,86.66 119.2,86.95 118.34,87.81 C1608.2
GFX_PCIE_TX_C_N2: length 6.1
  BOTTOM w0.076: CPU1.BU2 118.84,83.93 118.84,86.71 118.53,87.02 118.49,87.02
  BOTTOM w0.102: 118.49,87.02 117.42,88.1 117.26,88.26 117.26,88.29 116.88,88.67 C1610.2
GFX_PCIE_TX_C_N3: length 8.2
  BOTTOM w0.076: 118.04,86.87 118.06,86.86 118.09,86.86 118.49,86.46 118.49,83.71 118.34,83.56 118.34,82.89 CPU1.BT4
  BOTTOM w0.102: C1612.2 115.57,88.4 115.57,88.17 115.8,87.94 116.98,87.94 118.04,86.87
GFX_PCIE_TX_C_P0: length 6.3
  BOTTOM w0.076: CPU1.BW3 120.22,83.51 120.22,83.68 120.25,83.86 120.25,84.03 120.22,84.2 120.22,84.44 120.25,84.59 120.41,85.13 120.41,85.55 120.44,85.58 120.44,85.59
  BOTTOM w0.102: C1605.2 120.63,88.41 120.52,88.29 120.25,88.29 120.1,88.14 120.1,87.06 120.44,86.71 120.44,85.59
GFX_PCIE_TX_C_P1: length 6.7
  BOTTOM w0.076: 119.42,86.66 119.42,86.64 119.4,86.62 119.4,86.24 119.37,85.54 119.6,84.84 119.6,84.4 119.6,84.4 119.58,84.15 119.56,84.01 119.56,83.87 119.59,83.71 119.59,83.47 119.53,83.35 119.47,83.26 119.46,83.25 119.45,83.24 CPU1.BU3
  BOTTOM w0.102: C1607.2 119.11,88.4 119,88.29 118.67,88.29 118.57,88.19 118.57,87.9 119.42,87.05 119.42,86.66
GFX_PCIE_TX_C_P2: length 5.1
  BOTTOM w0.076: CPU1.BU1 119.02,84.4 119.02,86.78 118.67,87.13 118.67,87.17 118.66,87.18
  BOTTOM w0.102: C1609.2 117.58,88.26 118.22,87.62 118.66,87.18
GFX_PCIE_TX_C_P3: length 7.6
  BOTTOM w0.076: CPU1.BT3 118.52,83.37 118.52,83.49 118.67,83.64 118.67,86.53 118.22,86.99 118.22,87.02 118.2,87.04
  BOTTOM w0.102: 118.2,87.04 117.07,88.17 115.9,88.17 115.8,88.27 115.8,88.57 115.9,88.67 C1611.2
GFX_PCIE_TX_N0: length 63.4
  TOP w0.102: v1(119.83,90.61) 119.88,90.55 119.88,88.94 121.18,87.63 123.62,87.63 124.02,88.04 124.02,89.03 124.23,89.23 128.52,89.23 129.46,90.17 133.59,90.17 135.19,91.77 146.3,91.77 146.58,91.49 151.96,91.49 153.23,90.22 159.86,90.22 161.61,88.47 167.93,88.47 168.27,88.81 168.27,89.41 167.86,89.82 167.47,89.82 v1(167.25,90.03)
  BOTTOM w0.102: v1(167.25,90.03) 167.57,89.72 168.6,89.72 169.79,88.52 171.87,88.52 GPU1.AG7 ; v1(119.83,90.61) 119.91,90.53 119.91,89.63 C1606.1
GFX_PCIE_TX_N1: length 62.3
  TOP w0.102: v1(118.3,90.61) 118.51,90.81 118.51,91.09 118.76,91.34 120.85,91.34 121.36,90.83 128.85,90.83 129.05,91.04 133.19,91.04 134.79,92.64 146.38,92.64 146.56,92.81 151.89,92.81 153.47,91.24 160.06,91.24 161.92,89.39 165.64,89.39 167.16,90.91 168.92,90.91 v1(169.17,91.15)
  BOTTOM w0.102: v1(118.3,90.61) 118.36,90.55 118.36,89.6 C1608.1 ; v1(169.17,91.15) 169.86,91.15 171.6,89.41 171.6,89.36 171.83,89.13 172.1,89.13 173.2,88.04 173.2,87.84 173.55,87.48 GPU1.AE7
GFX_PCIE_TX_N2: length 69.5
  TOP w0.102: v1(170.07,92.2) 170.07,91.93 170.43,91.57 170.43,89.6 168.67,87.84 161.27,87.84 159.69,89.41 153.15,89.41 151.7,90.86 146.32,90.86 146.04,91.14 135.52,91.14 133.9,89.51 129.99,89.51 128.47,87.99 126.64,87.99 125.62,86.97 120.7,86.97 120.02,87.66 118.67,87.66 117.01,89.32 117.01,90.4 v1(116.83,90.58)
  BOTTOM w0.102: v1(116.83,90.58) 117.01,90.4 117.01,89.78 C1610.1 ; GPU1.AF9 173.98,88.78 173.46,88.78 172.94,89.3 172.94,89.74 172.26,90.43 171.5,90.43 170.07,91.85 v1(170.07,92.2)
GFX_PCIE_TX_N3: length 69
  TOP w0.102: v1(172.19,91.49) 172.19,91.39 172.53,91.04 172.53,90.71 169.02,87.2 159.92,87.2 159.62,87.51 154.16,87.51 151.44,90.22 146.05,90.22 145.77,90.5 135.8,90.5 134.07,88.78 130.42,88.78 128.7,87.05 126.73,87.05 125.67,85.98 120.59,85.98 120.14,86.44 118.84,86.44 115.36,89.92 115.36,90.52 v1(115.31,90.57)
  BOTTOM w0.102: GPU1.AG10 174.05,89.59 173.9,89.59 172.19,91.3 v1(172.19,91.49) ; C1612.1 115.33,89.63 115.33,90.54 v1(115.31,90.57)
GFX_PCIE_TX_P0: length 63.8
  TOP w0.102: v1(167.25,89.17) 167.25,89.17 167.25,89.49 167.35,89.59 167.77,89.59 168.04,89.32 168.04,88.9 167.84,88.7 161.7,88.7 159.95,90.45 153.33,90.45 152.06,91.72 146.68,91.72 146.4,92 135.1,92 133.5,90.4 129.36,90.4 128.42,89.46 124.13,89.46 123.79,89.12 123.79,88.13 123.52,87.86 121.28,87.86 120.11,89.03 120.11,90.2 120.21,90.3 120.52,90.3 120.62,90.4 v1(120.62,90.61)
  BOTTOM w0.102: GPU1.AG6 171.86,87.4 171.72,87.53 171.72,87.67 171.99,87.94 171.99,88.08 171.77,88.29 169.7,88.29 168.5,89.49 167.57,89.49 167.25,89.17 v1(167.25,89.17) ; C1605.1 120.63,89.87 120.53,89.97 120.24,89.97 120.13,90.07 120.13,90.3 120.44,90.61 v1(120.62,90.61)
GFX_PCIE_TX_P1: length 62.7
  TOP w0.102: v1(119.09,90.61) 119,90.51 118.84,90.51 118.74,90.61 118.74,90.99 118.86,91.11 120.75,91.11 121.26,90.6 128.94,90.6 129.15,90.81 133.29,90.81 134.89,92.41 146.48,92.41 146.65,92.59 151.8,92.59 153.37,91.01 159.97,91.01 161.82,89.16 165.73,89.16 167.25,90.68 169.14,90.68 169.24,90.58 169.24,90.36 v1(169.17,90.29)
  BOTTOM w0.102: C1607.1 119.11,89.84 119,89.94 118.69,89.94 118.59,90.05 118.59,90.27 118.71,90.4 118.99,90.4 119.09,90.5 v1(119.09,90.61) ; GPU1.AF7 172.97,87.42 172.97,87.94 172.01,88.9 171.73,88.9 171.37,89.27 171.37,89.32 169.76,90.92 169.58,90.92 169.46,90.81 169.46,90.38 169.37,90.29 v1(169.17,90.29)
GFX_PCIE_TX_P2: length 70.4
  TOP w0.102: v1(117.61,90.6) 117.42,90.6 117.24,90.43 117.24,89.41 118.76,87.89 120.11,87.89 120.8,87.2 125.53,87.2 126.54,88.22 128.37,88.22 129.9,89.74 133.8,89.74 135.43,91.37 146.14,91.37 146.41,91.09 151.8,91.09 153.24,89.64 159.79,89.64 161.36,88.06 168.57,88.06 170.2,89.69 170.2,91.48 169.83,91.85 169.67,91.85 v1(169.51,91.69)
  BOTTOM w0.102: v1(117.61,90.6) 117.42,90.6 117.24,90.43 117.24,89.77 117.42,89.59 C1609.1 ; v1(169.51,91.69) 169.64,91.82 169.78,91.82 171.4,90.2 172.16,90.2 172.71,89.65 172.71,89.21 173.36,88.56 173.69,88.56 174.22,88.02 GPU1.AE9
GFX_PCIE_TX_P3: length 69.7
  TOP w0.102: v1(171.62,90.92) 171.78,91.09 172.16,91.09 172.3,90.95 172.3,90.8 168.93,87.43 160.02,87.43 159.71,87.73 154.25,87.73 151.53,90.45 146.15,90.45 145.87,90.73 135.71,90.73 133.98,89 130.33,89 128.6,87.28 126.64,87.28 125.57,86.21 120.69,86.21 120.23,86.67 118.94,86.67 115.59,90.02 115.59,90.1 115.69,90.2 115.95,90.2 116.05,90.3 v1(116.05,90.56)
  BOTTOM w0.102: GPU1.AG9 173.74,89.28 173.74,89.43 172.08,91.09 171.78,91.09 v1(171.62,90.92) ; v1(116.05,90.56) 116.05,90.43 115.95,90.33 115.69,90.33 115.56,90.2 115.56,90 115.67,89.89 115.96,89.89 116.06,89.79 C1611.1
GPCPLL_AVDD: length 12.1
  TOP w0.305: v2(183.46,82.58) 183.09,82.21 L8001.2
  TOP w0.406: v1(187.59,78.04) 187.63,78 187.63,77.17 C8037.1
  TOP w0.508: v1(183.41,80.37) 183.09,80.69 L8001.2 ; v1(187.59,78.04) 187.15,78.48 C8047.1 185.75,77.26 C8048.1
  L3 w0.508: v1(187.59,78.04) 187.59,78.36 186.37,79.58 184.19,79.58 v1(183.41,80.37)
  BOTTOM w0.356: 187.05,78.04 v1(187.59,78.04)
GPD7: length 44.2
  TOP w0.102: v1(143.55,44.59) 143.47,44.5 142.97,44.5 v2(142.77,44.7) 142.54,44.94 142.54,45.7 143.02,46.18 R1525.2 143.73,46.18 143.89,46.03 R1524.1
  BOTTOM w0.076: 120.6,59.01 120.17,59.43 120.17,59.96 120.43,60.21 120.43,61.77 120.45,61.85 120.45,62.04 120.43,62.13 120.38,62.18 120.19,62.52 CPU1.BV35
  BOTTOM w0.102: 120.6,59.01 120.6,57.12 120.9,56.82 120.9,52.58 120.77,52.45 120.77,51.26 121.33,50.7 121.33,49.78 121.32,49.77 121.32,49.48 121.33,49.46 121.33,48.13 121.81,47.65 121.99,47.65 123.29,46.36 123.29,45.62 123.49,45.42 130.18,45.42 130.31,45.29 135.78,45.29 136.49,44.58 143.54,44.58 v1(143.55,44.59)
GPD11/LANPHYPC: length 15.1
  TOP w0.102: v1(118.76,58.98) 119.54,58.98 120.02,58.51 120.02,56.64 119.91,56.53 119.91,55.05 120.71,54.25 120.71,51.48 v2(120.95,51.24) 121.1,51.08 R1721.2
  BOTTOM w0.076: v1(118.76,58.98) 118.82,59.03 118.82,60.36 118.98,60.53 118.98,60.54 119.15,60.7 119.15,60.71 119.22,60.78 119.22,61.12 119.13,61.2 119.13,61.4 119.12,61.41 119.12,61.79 119.13,61.81 119.13,61.82 119.24,62.01 119.24,62.96 119.54,63.58 CPU1.BU34
GPIO0_CORE_VID: length 10.9
  TOP w0.089: v2(181.86,65.89) 182.42,66.45 R7960.1 183,66.86 v1(183.13,66.86)
  BOTTOM w0.089: R7959.1 182.8,66.53 v1(183.13,66.86) 183.46,67.19 183.46,67.97 184.19,68.71 184.19,70.03 185.04,70.88 185.04,71.27 184.86,71.45 184.86,71.84 185.02,71.99 185.02,72.44 184.89,72.56 184.89,72.95 185.35,73.4 GPU1.C6
GPIO1_GC6_FB_EN_GPU: length 4.4
  BOTTOM w0.127: R7958.1 182.01,67.39 182.01,67.62 183.97,69.57 183.97,70.38 GPU1.B2
GPIO2_EVEN_GPU#: length 16.9
  TOP w0.127: R7964.1 198.9,71.73 198.7,71.54 v2(197.53,71.54) 196.91,71.54 192.97,75.48 188.75,75.48 188.11,74.85 188.11,74.48 187.21,73.57 186.27,73.57 v1(185.87,73.97)
  BOTTOM w0.127: v1(185.87,73.97) 185.87,73.96 GPU1.D6
GPIO4_GC6_PWR_EN_GPU: length 14.3
  TOP w0.102: v1(184.7,76.33) 184.7,70.84 185.06,70.48 185.06,68.41 184.6,67.95 184.6,67.74 183.69,66.83 R7962.1 183.69,65.69 183,65 182.77,65 v2(182.54,64.77)
  BOTTOM w0.102: GPU1.F9 185.25,76.88 v1(184.7,76.33)
GPIO5_FRAME_LOCK#: length 6.9
  BOTTOM w0.102: v2(183.03,64.49) 183.03,64.8 183.51,65.28 R7963.1 183.94,65.66 183.94,67.77 185.11,68.94 185.11,70.39 GPU1.A3
GPIO5_GC6_NVVDD_OR: length 2.2
  TOP w0.102: Q8509.5 108.12,103.33 108.07,103.28 R8545.1 107.66,102.24 v2(107.16,102.24)
GPIO5_GC6_PWR_1V: length 3
  BOTTOM w0.102: v2(155.95,88.6) 155.95,88.8 155.23,89.52 U8605.4 154.28,89.52 154.07,89.31 R8651.1
GPIO5_GC6_PWR_1V_A: length 2.6
  BOTTOM w0.102: U8604.1 152.43,88.89 152.88,88.45 R8651.2 154.3,88.45 v2(154.45,88.6)
GPIO5_GC6_PWR_B: length 11.1
  BOTTOM w0.102: Q8601.D 148.92,91.42 149.42,91.93 151.89,91.93 152.95,92.99 153.13,92.99 153.56,93.42 v2(154.38,93.42) 154.42,93.38 154.42,93.03 154.27,92.89 153.87,92.89 153.71,92.74 153.71,92.1 153.56,91.95 R8635.1 154.1,91.62 R8648.1
GPIO5_GC6_PWR_EN: length 121.5
  TOP w0.102: R8545.2 108.33,101.78 v1(108.83,102.29) ; v1(182.34,65.56) 182.47,65.56 182.49,65.53 182.75,65.53 R7962.2
  L3 w0.102: v1(182.34,65.56) 181.43,66.47 177.74,66.47 175.84,68.38 175.84,69.37 175.76,69.45 175.76,72.65 168.85,79.56 168.85,80.08 167.91,81.02 167.91,81.03 167.68,81.26 166.92,81.26 165.12,83.06 165.12,84.89 161.56,88.45 161.56,88.61 161.52,88.65 161.52,88.68 159.89,90.3 159.87,90.3 159.69,90.48 159.69,90.48 159.68,90.49 159.21,90.96 158.03,90.96 v1(155.77,93.22) 156.23,93.68 158.52,93.68 161.69,90.5 165.68,90.5 167.61,92.43 167.61,94.64 v1(168.45,95.48) ; v1(108.83,102.29) 108.83,102.29 109.29,102.75 109.65,102.75 112.75,99.64 112.75,98.55 113.43,97.87 113.84,97.87 115.49,96.22 121.86,96.22 123.9,94.19 125.47,94.19 128.95,90.71 132.61,90.71 134.26,92.36 146.65,92.36 v1(146.86,92.15)
  BOTTOM w0.102: Q8606.5 169.69,95.86 169.44,95.61 168.57,95.61 v1(168.45,95.48) ; v1(182.34,65.56) 182.37,65.59 182.37,65.61 182.65,65.89 R7963.2 ; R7933.2 146.44,90.6 Q8601.S 146.78,92.08 v1(146.86,92.15) 147.24,92.53 151.92,92.53 152.5,93.11 152.5,93.53 153.12,94.15 v2(155.43,94.15) 155.77,93.8 v1(155.77,93.22)
GPIO6_VGA_CORE_PSI: length 7.9
  TOP w0.127: v1(185.21,66.86) 185.62,66.45 185.62,65.66 R7965.1 R7966.1
  BOTTOM w0.127: v2(185.72,66.6) 185.54,66.6 185.52,66.63 185.44,66.63 v1(185.21,66.86) 185.13,66.93 185.13,68.13 185.59,68.58 185.59,69.78 185.95,70.13 185.95,70.9 GPU1.A4
GPIO8_OVERT: length 46.2
  TOP w0.102: v1(188.06,61.88) 187.37,61.88 v2(187.17,61.67) 187.17,61.34 187.39,61.12 RN7910.2
  L3 w0.102: v1(188.06,61.88) 188.06,62.66 188.51,63.12 188.51,63.38 186.63,65.26 186.63,70.84 v1(186.48,71) 185.08,69.6 185.08,69.12 184.17,68.2 180.44,68.2 178.91,66.68 177.9,66.68 176.14,68.43 176.14,72.57 176.12,72.6 176.12,72.72 170.15,78.69 v1(170.15,80.5)
  BOTTOM w0.102: v1(170.15,80.5) 170.12,80.52 169.22,80.52 Q7904.S ; C7909.1 188.08,61.85 v1(188.06,61.88) ; GPU1.A6 186.99,71.5 v1(186.48,71)
GPIO8_OVERT#_EC: length 3.7
  BOTTOM w0.102: v2(167,75.52) 166.24,76.28 Q7904.D 165.59,76.28 D8602.K 164.46,75.14 R7934.2
GPIO9_ALERT: length 19.9
  TOP w0.102: RN7910.1 188.67,62.28 v1(188.54,62.41) 188.34,62.61 v2(187.98,62.61)
  L3 w0.102: v1(188.54,62.41) 188.82,62.69 188.82,63.51 186.99,65.33 186.99,72.44 187.44,72.9 187.44,75.29 186.04,76.69 185.68,76.69 185.29,76.3 v1(185.29,75.74)
  BOTTOM w0.102: v1(185.29,75.74) GPU1.F8
GPIO10_FBVREF: length 108.7
  TOP w0.102: v1(190.65,72.34) 189.25,72.34 188.47,71.56 187.13,71.56 v1(186.41,72.29) ; v1(206.24,105.62) 206.29,105.56 206.29,104.45 205.87,104.03 Q8101.G 204.54,104.28 R7910.1
  L3 w0.102: v1(190.65,72.34) 190.83,72.16 192.96,72.16 196.44,68.68 199.49,68.68 203.52,64.65 203.52,63.68 203.75,63.45 204.01,63.45 204.13,63.32 204.46,63.32 205.36,62.43 205.36,59.93 206.63,58.66 206.63,57.2 206.88,56.95 211.98,56.95 215,59.98 215,62.86 217.21,65.08 218.38,65.08 223.46,70.16 223.46,97.82 216.86,104.42 216.86,104.42 216.61,104.68 216.61,105.06 216.83,105.29 v1(216.83,105.51)
  BOTTOM w0.102: v1(186.41,72.29) 185.9,72.8 GPU1.C5 ; v1(216.83,105.51) 216.12,105.51 215.51,106.12 207.44,106.12 v2(207.23,105.92) 206.9,105.59 206.32,105.59 206.29,105.62 v1(206.24,105.62)
GPIO11_LCD_VDD: length 9.5
  TOP w0.089: v1(184.09,74.6) 184.09,68.94 v2(183.08,67.92) 182.82,67.92 R7961.1
  BOTTOM w0.089: GPU1.E7 184.71,75.1 184.22,74.6 v1(184.09,74.6)
GPIO12_PWR_LEVEL: length 19
  TOP w0.508: R7905.1 176.37,67.44 175.91,67.9 v2(175.91,68.33) 175.91,68.71 176.42,69.22 177.11,69.22 177.59,69.7 v1(178.76,69.7)
  L3 w0.381: v1(178.76,69.7) 180.08,71.02 180.08,71.38 182.11,73.41 184.12,73.41 185.25,74.54 v1(186.42,74.54)
  BOTTOM w0.356: v1(186.42,74.54) 186.41,74.53 GPU1.D7
  BOTTOM w0.508: v1(178.76,69.7) 178.35,69.29 177.18,69.29 177.13,69.24 177.03,69.24 177.01,69.22 175.29,69.22 D7902.A
GPIO13_LCD_BLEN: length 9.6
  TOP w0.127: v2(183.76,63.25) 183.76,63.81 R7967.1 184.17,64.93 184.91,65.67 v1(184.91,66.25)
  BOTTOM w0.127: v1(184.91,66.25) 184.63,66.53 184.63,68 185.36,68.74 185.36,70.01 185.63,70.27 185.63,70.68 185.29,71.02 185.29,71.57 GPU1.B4
GPP_B22_GSPI1_MOSI: length 13.1
  TOP w0.089: v1(126.36,55.6) 126.36,56.31 125.52,57.15 125.52,61.06 123.08,63.5 123.08,65 123.01,65.08 v2(123.01,65.08) 122.65,65.44 122.65,65.51 v1(122.65,65.51)
  BOTTOM w0.102: R1553.1 126.49,55.73 v1(126.36,55.6) ; v1(122.65,65.51) 122.61,65.51 CPU1.CA30
GPP_E3/CPU_GP0: length 1.7
  TOP w0.102: v1(123.8,79.22) 123.8,79.04 TP304.1
  BOTTOM w0.102: CPU1.CE9 124.06,78.97 123.81,79.22 v1(123.8,79.22)
GPP_E23: length 6.4
  TOP w0.102: TP402.1 131.36,80.5 132.23,81.36 132.23,81.61 v1(132.33,81.71)
  BOTTOM w0.102: CPU1.CN4 128.85,82.05 129.1,82.05 129.12,82.04 129.37,82.04 129.53,82.2 130.55,82.2 130.56,82.18 130.58,82.18 131.14,81.62 132.24,81.62 v1(132.33,81.71)
GPP_H17_STRAP: length 14
  TOP w0.102: v1(133.6,66.96) 134.02,66.96 134.46,67.4 134.46,67.73 134.14,68.05 131.95,68.05 v2(131.32,67.42) 130.6,66.7 130.42,66.7 R1527.1
  BOTTOM w0.102: CPU1.CP26 129.6,68.23 131.51,68.23 131.76,68.48 133.17,68.48 133.55,68.09 134.11,68.09 134.46,67.74 134.46,67.4 134.02,66.96 v1(133.6,66.96)
GPP_H21: length 21.5
  L4 w0.102: v1(125.34,68.38) 125.7,68.02 126.29,68.02 127.18,68.91 127.98,68.91 130.31,71.24 132.12,71.24 134.06,73.18 135.95,73.18 136.58,73.82 137.38,73.82 137.55,73.64 138.84,73.64 v1(139.25,74.05)
  BOTTOM w0.102: R1522.2 142.03,72.34 v2(141.14,72.34) 140.28,72.34 R1523.1 139.25,73.37 v1(139.25,74.05) ; v1(125.34,68.38) 125.34,68.4 CPU1.CF25
GPP_H23: length 15.8
  BOTTOM w0.102: CPU1.CM26 128.33,68.82 130.13,68.82 130.53,68.43 131.44,68.43 131.68,68.67 133.26,68.67 133.62,68.3 134.18,68.3 134.66,67.82 134.66,67.31 134.39,67.03 134.39,66.41 134.62,66.17 135.48,66.17 v2(135.9,66.6) 136.42,67.11 139.06,67.11 139.34,67.39 R1513.2 R1514.1
GPPC_H18_BOOTMPC: length 41.2
  TOP w0.102: v1(134.03,65.97) 134.23,65.76 141.63,65.76 142.47,66.6 145.59,66.6 146.68,67.69 146.68,68.6 147.32,69.24 147.75,69.24 147.77,69.27 149.5,69.27 152.37,72.14 156.51,72.14 156.97,72.6 159.71,72.6 v1(160.07,72.95)
  L6 w0.102: v1(134.03,65.97) 134.03,65.35 133.48,64.8 131.14,64.8 130.85,65.09 130.62,65.09 v1(127.79,67.92)
  BOTTOM w0.102: v1(127.79,67.92) 127.88,67.92 128.16,68.2 128.65,68.2 CPU1.CN27 ; v1(160.07,72.95) 159.94,72.82 v2(159.32,72.82) 159.13,73.02 R4020.1
GPU_CLKREQ#: length 17.7
  TOP w0.102: v2(174.64,94.52) v1(174.05,94.52)
  L6 w0.102: v1(174.12,84.59) 174.8,85.27 174.8,86.88 175.48,87.57 175.48,87.63 175.74,87.89 175.8,87.89 175.94,88.03 175.94,92.03 175.56,92.41 175.56,93 v1(174.05,94.52)
  BOTTOM w0.102: R7618.2 174.11,93.19 173.12,94.19 173.12,95.13 173.38,95.38 Q7601.S 174.05,94.95 v1(174.05,94.52) 174.07,94.54 R7603.1 ; GPU1.AC6 v1(174.12,84.59)
GPU_EVENT#: length 155.5
  TOP w0.127: v1(201.47,65.28) 201.47,67.92 R7948.1 200.58,69.9 R7944.1 200.83,71.6 v2(200.83,72.6) 200.83,73.2 v1(199.57,74.46) ; R2003.1 v1(129.08,51.77)
  L3 w0.127: v1(201.47,65.28) 201.47,64.09 200.45,63.07 200.45,61.68 v1(203.03,59.1)
  L6 w0.127: v1(200.32,31.22) 195.27,31.22 193.94,32.55 191.94,32.55 189.57,34.93 180.31,34.93 179.45,35.79 178.12,35.79 175.38,38.53 168.98,38.53 168.27,37.82 167.15,37.82 166.46,37.14 141.81,37.14 136.82,42.13 136.82,50.88 135.4,52.3 129.61,52.3 v1(129.08,51.77)
  BOTTOM w0.127: v1(199.57,74.46) 199.61,74.5 200.35,74.5 Q7906.D ; v1(203.03,59.1) 202.4,58.47 200.68,58.47 199.31,57.1 197.91,57.1 197.81,57 197.76,57 197.44,56.68 196.5,56.68 195.96,57.23 194,57.23 193.27,56.49 193.27,55.51 193.54,55.23 193.54,53.72 193.85,53.42 193.85,49.99 194.61,49.23 198.04,49.23 198.42,48.85 198.42,47.07 198.91,46.57 198.91,45.58 193.49,40.16 193.49,34.2 196.81,30.88 199.98,30.88 v1(200.32,31.22)
GPU_EVENT_GPU#: length 33.4
  TOP w0.127: R7965.2 186.23,65.05 186.23,70.59 185.99,70.83 185.99,72.46 186.68,73.15 187.57,73.15 188.34,73.92 188.34,74.75 188.84,75.25 192.79,75.25 196.92,71.12 198.62,71.12 v2(198.83,70.92) 199.28,70.92 R7944.2 199.77,71.4 R7964.2 R7949.1 199.77,73.44 197.58,75.62 197.56,75.62 197.45,75.72 196.83,75.72 v1(196.7,75.85)
  BOTTOM w0.127: v1(196.7,75.85) 198.58,75.85 Q7906.S
GPU_EVENT_MCP#: length 17.3
  TOP w0.127: R2003.2 129.08,54.91 128.42,55.57 128.42,56.04 127.79,56.66 127.79,61.48 126.73,62.55 126.73,63.87 125.87,64.72 125.87,65.75 125.15,66.47 124.65,66.47 v2(124.54,66.58) v1(123.53,67.59)
  BOTTOM w0.127: v1(123.53,67.59) 123.49,67.64 CPU1.CC27
GPU_I2C:
  vias: v2(190.16,59.01)
GPU_I2CA_SCL: length 14.6
  L6 w0.089: v1(188.11,71.97) 188.33,71.97 189.1,71.2 191.81,71.2 195.57,67.43 v1(195.57,67.29)
  BOTTOM w0.089: v1(195.57,67.29) 195.62,67.24 195.62,67.01 195.97,66.66 196.83,66.66 v2(197.03,66.87) 197.61,67.45 RN7701.1 ; GPU1.B7 186.99,72.83 187.85,71.97 v1(188.11,71.97)
GPU_I2CA_SDA: length 13.8
  L6 w0.089: v1(196.26,67.31) 196.16,67.41 196.06,67.41 191.97,71.5 189.2,71.5 188.61,72.09 v1(188.61,72.36)
  BOTTOM w0.089: v1(196.26,67.31) 196.27,67.32 196.27,67.81 196.62,68.15 v2(196.67,68.15) 196.93,68.41 197.86,68.41 RN7701.2 ; GPU1.A7 188.02,72.37 188.28,72.37 188.28,72.36 v1(188.61,72.36)
GPU_PEX_RST#: length 19.2
  BOTTOM w0.102: GPU1.AC7 174.69,85.09 175.12,84.65 175.12,84.35 172.01,81.23 171.51,81.23 171.12,81.61 168.16,81.61 C7903.1 167.65,81.1 167.18,81.1 166.67,81.61 R7613.2 v2(165.58,80.72) 164.31,79.45 R7614.2 164.98,78.64 Q7904.G 164.55,77.75 R7615.1
GPU_PEX_RST_D#: length 3.2
  BOTTOM w0.127: R7615.2 162.6,78.06 v2(162,78.06) 162,76.57 D7601.3
GPU_PEX_RST_HOLD: length 10.9
  BOTTOM w0.127: R7973.2 163.04,76.84 163.04,75.79 162.76,75.5 161.14,75.5 160.76,75.12 D7601.1 159.49,75.12 159.48,75.11 v2(159.38,75.11) 159.38,75.52 160.27,76.41 160.98,76.41 161.49,76.91 161.49,78.11 161.82,78.44 162.12,78.44 R7931.2
GPU_PEX_RST_HOLD_GPU#: length 31.2
  L3 w0.127: v1(173.76,68.48) 173.73,68.51 173.3,68.51 172.31,69.5 172.31,71.16 169.26,74.21 169.15,74.21 v1(167.43,75.92)
  BOTTOM w0.102: 181.91,68.2 182.04,68.33 182.04,69.02 184.44,71.42 GPU1.C4
  BOTTOM w0.127: v1(167.43,75.92) 166.41,76.94 R7973.1 ; v1(173.76,68.48) 173.76,68.05 v2(174.03,67.77) 174.59,67.21 174.59,66.76 174.88,66.47 175.75,66.47 176.88,65.34 176.88,65.26 177.41,64.73 178.06,64.73 178.94,65.61 179.32,65.61 181.91,68.2
GPU_PWR_LEVEL: length 5.2
  TOP w0.102: U2401.10 v2(48.56,40.91) 48.78,40.91 48.99,41.13 R2422.2 49.5,41.1 49.5,40.9 49.85,40.54 51.45,40.54 R2420.2
GPU_ROM: length 4.9
  BOTTOM w0.406: R7935.1 197.76,70.76 v2(197.76,70.82) 196.92,69.98 R7920.1 196.73,70.05 196.73,70.53 R7918.1
  BOTTOM w0.508: R7913.2 196.26,70.72 196.39,70.84 R7918.1 ; R7912.2 198.39,70.16 R7935.1
GPU_ROM_SCLK: length 13.9
  BOTTOM w0.089: R7921.1 198.55,68.89 197.43,68.89 197.23,68.68 196.87,68.68 196.62,68.94 R7920.2 195.67,69.37 193.14,71.9 192.59,71.9 v2(191.46,73.03) 190.52,73.97 190.52,74.91 189.76,75.67 189.76,75.97 189.37,76.36 GPU1.C12
GPU_ROM_SI: length 15.1
  L3 w0.089: v1(191.94,73.79) 192.37,74.22 192.78,74.22 194.62,72.38 194.62,71.6 194.66,71.57 194.66,71.53 197.05,69.14 v1(197.05,69.12)
  BOTTOM w0.089: v2(199.89,69.93) 199.28,69.32 R7924.1 199.08,69.47 197.83,69.47 R7935.2 197.48,69.55 v1(197.05,69.12) ; GPU1.B12 189.93,76.26 190.09,76.1 190.09,75.67 190.72,75.03 190.72,74.55 191.05,74.22 191.05,73.97 191.23,73.79 v1(191.94,73.79)
GPU_ROM_SO: length 7.9
  BOTTOM w0.089: R7932.1 196.34,71.99 R7918.2 195.02,72.24 v2(194.81,72.24) 194.48,72.24 191.71,75.01 191.59,75.01 190.82,75.77 GPU1.A12
GPU_THM_SMBCLK: length 6.8
  TOP w0.089: R2438.1 52.62,40.92 52.09,41.46 51.4,41.46 50.64,42.22 v2(49.93,42.22) 49.04,42.22 48.36,41.53 47.82,41.53 47.64,41.71 U2401.12
GPU_THM_SMBDAT: length 8.6
  TOP w0.089: R2439.1 54.02,39.98 v2(53.64,39.98) 53.13,39.98 51.94,41.18 51.3,41.18 50.92,41.56 48.76,41.56 48.46,41.25 47.72,41.25 47.66,41.31 U2401.11
GSEN2_INT1: length 78.9
  TOP w0.102: v1(163.62,52.96) 163.62,53.06 163.95,53.39 164.71,53.39 R7011.2 R7009.2 165.73,52.05 165.86,52.18
  TOP w0.254: v1(166.54,59.51) 166.03,59.01 v2(165.93,59.01)
  TOP w0.305: U7001.12 165.86,52.18
  L6 w0.102: v1(215.54,51.79) 211.09,51.79 210.23,52.66 206.07,52.66 200.1,58.64 200.1,59.83 199.84,60.09 199.84,62 199.16,62.69 194.7,62.69 193.53,63.86 189.87,63.86 188.78,64.95 179.66,64.95 178.73,64.02 177.34,64.02 171.94,58.63 166.92,58.63 166.54,59.01 v1(166.54,59.51)
  BOTTOM w0.102: v1(215.54,51.79) 216.08,51.25 IOBD1.4 ; v1(166.54,59.51) 166.41,59.39 164.18,59.39 163.75,58.96 163.75,57.1 163.49,56.85 162.5,56.85 162.05,56.39 162.05,53.47 162.55,52.96 v1(163.62,52.96)
GSEN2_INT1_C: length 2.5
  TOP w0.102: R7009.1 163.52,52.05 R2025.2 163.24,52.07 162.4,51.23 v2(162.4,51.03)
GSEN2_INT1_ISH: length 58.7
  TOP w0.102: R2025.1 162.86,50.57 161.82,50.57 v2(161.09,49.85) 160.31,49.06 159.39,49.06 158.15,47.83 158.15,45.91 v1(158.74,45.32)
  BOTTOM w0.076: CPU1.CA36 122.06,62.15 121.93,61.9 121.86,61.84 121.81,61.75 121.81,61.49 122.08,61.21 122.08,60.65 121.7,60.27 121.7,58.42 121.56,58.28 121.56,57.96 122.37,57.15 122.95,57.15 123.74,56.36 123.74,56.26 123.74,56.25 123.74,55.21
  BOTTOM w0.102: 123.74,55.21 123.74,54.09 128.22,49.61 129.07,49.61 131.99,46.69 136.04,46.69 136.98,45.75 139.74,45.75 140.58,46.59 157.47,46.59 v1(158.74,45.32)
GSEN2_INT2: length 75.5
  TOP w0.102: 166.17,52.68 165.94,52.68 165.73,52.89 165.73,53.72 165.63,53.83 R7010.2 R7012.2 v2(165.17,57.2) v1(167.1,59.13)
  TOP w0.305: 166.17,52.68 U7001.11
  L6 w0.102: v1(167.1,59.13) 168.14,60.18 172.26,60.18 174.24,62.16 174.24,63.17 175.61,64.54 176.57,64.54 177.16,65.13 177.16,65.54 178.1,66.47 182.92,66.47 183.59,65.81 189.17,65.81 190.21,64.77 193.92,64.77 195.26,63.43 199.41,63.43 200.53,62.31 200.53,60.48 201.18,59.82 201.67,59.82 202.86,58.63 204.39,58.63 205.18,57.84 210.89,57.84 214.32,54.41 217.57,54.41 219.91,52.07 v1(219.91,50.75)
  BOTTOM w0.102: IOBD1.5 v1(219.91,50.75)
GSEN2_INT2_C: length 59.1
  TOP w0.102: v1(158.46,51.29) 158.46,51.16 158.54,51.08 v2(159.25,51.08) 161.11,51.08 163.85,53.83 R7010.1 ; R2026.2 122.83,51.56 v1(122.65,51.39)
  BOTTOM w0.102: v1(122.65,51.39) 122.65,48.92 124.15,47.42 124.15,45.72 124.25,45.62 130.27,45.62 130.4,45.49 135.87,45.49 136.58,44.78 141.69,44.78 141.93,45.02 148.24,45.02 148.59,44.68 149.35,44.68 150.3,45.63 157.47,45.63 158.22,44.88 158.95,44.88 159.6,45.53 160.18,45.53 160.62,45.98 160.62,49.13 v1(158.46,51.29)
