# Allegro board 17859-1.0710WZS1337.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PM_SLP_S3#: length 313.8
  TOP w0.102: v1(57.7,48.21) 57.96,47.96 59.71,47.96 59.76,48.01 63.01,48.01 66.36,44.66 66.36,43.82 67.25,42.93 73.35,42.93 78.65,37.63 100.15,37.63 101.46,38.94 112.56,38.94 113.35,38.16 121.3,38.16 122.7,39.56 122.7,45.44 122.12,46.03 v1(122.12,46.15) ; R4010.1 211.88,45.06 v1(212.25,44.69) 212.72,44.22 213.28,44.22 213.45,44.05 Q4001.2 214.19,44.05 214.49,43.75 214.49,43.48 215.07,42.9 215.38,42.9 215.82,42.46 215.82,41.79 213.86,39.84 213.86,37.79 214.07,37.59 214.07,36.24 213.07,35.25 213.07,31.49 215.18,29.38 v1(215.18,27) ; D4003.K 204.39,49.15 203.77,48.53 203.77,47.47 204.98,46.26 206.52,46.26 v1(207.13,46.87) ; v1(51.38,54.61) 51.91,55.15 R2740.1
  L3 w0.102: v1(174.16,31.96) 172.51,33.61 172.51,33.86 172.08,34.29 172.08,34.4 170.53,35.94 170.32,35.94 170.32,35.94 168.75,35.94 v1(167.84,36.86) ; v1(51.38,54.61) 51.81,55.04 52.91,55.04 53.99,53.96 53.99,53.29 55.64,51.65 56.08,51.65 57.93,49.79 57.93,49.14 57.7,48.91 v1(57.7,48.21) ; v1(168.62,62.99) 168.68,62.99 168.73,63.05 168.88,63.05 172.61,59.31 172.61,46.04 189.56,29.09 189.88,29.09 190.57,28.4 v1(190.57,27.94)
  L6 w0.102: v1(174.16,31.96) 175.76,30.36 178.15,30.36 178.43,30.64 182.52,30.64 184.17,28.98 187.85,28.98 188.89,27.94 v1(190.57,27.94) 190.57,27.22 191.44,26.34 198.26,26.34 200.54,24.07 206.51,24.07 207.23,24.79 211.26,24.79 213.47,27 v1(215.18,27) ; v1(135.15,43.56) 135.15,43.03 135.75,42.43 135.75,41.01 140.21,36.54 167.52,36.54 v1(167.84,36.86) ; v1(168.62,62.99) 168.17,63.45 168.17,64.29 168.42,64.54 168.42,65.89 163.37,70.94 v1(163.37,71.05)
  BOTTOM w0.076: CPU1.BU36 119.56,62.21 119.56,62.21 119.44,61.98 119.41,61.97 119.28,61.75 119.28,61.48 119.36,61.41 119.36,61.39 119.48,61.27 119.48,60.58 119.22,60.33 119.22,58.85 TP1710.1
  BOTTOM w0.102: v1(135.15,43.56) 134.87,43.56 134.11,44.33 129.86,44.33 129.72,44.47 123.07,44.47 122.12,45.42 v1(122.12,46.15) 121.63,46.64 121.48,46.64 120.34,47.78 120.34,50.52 120.42,50.6 120.42,51.01 120.24,51.18 120.24,51.5 118.13,53.61 118.13,56.75 TP9952.1 118.41,58.04 TP1710.1 ; U4007.1 162.72,73.44 162.2,72.93 162.2,72.92 161.93,72.65 161.93,72.23 160.95,71.25 R4017.1 161.03,70.28 D4004.K 162.61,70.28 v1(163.37,71.05) ; v1(212.25,44.69) 211.94,44.39 209.34,44.39 208.88,44.84 208.88,45.11 v1(207.13,46.87)
PM_SLP_S4#: length 429.1
  TOP w0.102: v1(119.88,67.59) 120.03,67.59 TP9950.1 ; TP1711.1 216.58,47.25 v1(216.94,47.25) ; v1(130.22,41.46) 122.57,33.81 72.28,33.81 70.33,35.77 68.42,35.77 68.32,35.87 v1(68.27,35.87)
  L3 w0.102: v1(75.99,16.39) 75.08,17.3 74.21,17.3 73.93,17.58 67.79,17.58 66.47,18.89 66.47,32.93 68.27,34.72 v1(68.27,35.87) 67.18,35.87 62.58,40.46 62.58,43.98 60.9,45.65 60.9,47.37 60.93,47.4 60.93,47.88 59.66,49.15 59.66,49.25 59.51,49.41 59.51,50.55 57.6,52.45 57.6,54.49 56.53,55.55 56.26,55.55 56.23,55.53 54.32,55.53 52.62,57.23 v1(50.31,57.23) ; v1(108.44,98.24) 108.41,98.28 107.08,98.28 104.23,95.43 92.58,95.43 90.29,97.72 87.6,97.72 86.3,96.42 85.11,96.42 83.28,98.25 83.28,99.24 82.39,100.13 79.42,100.13 78.89,99.6 78.35,99.6 77.64,98.88 77.64,97.64 77.92,97.36 77.93,97.36 78.4,96.88 78.4,95.23 78.15,94.97 74.29,94.97 73.63,95.63 73.63,95.94 71.75,97.82 70.25,97.82 68.47,96.04 66.34,96.04 65.91,95.61 64.64,95.61 63.7,94.67 47.54,94.67 46.63,95.58 44.34,95.58 39.06,90.3 39.06,89.11 35.68,85.73 35.68,83.9 34.92,83.14 34.92,81.69 34.08,80.85 34.08,77.7 33.04,76.66 33.04,75.19 31.97,74.13 31.97,73.92 31.49,73.43 31.49,70.59 29.89,68.99 29.89,68.43 29.97,68.35 29.97,67.67 29.66,67.36 29.66,66.68 30.32,66.02 31.07,66.02 32.94,64.14 32.94,62.41 32.02,61.5 32.02,58.53 32.53,58.02 33.32,58.02 34.28,57.05 34.28,56.24 33.54,55.5 v1(33.54,53.67)
  L4 w0.102: v1(216.94,47.25) 216.33,46.64 216.33,40.46 215.78,39.92 215.78,36.87 216.86,35.79 216.86,35.03 216.25,34.42 216.25,32.42 v1(216.35,32.32)
  L6 w0.102: v1(33.54,53.67) 33.63,53.75 39.11,53.75 39.69,54.33 39.69,54.61 39.94,54.87 41.54,54.87 43.03,56.37 47.26,56.37 47.57,56.06 49.14,56.06 v1(50.31,57.23) ; v1(216.35,32.32) 216.88,31.79 216.88,31.27 216.63,31.02 216,31.02 215.74,31.27 215.39,31.27 214.88,31.78 212.13,31.78 211.14,30.79 206.72,30.79 205.84,31.68 202.58,31.68 202.43,31.52 201.77,31.52 201.04,30.79 195.12,30.79 193.75,32.16 191.81,32.16 190.04,33.94 186.81,33.94 186.25,34.5 180.21,34.5 179.29,35.41 177.97,35.41 175.66,37.72 172.05,37.72 170.61,36.28 167.93,36.28 167.84,36.19 135.49,36.19 v1(130.22,41.46) 128.44,43.23 128.44,44.12 126.33,46.23 126.33,46.26 126.31,46.28 126.31,50.22 125.88,50.65 125.88,51.89 125.34,52.43 125.34,52.94 122.3,55.98 121.58,55.98 120.76,56.81 120.76,58.29 117.68,61.37 117.68,66.5 118.77,67.59 v1(119.88,67.59)
  BOTTOM w0.102: IOBD1.12 v1(216.94,47.25) ; R4024.1 108.07,100.87 108.07,99.39 108.44,99.03 v1(108.44,98.24) ; PR5116.1 75.99,14.84 v1(75.99,16.39) ; v1(119.88,67.59) 119.88,67.61 CPU1.BU27
PM_SLP_S5#: length 8.5
  TOP w0.102: TP1712.1 112.62,69.09 115.62,69.09 117.62,67.09 TP9949.1 117.71,65.94 v1(118.1,66.34)
  BOTTOM w0.102: v1(118.1,66.34) 118.13,66.34 118.37,66.58 CPU1.BT29
POWER_SW_IN#: length 11.5
  TOP w0.102: R2432.2 R2451.2 51.81,32.13 51.23,32.72 49.95,32.72 49.52,33.15 v2(49.52,33.53) C2426.1 49.52,35.38 48.21,36.7 45.33,36.7 45.18,36.55 U2401.127
PQ3802_1: length 10.7
  TOP w0.102: R4309.2 23.51,97.54 R4302.1 23.9,97.72 23.97,97.64 24.86,97.64 25.14,97.92 25.14,98.71 26.11,99.67 28.35,99.67 v2(28.95,99.06) 29.31,98.71 29.31,96.89 Q4302.B
PQ4348_D: length 7.1
  TOP w0.254: R4368.2 40.63,80.85 40.28,81.21 v2(39.8,81.21) 39.36,80.77 39.36,79.58 v1(39.29,79.5)
  BOTTOM w0.254: v1(39.29,79.5) 38.02,78.23 36.52,78.23 Q4348.D
PQ4405_2: length 14.1
  TOP w0.102: v1(165.02,17.88) 165.02,17.53 PR4462.1 ; v1(169.36,11.13) v2(169.95,11.13) 170.81,10.26 170.81,9.32 PR4463.1
  L4 w0.102: v1(165.02,17.88) 165.96,16.94 166.24,16.94 168.12,15.07 168.12,14.79 169.26,13.64 169.26,11.46 169.29,11.43 169.29,11.2 v1(169.36,11.13)
  BOTTOM w0.102: v1(169.36,11.13) 169.36,11.43 169.21,11.59 PQ4405.2
PQ4405_3: length 3.5
  TOP w0.089: v1(168.73,11.13) 169.08,10.77 PR4476.1
  BOTTOM w0.089: PQ4405.3 168.21,12.08 167.94,11.81 v2(167.94,11.13) v1(168.73,11.13)
PQ4405_5: length 4.1
  TOP w0.102: PC4438.1 169.31,14.35 v1(169.03,14.63) 168.65,15.01 PR4474.2 168.83,15.5 v2(169.56,15.5)
  BOTTOM w0.102: PQ4405.5 169.21,14.48 169.06,14.63 v1(169.03,14.63)
PQ4405_6: length 4.6
  TOP w0.102: v1(170.5,12.88) 170.25,12.88 170.1,13.03 PR4450.1 170.2,13.54 171.01,14.35 PC4438.2 171.09,15.01 v2(170.86,15.24)
  BOTTOM w0.102: v1(170.5,12.88) 170.25,12.88 169.86,13.27 PQ4405.6
PQ4408_C: length 3.4
  TOP w0.102: PR4462.2 PR4475.1 165.75,16.28 165.88,16.41 v2(166.31,16.41) 166.31,15.76 v1(166.23,15.67)
  BOTTOM w0.102: v1(166.23,15.67) 165.95,15.95 PQ4408.C
PQ4408_E: length 3.7
  TOP w0.102: PR4436.1 167.66,15.98 v1(167.89,15.98) 167.99,15.98 PR4473.2 169.08,16.41 v2(169.44,16.77)
  BOTTOM w0.102: v1(167.89,15.98) 167.61,15.71 PQ4408.E
PQ4417_D: length 4.5
  TOP w0.254: v2(96.01,8.21) 96.18,8.21 96.56,7.83 PR4430.2 96.95,7.8 PQ4417.D 96.95,6.68 97.38,6.25 98.98,6.25 PR4431.2
PQ4418_2: length 3.2
  TOP w0.254: PQ4418.2 99.89,7.72 99.94,7.67 v2(99.94,7.47) 99.33,7.47 PR4431.1 99.28,7.19 99.82,6.66 PR4432.1
PQ4418_3: length 4
  TOP w0.254: PQ4418.3 100.54,6.46 v2(100.71,6.3) 100.71,5.46 PR4433.1
PQ4418_5: length 3.6
  TOP w0.254: v2(98.37,10.47) 98.22,10.62 PC4446.1 99.03,11.36 PR4465.2 99.64,11.31 99.89,11.05 PQ4418.5
PQ4418_6: length 4.5
  TOP w0.254: PQ4418.6 98.91,10.25 98.62,9.96 97.56,9.96 PR4464.1 97.38,9.98 v2(96.56,9.98) 96.56,10.62 PC4446.2
PRIM_PWRGD: length 309.8
  TOP w0.102: PR5301.1 94.69,15.55 94.69,16.36 v1(94.66,16.39) ; v1(203.33,43.46) 203.59,43.73 R4030.1 ; ED4001.1 209.38,50.31 v1(209.62,50.07) ; v1(54.53,51.92) 54.38,51.92 54.2,52.1 53.82,52.1 53.12,51.4 53.12,50.82 v2(52.93,50.62) 52.84,50.53 50.41,50.53 50.21,50.34 50.21,49.2 50.11,49.1 47.78,49.1 47.59,48.91 U2401.30
  L3 w0.102: v1(94.66,16.39) 94.66,18.44 95.22,19 102.8,19 104.5,20.7 150.29,20.7 150.34,20.65 151.68,20.65 151.73,20.7 173.63,20.7 174.67,21.75 174.67,21.95 174.66,21.96 174.66,32.15 174.03,32.77 174.03,33.35 174.34,33.66 174.34,34.85 169.16,40.03 v1(169.16,41.58)
  L4 w0.102: v1(209.62,50.07) 209.62,49.86 209.01,49.25 209.01,47.12 208.33,46.43 206,46.43 203.33,43.76 v1(203.33,43.46) ; v1(202.23,31.96) 201.95,32.24 199.66,32.24 199.16,32.74 198.14,32.74 197.22,31.83 186.63,31.83 185.49,32.97 180.72,32.97 179.29,34.39 178.17,34.39 171.16,41.41 169.39,41.41 169.21,41.58 v1(169.16,41.58) 167.72,43.02 v1(166.8,43.02)
  BOTTOM w0.102: v1(203.33,43.46) 203.33,43.22 200.04,39.93 200.04,34.47 199.18,33.61 199.18,32.82 200.04,31.96 v1(202.23,31.96) ; v1(166.8,43.02) 166.8,42.19 165.83,41.23 165.83,40.57 162.33,37.06 149.73,37.06 148.66,35.99 148.66,35.97 148.53,35.84 117.22,35.84 117.19,35.82 116.61,35.82 111.78,40.64 108.4,40.64 107.72,41.33 78.3,41.33 71.5,48.14 68.5,48.14 68.24,47.88 61.93,47.88 60.4,49.41 60.4,49.43 59.08,50.75 59.05,50.75 58.54,51.26 57.5,51.26 56.84,51.92 v1(54.53,51.92)
PROCHOT: length 14.7
  TOP w0.089: U2401.83 31.07,42.51
  TOP w0.102: v1(26.04,45.96) 26.33,45.67 26.33,44.66 25.8,44.12 R2417.1 R2418.1 24.4,43.89 24.78,43.51 26.18,43.51 v2(26.42,43.28) 27.25,42.45 31.01,42.45 31.07,42.51
  BOTTOM w0.102: v1(26.04,45.96) 25.81,45.96 25.35,45.5 Q2408.G
PROCHOT#_CPU: length 394.6
  TOP w0.089: PR4433.2 98.65,4.9 v1(98.62,4.93) ; R2416.2 25.32,46.13 25.32,47.35 25.06,47.6 v1(23.67,47.6) ; v1(171.11,3.84) 171.31,4.04 171.31,5.67 170.53,6.45 170.53,7.11 170.21,7.44 170.21,7.54 170.2,7.55 170.2,7.9 170.45,8.16 170.5,8.16 170.66,8.31 v1(170.66,8.84) 169.95,9.55 PR4476.2 ; v2(41.52,58.98) 41.37,58.83 v1(40.81,58.83) 40.79,58.81 38.2,58.81 37.48,59.53 37.48,60.46 38.56,61.55 38.63,61.55 PR4603.2
  L3 w0.114: v1(37.92,52.78) 37.92,50.11 40.44,47.59 40.44,46.8 39.69,46.05 v1(39.69,44.07) ; v1(92.93,91.8) 92.4,92.33 87.91,92.33 85.07,89.49 68.78,89.49 67.76,88.47 59.98,88.47 59.46,88.99 56.11,88.99 55.8,88.67 50.52,88.67 46.48,84.63 46.48,80.93 45.36,79.81 45.36,78.9 44.04,77.57 44.04,75.31 43.12,74.4 43.12,73.48 40.83,71.19 40.83,68.08 42.12,66.79 42.12,64.99 41.29,64.16 41.29,59.31 v1(40.81,58.83)
  L4 w0.114: v1(39.69,44.07) 40.08,44.45 41.55,44.45 41.93,44.07 43.58,44.07 43.76,43.89 44.24,43.89 45.25,42.88 48.56,42.88 50.78,40.67 50.78,36.32 52.12,34.97 52.12,30.48 52.5,30.1 52.5,27.82 53.23,27.08 53.23,21.52 57.71,17.05 59.33,17.05 60.7,15.67 62.1,15.67 62.35,15.42 66.01,15.42 67.71,13.72 70.15,13.72 71.2,12.67 73.42,12.67 73.58,12.84 75.88,12.84 76.94,11.78 89.44,11.78 90.95,13.29 95.07,13.29 96.31,14.53 99.2,14.53 101.92,17.25 107.99,17.25 110.2,19.45 169.71,19.45 171.03,18.13 171.03,13.52 171.87,12.68 171.87,9.76 171.88,9.75 171.88,9.37 171.35,8.84 v1(170.66,8.84) ; v1(98.62,4.93) 99.21,4.93 101.52,7.24 109.47,7.24 110.94,5.77 112.44,5.77 116.45,1.76 116.83,1.76 v1(116.86,1.73) ; v1(37.92,52.78) 37.92,56.7 38.14,56.92 38.14,57.28 39.69,58.83 v1(40.81,58.83)
  L6 w0.089: v1(116.86,1.73) 117.29,2.16 126.44,2.16 127.78,3.5 149.02,3.5 149.06,3.46 153.49,3.46 153.53,3.5 157.82,3.5 158.57,4.24 159.4,4.24 159.99,3.66 162.78,3.66 163.19,4.07 168.37,4.07 169.03,3.41 170.69,3.41 v1(171.11,3.84)
  BOTTOM w0.089: v1(170.66,8.84) 170.66,8.94 170.29,9.31 168.61,9.31 168.21,8.91 167.37,8.91 167.33,8.87 165.88,8.87 165.66,9.09 PQ4416.3 ; v1(92.93,91.8) 92.98,91.85 92.98,92.36 92.68,92.66 92.04,92.66 R301.2 91.66,91.78 R302.1 ; v1(40.81,58.83) 37.76,58.83 37.21,59.38 37.21,59.82 37.64,60.25 PR4607.1 ; v1(23.67,47.6) 27.02,47.6 27.22,47.41 27.92,47.41 28.96,48.45 28.96,50.01 29.36,50.41 32.65,50.41 34,51.76 36.89,51.76 v1(37.92,52.78)
PROCHOT#_CPU_R: length 12.7
  BOTTOM w0.089: CPU1.Y4 96.54,82.82 96.37,83 96.37,83.44 96.55,83.62 96.55,85.4 95.96,85.99 95.96,87.53 93.92,89.56 92.68,89.56 91.98,90.26 R302.2 91.98,90.67 92.4,91.09 92.4,91.79 92.4,91.8 92.4,92.18 v2(92.53,92.31)
PROJECT_ID0: length 19.7
  L6 w0.102: v1(125.69,69.6) 125.77,69.6 126.51,68.85 126.51,68.15 125.93,67.57 125.93,65.81 125.9,65.79 125.9,64.7 127.73,62.87 127.73,62.84 127.98,62.59 128.01,62.59 128.54,62.05 128.54,58.68 v1(129.71,57.51)
  BOTTOM w0.089: CPU1.CH23 126.02,69.96 125.69,69.63 v1(125.69,69.6)
  BOTTOM w0.102: v1(129.71,57.51) 129.71,56.44 130.04,56.11 130.65,56.11 R2114.1 R2113.2 132.1,55.65 132.76,54.99 v2(132.76,54.94)
PROJECT_ID1: length 17.1
  TOP w0.102: v1(126.99,72.71) 127.03,72.67 v2(127.68,72.67)
  L6 w0.102: v1(138.91,68.48) 138.47,68.91 135.17,68.91 134.56,69.52 132.89,69.52 131.34,71.07 129.23,71.07 127.59,72.71 v1(126.99,72.71)
  BOTTOM w0.089: v1(126.99,72.71) 127.32,73.05 CPU1.CK19
  BOTTOM w0.102: v1(138.91,68.48) 139.04,68.61 R2112.1 R2111.2
PROJECT_ID2: length 18.6
  L3 w0.102: v1(137.59,68.48) 137.59,68.55 135.09,71.05 133.23,71.05 131.62,72.66 131.62,73.02 131.32,73.32 131.32,73.77 131.08,74.01 130.75,74.01 130.42,73.69 125.12,73.69 v1(125.06,73.74)
  BOTTOM w0.089: v1(125.06,73.74) 125.06,73.8 125.37,74.11 CPU1.CG17
  BOTTOM w0.102: R2118.1 137.88,70.08 R2117.2 137.9,69.33 v2(137.69,69.12) 137.59,69.01 v1(137.59,68.48)
PROJECT_ID3: length 16.1
  L6 w0.102: v1(139.08,71.13) 138.67,70.72 136.15,70.72 133.58,73.28 133.19,73.28 132.96,73.05 132.63,73.05 132.35,73.33 131.03,73.33 130.93,73.43 v1(130.91,73.43)
  BOTTOM w0.102: R2116.1 140.76,71.2 R2115.2 140.56,71.05 139.67,71.94 v2(139.36,71.94) 139.08,71.66 v1(139.08,71.13) ; v1(130.91,73.43) 130.91,73.41 130.75,73.26 130.75,72.74 130.55,72.53 130.16,72.53 130.12,72.57 128.98,72.57 128.8,72.38 CPU1.CN20
PS_ID: length 15.7
  TOP w0.203: U2401.36 44.38,50.13 v1(44.34,50.09)
  TOP w0.305: v2(48.74,50.42) R4305.2 49.63,51.21 R4304.2 50.62,51.26 50.8,51.08 D4302.3 51.95,51.08 52.69,51.82 v1(52.69,51.83)
  L4 w0.305: v1(44.34,50.09) 44.88,50.62 45.28,50.62 45.84,50.07 50.18,50.07 51.94,51.83 52.69,51.83 v1(52.69,51.83)
PS_ID_R: length 8.2
  TOP w0.102: v1(26.33,94.39) 26.61,94.67 EC4311.1 27.1,95.02 AFTP4304.1 27.83,97.16 R4317.1
  BOTTOM w0.102: DCIN1.4 26.81,93.91 v1(26.33,94.39)
PS_ID_R1: length 110.1
  TOP w0.102: R4305.1 48.58,49.56 48.33,49.81 48.33,50.65 48.66,50.98 48.66,51.64 48.61,51.69 48.61,52.02 49.57,52.98 v1(49.64,52.98) ; v1(18.64,93.73) 18.82,93.91 18.82,94.74 18.49,95.07 18.49,95.74 19.04,96.29 21.23,96.29 21.38,96.14 v2(21.96,96.14) 22.22,96.14 22.96,96.88 R4306.2
  L4 w0.102: v1(18.64,93.73) 18.1,93.73 17.8,93.42 17.8,91.15 21.84,87.11 21.84,85.5 21.23,84.89 21.23,82.15 19.93,80.85 17.42,80.85 13.66,77.09 13.66,71.78 13.43,71.55 13.43,67.77 13.3,67.64 13.3,66.27 13.86,65.71 13.86,61.83 13.48,61.45 13.48,60.76 13.63,60.61 13.63,60 12.31,58.68 12.31,57.81 12.24,57.74 12.24,55.45 12.36,55.32 12.36,54.69 15.79,51.26 16.22,51.26 17.47,50.02 19.45,50.02 22.35,52.91 28.42,52.91 30.92,50.41 32.84,50.41 33.32,50.89 35.29,50.89 36.88,49.3 39.54,49.3 39.8,49.05 42.52,49.05 43.15,49.68 43.15,50.19 43.91,50.96 45.51,50.96 45.87,50.6 48.41,50.6 49.64,51.83 v1(49.64,52.98)
  BOTTOM w0.102: v1(18.64,93.73) 18.21,93.73 17.82,94.11 17.82,94.92 17.72,95.02 16.42,95.02 Q4301.S
PS_ID_R2: length 30.2
  TOP w0.102: v1(22.73,96.01) R4306.1 R4309.1 24.62,96.01 24.89,96.28 24.89,96.9 v1(24.91,96.93) ; v1(25.8,96.83) 25.9,96.93 25.9,97.49 27.02,98.61 R4317.2
  L3 w0.102: v1(24.91,96.93) 24.86,96.93 23.36,95.43 21.56,95.43 21.05,95.94 19.76,95.94 v1(19.48,95.66)
  L4 w0.102: v1(21.71,97.64) 22.12,97.64 23.36,96.4 25.37,96.4 v1(25.8,96.83)
  BOTTOM w0.102: v1(22.73,96.01) 22.47,96.01 21.23,97.26 19.32,97.26 19.03,97.55 D4303.2 D4303.1 21.46,97.89 v1(21.71,97.64) ; v1(19.48,95.66) 19.23,95.91 v2(18.82,95.91) 18.56,95.91 17.93,95.28 17.04,95.28 16.55,95.76 Q4301.D
PS_S3CNTRL: length 4.1
  TOP w0.254: v2(215.87,46.69) R4004.2 215.87,45.34 215.48,44.96 Q4001.6 216.11,44.7 216.22,44.59 216.22,44.23 216.04,44.05 Q4001.5
PSID_DISABLE#_R_C: length 21.9
  TOP w0.102: Q4302.C 31.37,98.87 v2(31.52,99.01) 31.52,99.72 31.01,100.23 17.6,100.23 v1(16.25,98.88)
  BOTTOM w0.102: v1(16.25,98.88) 16.96,98.88 R4303.2 16.99,98.5 17.19,98.3 17.19,96.15 Q4301.G
PTP_DIS#: length 6.9
  TOP w0.127: 26.54,40.72 26.54,40.16 26.46,40.08 v2(26.46,39.53) 26.87,39.12 30.5,39.12 31.09,39.71 U2401.90
PU4348_G: length 10.4
  TOP w0.254: v1(40.38,79.25) 40.38,79.1 40.58,78.9 R4370.2
  BOTTOM w0.254: R4369.1 33.45,77.37 Q4348.G 34.17,78.08 35.73,78.08 36.25,77.56 v2(36.39,77.56) 37.75,77.56 38.09,77.22 38.53,77.22 38.85,77.53 38.85,78.31 39.7,79.16 40.03,79.16 40.13,79.25 v1(40.38,79.25)
PURE_HW_SHUTDOWN#: length 302.7
  TOP w0.102: ED4001.2 207.09,51.47 v1(206.64,51.91) 206.45,52.11 206.45,52.71 205.73,53.42 204.79,53.42 R4007.2 ; v1(22.75,35.05) 22.73,35.08 22.5,35.08 22.32,35.26 22.32,35.97 22.04,36.25 22.04,36.53 21.41,37.16 21.41,38.18 20.64,38.94 20.64,40.41 21.05,40.82 23.11,40.82 23.34,41.04 23.34,41.84 23.67,42.17 C2610.1 25.24,42.17 25.44,41.96 R2615.1 25.39,41.23 Q2602.D ; v1(209.72,55.35) 210.14,54.94 D4001.K
  L3 w0.102: v1(206.64,51.91) 207.99,53.27 207.99,54.26 209.09,55.35 v1(209.72,55.35) 209.72,54.94 212.19,52.48 213.31,52.48 214.93,50.85 216.1,50.85 216.48,50.47 216.48,42.47 218.03,40.92 218.03,39.02 221.84,35.21 221.84,25.15 221.53,24.84 221.53,9.22 219.02,6.71 210.92,6.71 210.16,7.46 206,7.46 204.51,8.95 204.51,12.39 201.56,15.34 201.14,15.34 199.57,16.92 195.25,16.92 194.29,17.88 191.64,17.88 191.05,18.47 189.68,18.47 189.2,18.95 184.91,18.95 180.59,23.27 178.66,23.27 178.05,22.66 177.46,22.66 177.24,22.89 176.32,22.89 175.3,23.9 v1(175.3,24.41)
  L4 w0.102: v1(175.3,24.41) 175.2,24.51 175.2,31.07 176.02,31.88 v1(176.02,32.24)
  BOTTOM w0.102: v1(22.75,35.05) 23.92,33.89 v2(23.95,33.89) 25.67,33.89 27.86,31.7 28.65,31.7 29.41,30.94 34.51,30.94 35.1,30.36 36.02,30.36 38.02,32.35 40.75,32.35 41.09,32.69 41.45,32.69 43.52,34.76 46.97,34.76 47.19,34.55 47.19,33.89 47.67,33.4 48.92,33.4 49.73,32.59 50.77,32.59 51.84,31.52 53.45,31.52 54.77,30.2 154.58,30.2 154.93,30.56 174.7,30.56 176.02,31.88 v1(176.02,32.24)
PWR_1D0V_BT: length 2.2
  BOTTOM w0.305: PU5201.20 v2(147.08,68.99) 146.65,68.56 PC5204.1
PWR_1D0V_EN: length 3
  BOTTOM w0.127: PR5207.2 149.17,73.18 PC5215.1 149.88,72.77 149.4,72.29 v2(149.4,72.14) 149.45,72.09 PU5201.2
PWR_1D0V_FB: length 4.8
  BOTTOM w0.305: v2(153.08,71.96) 152.34,71.96 152.04,72.27 PR5204.1 151.73,72.34 150.95,71.56 PU5201.5
  BOTTOM w0.381: v2(153.08,71.96) 152.98,72.06 PR5202.2 PC5212.2
PWR_1D0V_FB_A: length 21.6
  TOP w0.254: v1(154.62,71.08) v2(155.26,71.08)
  L3 w0.381: v1(155.95,57.53) 156.43,58.02 156.43,69.09 154.62,70.91 v1(154.62,71.08)
  BOTTOM w0.381: v1(154.62,71.08) 154.81,71.08 155.19,71.47 155.19,72.16 154.43,72.93 PR5202.1 153.89,72.98 PC5212.1 ; PG5223.1 155.01,55.83 155.57,56.39 155.57,57.15 v1(155.95,57.53)
PWR_1D0V_PFM: length 2.6
  BOTTOM w0.254: PR5203.1 150.64,72.62 v2(150.57,72.55) 149.95,71.93 PU5201.3
PWR_1D0V_PG: length 3.8
  BOTTOM w0.127: PR5208.2 PR5206.2 148.33,72.78 147.67,72.12 v2(147.67,71.94) 147.97,71.63 148.66,71.63 148.95,71.34 PU5201.1
PWR_1D0V_PH: length 2.7
  BOTTOM w0.254: PC5204.2 v2(145.76,67.26)
  BOTTOM w0.508: 148.03,66.6 146.96,66.6 146.65,66.91 PC5204.2
PWR_1D0V_SS: length 2.7
  BOTTOM w0.254: v2(146.17,71.76) 146.45,71.76 147.24,70.97 147.24,70.89 PC5213.1 147.65,70.49 PU5201.22
PWR_1D0V_TON: length 3.4
  BOTTOM w0.254: v2(154.45,71.94) 153.71,71.2 PR5201.2 153.56,71.12 152.75,71.12 152.71,71.16 PU5201.6
PWR_1D8V_EN: length 4.8
  TOP w0.127: PR5305.2 93.63,12.73 93.14,13.21 v2(93.09,13.21) 93.07,13.23 PR5306.1 92.2,12.52 PC5304.1 92.83,12.45 v1(92.98,12.3)
  BOTTOM w0.127: PU5301.8 v1(92.98,12.3)
PWR_1D8V_POK: length 4.6
  TOP w0.127: v2(95.83,14.96) 95.29,14.43 PR5301.2 PR5304.2 93.57,14.43 v1(92.98,13.85)
  BOTTOM w0.127: v1(92.98,13.85) 92.7,13.57 PU5301.7
PWR_1D35V_BOOT_R: length 2.3
  BOTTOM w0.635: v2(183.18,48.26) PR8633.2 183.92,49.3 PC8619.1
PWR_1D35V_BYP: length 4.4
  TOP w0.102: v1(182.95,56.14) 183.2,55.88 v2(184.58,55.88) 184.63,55.93 PR8634.1 184.68,56.85 PC8618.1
  BOTTOM w0.102: v1(182.95,56.14) 182.86,56.05 PU8602.15
PWR_1D35V_EN: length 3.8
  TOP w0.102: v2(180.61,54.94) 180.97,55.3 180.97,56.01 v1(180.89,56.09) 180.89,56.67 PC8616.1 180.05,56.75 PR8631.2
  BOTTOM w0.102: v1(180.89,56.09) 181.06,55.92 PU8602.11
PWR_1D35V_IMAX: length 2.4
  TOP w0.254: PR8632.2 181.58,56.16 v1(181.55,56.14) 181.55,55.68 v2(181.71,55.53)
  BOTTOM w0.254: PU8602.13 181.96,55.73 v1(181.55,56.14)
PWR_1D35V_LDO_P5:
  vias: v1(185.54,56.14) v2(186.18,55.5)
PWR_1D35V_PGOOD: length 8.3
  TOP w0.102: v1(180.54,55.53) 180.05,55.53 179.78,55.81 178.76,55.81 178.56,56.01 178.56,57.28 PR8636.2 179.11,58.6 PR8635.2 179.09,59.39 v2(178.96,59.51)
  BOTTOM w0.102: v1(180.54,55.53) 180.66,55.4 PU8602.10 180.16,54.83 180.05,54.73 180.05,54.48 180.16,54.38 PU8602.9
PWR_1D35V_PHASE: length 6.7
  L3 w0.508: v1(179.45,53.11) 179.49,53.11 179.51,53.09 180.04,53.09 180.06,53.11 183.5,53.11 v1(184.45,52.16)
  BOTTOM w0.254: v1(179.45,53.11) 179.53,53.03 PU8602.6
  vias: v2(185.34,49.79)
PWR_1D35V_VFB: length 4.1
  TOP w0.254: v2(182.92,55.53) 182.84,55.53 182.32,56.05 v1(182.32,56.14)
  TOP w0.305: PC8602.2 183.69,56.8 PR8627.2 PR8626.1 182.34,56.16 v1(182.32,56.14)
  BOTTOM w0.254: PU8602.14 182.41,56.04 v1(182.32,56.14)
PWR_1D35V_VFB1: length 9.5
  TOP w0.254: v1(184.09,59.11) 184.06,59.11 183.86,58.91 v2(183.86,58.45) PC8602.1 183.23,57.53 PR8627.1
  TOP w0.305: PG8613.2 190.11,57.86 189.86,58.12 v1(189.86,58.17)
  L3 w0.381: v1(189.86,58.17) 185.03,58.17 v1(184.09,59.11)
PWR_1V: length 8.1
  BOTTOM w0.508: PC8632.1 149.12,82.37 PR8613.1 149.57,82.5 149.68,82.6 154.05,82.6 154.55,83.11 154.55,84.76
  vias: v2(153.28,86.74)
PWR_1V_FB: length 5.1
  BOTTOM w0.305: 145.84,84.43 145.71,84.56 PU8603.1
  BOTTOM w0.508: PR8613.2 149.17,83.29 PC8632.2 147.52,83.29 v2(147.47,83.34) 147.29,83.52 PR8620.1 146.04,84.23 145.84,84.43
PWR_1V_PHASE:
  vias: v2(147.8,87.58)
PWR_1V_PVDD:
  vias: v2(143.58,85.14)
PWR_2D5V:
  vias: v2(63.67,15.75)
PWR_2D5V_EN: length 4.2
  BOTTOM w0.102: PU5102.8 71.57,12.4 PC5129.1 72.41,12.3 PR5115.1 v2(73.35,12.25) PR5116.2
PWR_2D5V_FB:
  vias: v2(62.81,13.01)
PWR_2D5V_PG: length 25.5
  BOTTOM w0.127: PU5102.7 71.32,13.67 PR5114.2 72.18,14.53 73.07,14.53 73.35,14.81 73.35,16.82 72.97,17.2 67.69,17.2 67.25,17.63 61.31,17.63 61.18,17.76 60.07,17.76 v2(59.56,17.25) 59.56,14.94 58.62,14 58.62,13.26 58.34,12.98 PR5105.1
PWR_3D3V:
  vias: v2(185.29,47.27) v2(187.5,46.1) v3(185.24,46.61) v3(185.26,45.67) v3(186.1,46.7) v3(186.13,45.75) v3(188.89,46.69) v3(188.89,45.85) v3(188.92,45.01)
PWR_3D3V_BOOT: length 3.8
  TOP w0.254: PU4501.1 194.61,45.85 194.24,45.48
  TOP w0.508: 194.24,45.48 v2(193.57,44.81) 192.88,44.12 PR4501.1
PWR_3D3V_BOOT_A: length 2
  TOP w0.508: PR4501.2 191.05,42.8 PC4506.1 v2(189.96,42.98)
PWR_3D3V_EN: length 6.2
  TOP w0.127: PC4508.1 199.89,52.4 PR4508.1 199.61,51.41 PR4509.2 199.22,50.51 199.22,49.9 199.05,49.74 199,49.74 v2(198.85,49.58) 198.39,49.13 196.95,49.13 196.8,48.98 PU4501.11
PWR_3D3V_EN1: length 6.2
  TOP w0.102: PR4516.2 PR4514.1 PC4532.1 196.87,51.46 197,51.46 197.17,51.29 197.17,50.78 197.39,50.56 197.39,50.43 v2(197.73,50.09) 197.73,49.74 197.4,49.41 196.77,49.41 196.35,48.99 PU4501.12
PWR_3D3V_FB: length 2.4
  TOP w0.254: PU4501.13 195.9,48.79 195.93,48.82 195.93,49.2 v2(195.5,49.63) 195.5,50.4 PC4533.1
PWR_3D3V_FB2: length 2.1
  TOP w0.305: v2(196.69,50.75) 196.46,50.75 196.23,50.98 196.23,50.99 196.04,51.18 196.03,51.18 PC4533.2
  TOP w0.381: PR4506.2 195.65,51.56 PC4533.2
PWR_3D3V_LDO:
  vias: v2(193.69,48.62)
PWR_3D3V_PH: length 6.3
  TOP w0.254: v1(198.01,45.98) 198.01,45.99 197.76,46.25 PU4501.6
  BOTTOM w0.508: v3(192.88,46.43) 193.26,46.43 193.64,46.05 197.94,46.05 v1(198.01,45.98)
  vias: v2(190.98,46.43) v3(190.9,47.78) v3(190.9,45.05) v3(191.76,45.05) v3(191.97,47.78) v3(192.86,47.27) v3(192.78,45.52)
PWR_3D3V_VOUT: length 14.7
  TOP w0.254: PU4501.14 195.45,49.02 194.86,49.61 v1(194.86,49.99)
  TOP w0.381: PG4530.1 185.21,48.97 v1(184.98,49.2) ; PR4506.1 194.91,50.04 v1(194.86,49.99)
  L3 w0.381: v1(194.86,49.99) 194.48,50.37 193.34,50.37 192.83,49.86 185.64,49.86 v1(184.98,49.2)
  BOTTOM w0.381: v2(185.13,48.49) 185.13,49.05 v1(184.98,49.2)
PWR_3V_PG: length 5.2
  TOP w0.102: PU4501.9 197.65,47.6 198.1,48.05 ; PR4505.2 199.89,49.86 PG4531.2 199.84,49.1 v2(199.05,48.31) 198.79,48.05 198.1,48.05 ; 198.1,48.05 PU4501.10
PWR_5V:
  vias: v2(42.31,5.92) v3(39.95,5.87) v3(39.95,4.3) v3(40.28,6.66) v3(40.28,5.08) v3(43.94,6.48) v3(43.94,5.01) v3(44.01,7.95) v3(44.34,5.74) v3(44.42,7.19)
PWR_5V_BOOT: length 2.5
  TOP w0.508: v2(52.19,7.24) 51.6,7.24 v1(51.57,7.22) 51.25,7.22 50.74,6.71 PR4502.1
  BOTTOM w0.254: PU4502.1 51.8,6.98 v1(51.57,7.22)
PWR_5V_BOOT_A: length 2.5
  TOP w0.508: PR4502.2 v2(49.24,7.96) 49.24,8.36 v1(49.45,8.56)
  BOTTOM w0.508: PC4521.1 v1(49.45,8.56)
PWR_5V_EN: length 5.9
  TOP w0.254: PC4530.1 v1(55.8,3.58) v2(55.8,4.19)
  BOTTOM w0.254: PU4502.11 53.88,4.19 54.13,3.94 54.65,3.94 54.81,4.09 55.26,4.09 55.37,3.99 55.39,3.99 v1(55.8,3.58) PR4512.1 55.83,2.92 56.15,2.61 PR4511.2
PWR_5V_EN1: length 5.3
  TOP w0.102: PC4531.1 54.4,2.95 54.27,3.08 v2(54.27,3.48) 54.38,3.58 v1(55.03,3.58)
  BOTTOM w0.102: PU4502.12 53.43,3.92 54.26,3.09 54.26,2.94 PR4504.2 PR4513.1 55.04,3.58 v1(55.03,3.58)
PWR_5V_EN1_R: length 242.2
  TOP w0.102: v1(206.27,6.53) 206.01,6.53 204.21,8.33 204.21,12.17 200.55,15.83 195.88,15.83 v1(193.47,13.41) ; PR4515.2 195.75,52.38 PR4503.2 PR4530.2 194.76,53.47 194.76,54.36 194.61,54.51 v2(194,54.51) v1(194,53.9)
  L4 w0.102: v1(101.01,1.86) 101.47,1.4 114.65,1.4 v1(115.11,1.86) ; v1(212.39,23.29) 212.34,23.35 212.11,23.35 211.78,23.68 211.78,25.96 208.91,28.83 208.86,28.83 208.63,29.06 208.63,29.11 206.75,30.99 201.49,30.99 v1(201.06,31.42)
  L6 w0.102: v1(115.11,1.86) 115.67,1.3 126.03,1.3 127.93,3.2 148.89,3.2 148.93,3.17 153.63,3.17 153.66,3.2 168.8,3.2 168.9,3.1 170.81,3.1 170.91,3.2 178.66,3.2 182.92,7.46 184.22,7.46 188.21,11.46 191.51,11.46 v1(193.47,13.41)
  BOTTOM w0.102: v1(194,53.9) 194.23,53.67 194.23,51.64 196.39,49.48 198.16,49.48 198.67,48.97 198.67,47.2 199.16,46.71 199.16,45.47 193.73,40.05 193.73,34.3 196.91,31.12 199.39,31.12 199.92,31.65 200.83,31.65 v1(201.06,31.42) ; PR4504.1 54.27,1.86 54.94,1.19 100.35,1.19 v1(101.01,1.86) ; v1(212.39,23.29) 213.38,22.3 213.38,18.77 212.54,17.93 212.54,12.09 210.99,10.54 210.99,8.21 209.82,7.04 208.99,7.04 208.05,6.1 206.7,6.1 v1(206.27,6.53)
PWR_5V_FB: length 3.7
  TOP w0.381: PR4551.1 v2(52.62,2.67) 52.62,3 v1(53,3.38)
  BOTTOM w0.254: v1(53,3.38) 52.98,3.41 PU4502.13
  BOTTOM w0.381: v1(53,3.38) 53.51,2.87 PC4526.1
PWR_5V_FB_A: length 1.8
  BOTTOM w0.381: PC4526.2 52.78,1.78 PR4507.1 52.7,1.76 52.04,1.76 v2(51.86,1.58)
PWR_5V_LDO: length 4.1
  TOP w0.406: PG4528.1 52.5,4.27 51.88,3.66 v1(51.69,3.66) v2(51.12,3.66)
  BOTTOM w0.254: PU4502.15 52.08,3.98 51.75,3.66 v1(51.69,3.66)
  BOTTOM w0.508: 50.74,3.13 51.25,3.63 51.67,3.63 v1(51.69,3.66)
PWR_5V_PG: length 5.7
  TOP w0.102: v1(56.43,3.2) 56.76,2.87 PR4510.1 57.86,2.87 PG4529.2
  BOTTOM w0.102: 54.78,4.79 54.88,4.89 54.88,5.14 54.78,5.24 PU4502.9 ; 54.78,4.79 55.23,4.79 v2(55.47,4.55) 56.43,3.58 v1(56.43,3.2) ; 54.78,4.79 PU4502.10
PWR_5V_PH: length 6.3
  L4 w0.508: v1(55.13,6.59) 52.53,6.59 51.35,5.41 v1(50.21,5.41)
  BOTTOM w0.254: PU4502.6 v1(55.13,6.59)
  vias: v2(50.11,6.02)
PWR_5V_VCC: length 4
  TOP w0.508: v2(50.03,4.73) 50.67,4.73 v1(50.72,4.78) 50.82,4.88 PC4524.1
  BOTTOM w0.254: PU4502.17 50.97,5.24 50.72,4.98 v1(50.72,4.78) 50.73,4.79 PU4502.16
PWR_5V_VOUT: length 18.2
  TOP w0.381: PG4527.1 38.91,3.3 v1(38.91,1.86)
  BOTTOM w0.254: PR4507.2 52.75,2.9 52.5,3.15 52.5,3.61 52.53,3.64 PU4502.14
  BOTTOM w0.381: PR4507.2 51.66,2.67 51,2.01 v2(50.16,2.01) 49.83,2.01 49.42,1.6 47.03,1.6 46.59,1.15 39.48,1.15 38.91,1.73 v1(38.91,1.86)
PWR_CHG_ACIN: length 3.9
  TOP w0.254: v1(161,8.1) 160.22,7.32 160.22,7.27 v2(160.17,7.22) 160.22,7.17 PR4485.1 PR4484.2
  BOTTOM w0.203: v1(161,8.1) 160.98,8.12 160.98,8.18 160.89,8.27 PU4401.19
PWR_CHG_ACOK: length 104.2
  TOP w0.102: PR4432.2 98.7,5.69 v1(98.67,5.67) ; PR4463.2 171.34,7.65 170.81,7.11 170.81,6.58 171.11,6.28 PR4426.1 171.83,6.25 v2(171.83,5.13) 171.83,4.22 v1(172.1,3.94)
  L3 w0.102: v1(172.1,3.94) 172.1,3.43 171.88,3.2 164.84,3.2 164.71,3.33 153.44,3.33 153.31,3.2 126.66,3.2 126.54,3.33 119.12,3.33 v1(117.52,1.73)
  L4 w0.102: v1(98.67,5.67) 99.41,5.67 101.37,7.62 109.62,7.62 111.09,6.15 112.59,6.15 116.25,2.49 116.76,2.49 v1(117.52,1.73)
  BOTTOM w0.102: v1(172.1,3.94) 171.52,3.36 167.43,3.36 166.59,4.19 164.69,4.19 164.05,3.56 160.14,3.56 159.43,4.27 158.9,4.27 158.67,4.5 PR4429.2 158.85,6.63 PG4408.1 158.82,7.32 158.31,7.83 158.31,8.36 158.52,8.56 158.76,8.56 158.89,8.69 PU4401.24
PWR_CHG_ADP/ACIN: length 8
  TOP w0.254: v1(162.27,8.97) 162.43,9.12 v2(162.83,9.12) 162.81,9.1 162.81,8.55 163.48,7.88 163.48,7.7 163.99,7.19 165.63,7.19 166.54,6.28 PR4434.1 166.95,6.17 167.35,5.77 167.46,5.77 PR4437.1
  BOTTOM w0.127: v1(162.27,8.97) 162.27,9.02 162.25,9.04 PU4401.16
PWR_CHG_AIN: length 58.4
  TOP w0.254: PR4404.1 156.59,4.19 156.31,4.47 v1(156.31,4.73)
  BOTTOM w0.254: v1(156.31,4.73) 156.31,4.65 155.62,3.97 153.28,3.97 152.85,3.53 147.78,3.53 147.46,3.85 137.56,3.85 137.44,3.74 129.74,3.74 125.02,8.46 119.02,8.46 117.14,10.35 117.14,10.78 114.38,13.54 113.58,13.54 110.76,16.36 v2(108.42,16.36) 105.29,16.36 PD4408.3
PWR_CHG_AIN_R: length 17.1
  TOP w0.254: v2(169.97,6.33) 169.59,6.33 v1(169.34,6.07) 169.26,6.07 168.72,5.54 PR4437.2 ; v1(159.24,4.7) 159.24,4.81 159.35,4.93 PR4484.1 158.85,5.44 PR4406.1 PC4420.2 157.02,5.11 PR4404.2
  L4 w0.254: v1(159.24,4.7) 159.54,5.01 161.32,5.01 161.61,4.71 161.61,4.09 161.87,3.84 163.54,3.84 164.41,4.7 167.96,4.7 v1(169.34,6.07)
PWR_CHG_AMON: length 6.2
  TOP w0.254: PC4432.1 156.15,12.5 156.15,11.76 v2(156.2,11.71) 156.43,11.48 156.43,10.98 156.66,10.75 v1(156.86,10.75)
  BOTTOM w0.203: PU4401.29 157.65,11.05
  BOTTOM w0.254: PR4412.2 v1(156.86,10.75) 157.19,10.75 157.5,11.05 157.65,11.05
PWR_CHG_ASGATE: length 1.6
  TOP w0.356: TP4401.1 164.36,10.86 165.06,11.56 PR4490.2
PWR_CHG_ASGATE22: length 1.9
  TOP w0.305: v2(164.15,15.4) 163.44,14.68 PC4442.2 163.27,14.05 PR4445.1
PWR_CHG_ASGATE/NTC: length 5.6
  TOP w0.127: PR4491.2 PR4490.1 165.12,12.42 163.62,10.93 v1(163.62,10.87)
  BOTTOM w0.127: v1(163.62,10.87) 163.29,10.54 162.68,10.54 162.58,10.65 PU4401.13
  BOTTOM w0.254: v1(163.62,10.87) 164.1,10.87 v2(164.26,10.72)
PWR_CHG_BATGONE: length 4.4
  BOTTOM w0.203: PU4401.25 158.34,8.81 157.96,8.43 157.96,8.36
  BOTTOM w0.254: v2(156.13,6.61) 156.86,7.34 PR4409.1 157.09,7.27 PC4430.1 157.96,7.44 157.96,8.36
PWR_CHG_BGATE: length 42.6
  TOP w0.254: v1(152.93,4.7) 152.93,6.45 153.64,7.17 153.64,10.06 154.15,10.57 154.15,11.51 153.36,12.3 153.36,14.91 153.28,14.99 153.28,15.5 153.39,15.6 v1(153.39,17.74) ; PU4412.4 128.35,7.84 v1(129.08,7.11)
  BOTTOM w0.254: v1(152.93,4.7) 152.95,4.68 152.95,4.4 152.6,4.04 147.99,4.04 147.66,4.37 137.36,4.37 137.23,4.24 133.88,4.24 v2(131.64,6.48) PC4429.1 130.22,7.11 v1(129.08,7.11)
  BOTTOM w0.356: PR4443.1 154.05,16.94 153.39,17.6 v1(153.39,17.74)
PWR_CHG_BGATE/HG2: length 7.2
  BOTTOM w0.203: PU4401.32 158.06,12.25 157.86,12.45 157.86,13 156.56,14.3 156.03,14.3 PC4445.2 155.76,14.85 155.76,15.94 155.37,16.33 PR4443.2
  BOTTOM w0.305: PR4443.2 v2(155.37,17.6)
PWR_CHG_BGATE_22: length 3.9
  TOP w0.254: v2(140.08,17.43) 140,17.35 PR4495.1
  TOP w0.508: PD4409.K 139.21,16.37 PR4495.1 139.21,17.81 PD4411.K
PWR_CHG_BGATE_22_R: length 14.7
  TOP w0.406: PU4413.4 130.87,12.15 130.68,12.35 PC4443.2
  TOP w0.508: PC4443.2 130.68,12.93 v1(131.03,13.29) ; PR4495.2 137.92,17.78 v1(137.54,17.78) 137.54,17.78 137.41,17.91 137.28,17.91 137.26,17.94 v2(136.72,17.94) 136.65,17.94 PR4494.1
  L4 w0.508: v1(131.03,13.29) 131.03,14.61 132.2,15.78 136.83,15.78 137.74,16.68 137.74,17.59 v1(137.54,17.78)
PWR_CHG_BOOT1: length 4.2
  TOP w0.508: PR4402.2 164.88,13.13 164.88,13.05 v2(163.93,12.09) 163.53,11.69 163.53,11.68 162.99,11.14 v1(162.99,10.99)
  BOTTOM w0.203: PU4401.12 162.81,11.05 162.87,10.99 v1(162.99,10.99)
PWR_CHG_BOOT2: length 0.8
  BOTTOM w0.203: PU4401.4 160.09,13.16 159.89,13.36 159.89,13.52
  vias: v2(159.61,13.82)
PWR_CHG_BT1_R: length 2.4
  TOP w0.305: v2(167.58,13.64) 167.41,13.46 PR4402.1
  TOP w0.508: PC4436.2 PR4402.1
PWR_CHG_BT2_R: length 7.2
  TOP w0.508: v1(160.24,17.94) 160.67,18.37 162.71,18.37 163.21,17.86 163.21,17.27 v1(163.33,17.16)
  BOTTOM w0.305: v2(163.93,17.3) 163.85,17.22 163.39,17.22 v1(163.33,17.16)
  BOTTOM w0.508: PC4423.2 160.24,17.38 v1(160.24,17.94) ; v1(163.33,17.16) 163.24,17.07 PR4444.1
PWR_CHG_CMRSC: length 38
  TOP w0.254: PC4442.1 163.27,15.98 164.1,16.82 164.1,17.71 v1(164.31,17.91) ; v2(154.48,4.5) 154.63,4.65 v1(155.04,4.65)
  L4 w0.254: v1(164.31,17.91) 164.31,16.5 167.64,13.16 167.92,13.16 168.31,12.78 168.31,12.18 166.31,10.19 166.31,8.52 163.31,5.52 159,5.52 157.42,3.94 155.85,3.94 155.24,4.55 155.14,4.55 v1(155.04,4.65)
  BOTTOM w0.254: v1(164.31,17.91) 164.13,18.09 162.3,18.09 161.67,17.45 161.67,17.12 161.13,16.59 PR4438.1 ; PR4439.2 153.54,5.05 153.91,4.68 155.01,4.68 v1(155.04,4.65)
PWR_CHG_COMP: length 3.1
  BOTTOM w0.203: PU4401.28 157.68,10.65 157.43,10.39
  BOTTOM w0.254: 157.28,10.25 157.02,9.98 PC4433.1 PR4411.1 ; 157.28,10.25 v2(157.27,10.26) ; 157.28,10.25 157.43,10.39
PWR_CHG_COMP_R: length 3.2
  TOP w0.254: v2(154.17,9.17) 154.17,8.69 v1(154.3,8.56) 155.19,8.56 PC4431.1
  BOTTOM w0.254: PR4411.2 155.06,9.2 154.43,8.56 v1(154.3,8.56)
PWR_CHG_CSIN: length 6.6
  TOP w0.254: v1(163.11,10.1) 163.76,9.45 PC4415.1 164.84,10.04 PC4417.2 166.8,11.1 167.18,11.1
  BOTTOM w0.203: PU4401.14 162.85,10.25 162.99,10.11 163.1,10.11 v1(163.11,10.1)
  BOTTOM w0.254: v2(163.24,9.48) 163.24,9.97 v1(163.11,10.1)
PWR_CHG_CSIN_R: length 27.2
  TOP w0.254: v1(169.21,7.78) 169.21,7.83 169.23,7.85 169.23,7.93 169.49,8.18 169.69,8.18 170.05,8.54 v2(170.05,8.77) 169.82,8.99 PR4423.1
  L3 w0.254: v1(170.68,11.36) 170.66,11.38 170.15,11.38 169.79,11.74 169.77,11.74 169.67,11.84 168.62,11.84 168.19,11.41 166.64,11.41 166.24,11.81 164.48,11.81 164.33,11.66 162.05,11.66 161.13,12.58 157.17,12.58 156.56,11.97 154.25,11.97 153.64,11.36 v1(153.64,11.18)
  L4 w0.254: v1(169.21,7.78) 169.21,8.89 170.76,10.44 170.76,11.28 v1(170.68,11.36)
  BOTTOM w0.254: PG4402.2 152.39,11.71 152.93,11.18 v1(153.64,11.18)
PWR_CHG_CSIN_RR: length 3.6
  TOP w0.254: PR4423.2 168.47,9.35 168.47,10.37 168.04,10.8 PR4489.1 168.17,11.23 168.17,11.38 168.6,11.81 v2(168.8,11.81)
PWR_CHG_CSIP: length 6.7
  TOP w0.254: PR4488.2 165.42,7.83 PC4416.2 164.89,8.77 PC4415.2 163.98,8.13 v1(163.32,8.79)
  BOTTOM w0.203: v1(163.32,8.79) 163.11,8.79 162.79,9.12 162.79,9.64 162.65,9.78 162.64,9.78 162.64,9.78 162.62,9.78 162.55,9.85 PU4401.15
  BOTTOM w0.254: v1(163.32,8.79) 163.85,8.79 164.1,9.05 v2(164.41,9.05)
PWR_CHG_CSIP_R: length 29.3
  TOP w0.254: PR4422.1 168.62,8.18 168.62,7.57 v1(169.18,7.01) 169.72,7.55 v2(169.82,7.55)
  L3 w0.254: v1(153.18,11.69) 153.97,12.47 156.33,12.47 156.94,13.08 161.36,13.08 162.27,12.17 164.12,12.17 164.27,12.32 166.45,12.32 166.85,11.92 167.96,11.92 168.4,12.35 170.12,12.35 170.38,12.09 170.61,12.09 v1(170.63,12.07)
  L4 w0.254: v1(170.63,12.07) 170.69,12.07 171.39,11.36 171.39,10.34 169.82,8.77 169.82,8.16 169.77,8.11 169.77,7.39 169.39,7.01 v1(169.18,7.01)
  BOTTOM w0.254: PG4401.2 152.58,12.88 153.18,12.27 v1(153.18,11.69)
PWR_CHG_CSIP_RR: length 2.2
  TOP w0.254: PR4488.1 166.77,7.34 v2(167.28,7.34) 167.28,7.8 PR4422.2
PWR_CHG_CSON: length 7.6
  TOP w0.254: PR4487.1 155.75,15.32 v2(155.85,15.22) PC4425.2 156.51,14.38 157.22,13.67 v1(157.96,13.67)
  BOTTOM w0.203: 158.16,13.26 158.61,12.81 PU4401.1
  BOTTOM w0.254: PC4426.2 v1(157.96,13.67) 157.98,13.64 157.98,13.44 158.16,13.26
PWR_CHG_CSON_R: length 33.2
  TOP w0.254: PG4406.2 133.93,6.43 v1(133.65,6.71) ; PR4425.1 156.84,18.39 155.44,18.39 v1(154.81,17.76)
  L4 w0.254: v1(133.65,6.71) 133.65,10.48 139.16,16 139.16,16.54 139.95,17.33 147.34,17.33 148.28,18.27 152.02,18.27 153.05,17.23 154.28,17.23 v1(154.81,17.76)
  BOTTOM w0.254: v2(133.22,6.3) 133.24,6.3 v1(133.65,6.71)
PWR_CHG_CSON_RR: length 2.1
  TOP w0.254: PR4487.2 156.97,16.87 PR4425.2 156.51,17.86 v2(156.08,17.86)
PWR_CHG_CSOP: length 7.6
  TOP w0.254: v2(157.17,13.16) 157.3,13.03 158.19,13.03 v1(158.77,13.62) 158.03,14.35 157.63,14.35 PC4425.1 157.42,14.89 PR4486.1
  BOTTOM w0.203: PU4401.2 159.29,13.14 159.09,13.34 159.05,13.34 158.79,13.59
  BOTTOM w0.254: PC4424.2 157.8,14.58 v1(158.77,13.62) 158.77,13.62 158.79,13.59
PWR_CHG_CSOP_R: length 34.9
  TOP w0.254: PR4424.1 157.93,18.44 v2(158.79,18.44) 158.79,18.11 158.52,17.83 v1(158.44,17.83) ; PG4405.2 134.33,7.37 v1(134.33,6.94)
  L4 w0.254: v1(158.44,17.83) 158.31,17.96 155.75,17.96 154.51,16.72 152.83,16.72 151.77,17.78 148.56,17.78 147.59,16.82 140.16,16.82 139.67,16.33 139.67,15.79 134.16,10.27 134.16,7.22 134.33,7.04 v1(134.33,6.94)
PWR_CHG_CSOP_RR: length 2.4
  TOP w0.254: v2(157.04,15.65) 157.65,16.26 PR4486.2 157.93,17.22 PR4424.2
PWR_CHG_DCIN: length 5.1
  TOP w0.254: v1(162.29,8.33) 162.31,8.33 162.94,7.71 v2(162.94,7.67) 162.94,7.52 163.8,6.66 PC4419.1
  TOP w0.508: PR4403.1 163.49,6.17 PC4419.1
  BOTTOM w0.203: v1(162.29,8.33) 162.27,8.34 162.09,8.34 161.69,8.74 PU4401.17
PWR_CHG_DCIN_R: length 75.9
  TOP w0.508: PD4407.K 166.33,4.22 165.77,3.66 165.2,3.66 v1(165.17,3.63) PR4403.2
  BOTTOM w0.254: v1(165.17,3.63) 165.17,3.51 164.79,3.13 159.94,3.13 159.71,3.36 159.38,3.36 159.33,3.3 158.31,3.3 158.26,3.36 153.41,3.36 153.08,3.03 147.57,3.03 147.25,3.35 137.78,3.35 137.66,3.23 129.53,3.23 124.81,7.95 117.31,7.95 114.98,10.28 114.98,10.79 111.79,13.98 109.2,13.98 107.49,12.27 v2(107.17,12.27) 103.58,12.27 102.99,12.86 102.99,14.49 PD4401.3
PWR_CHG_HG1_R: length 28.1
  L4 w0.508: v3(167.7,12.52) 166.96,12.52 165.75,11.32 165.75,10.54 165.37,10.16 165.37,8.48 163.1,6.2 159.63,6.2 159.4,6.43 154.59,6.43 153.65,5.49 144.85,5.49 144.52,5.16 v3(144.29,5.16)
  vias: v2(144.27,4.3)
PWR_CHG_HG2_R: length 24.1
  TOP w0.508: PR4420.2 161.04,16.58 v3(161.04,17.63)
  L4 w0.508: v3(161.04,17.63) 161.04,17.49 159.25,15.7 157.02,15.7 155.87,14.56 152.57,14.56 151.86,15.27 143.3,15.27 142.16,14.13 141.78,14.13 141.22,13.57 v3(140.46,13.57)
  vias: v2(141.17,13.52)
PWR_CHG_LGATE1: length 18.3
  L4 w0.508: v3(162.73,13.16) 162.73,13.03 162.22,12.52 162.22,10.06 161.26,9.1 157.3,9.1 157.17,9.22 156.61,9.22 156.59,9.2 152.04,9.2 149.27,11.97 v1(149.27,12.4)
  vias: v2(148.76,12.78)
PWR_CHG_LGATE2: length 37.5
  TOP w0.305: v2(161.87,17.73) 162.3,17.3 v3(162.3,17.22)
  TOP w0.508: v3(162.3,17.22) 162.17,17.1 162.17,16.28 PR4446.1
  L4 w0.508: v3(136.29,6.96) 136.29,10.67 136.8,11.18 142.89,11.18 143.38,11.66 143.38,12.47 144.37,13.46 151,13.46 152.09,12.37 154.43,12.37 154.45,12.35 155.01,12.35 155.04,12.37 160.8,12.37 162.26,13.83 162.26,17.19 v3(162.3,17.22)
PWR_CHG_LGATE2/ASGATE: length 3.9
  TOP w0.508: PR4446.2 162.35,14.79 PR4445.2 162.22,14.13 v1(161.63,14.13)
  BOTTOM w0.203: PU4401.7 161.29,13.19 161.63,13.53 v1(161.63,14.13) 162.05,14.13 v2(162.22,14.3)
PWR_CHG_NGATE: length 6.2
  TOP w0.305: v1(158.92,14.25) 159.18,14.25 v2(159.53,14.61) 159.94,15.01 PR4453.2 159.61,16 159.23,15.62 PC4439.2
  BOTTOM w0.127: PU4401.3 159.69,13.12 159.61,13.21 159.61,13.26 159.23,13.64 159.23,13.95 v1(158.92,14.25)
  BOTTOM w0.305: v1(158.92,14.25) 158.92,15.06 PR4480.1
PWR_CHG_NTC: length 3.2
  TOP w0.254: PR4491.1 166.34,11.61 166.71,11.61 v2(167.17,12.07) 167.33,11.92 167.96,11.92 168.65,12.6 PR4492.1
PWR_CHG_OTGEN: length 14.9
  TOP w0.254: v1(170.28,3.84) 170.25,3.86 PR4449.2
  L3 w0.254: v1(170.28,3.84) 170.3,3.86 170.3,4.22 170.05,4.47 162.77,4.47 v1(162.64,4.35)
  BOTTOM w0.203: 160.67,7.5 160.52,7.65 160.52,8.3 160.49,8.33 PU4401.20
  BOTTOM w0.254: 160.67,7.5 PR4451.1 PR4417.2 161.72,7.34 162.48,6.58 v2(162.48,6.3) 162.64,6.14 v1(162.64,4.35)
PWR_CHG_OTGPG: length 5.6
  TOP w0.254: v1(157.14,8) 156.76,8 TP4411.1 155.32,7.39 PR4447.1 PR4448.2
  BOTTOM w0.203: 157.8,9.22 157.78,9.24 157.78,9.63 158,9.85 PU4401.26
  BOTTOM w0.254: v1(157.14,8) 157.14,8.12 157.8,8.77 157.8,9.22
PWR_CHG_PHASE1: length 29.4
  L4 w0.508: v3(143.38,6.58) 144.55,6.58 144.88,6.25 153.33,6.25 154.27,7.19 159.72,7.19 159.95,6.96 162.78,6.96 164.46,8.64 164.46,10.93 163.57,11.82 163.57,13.11 v3(163.62,13.16)
  BOTTOM w0.203: PU4401.10 162.69,11.85 163.49,12.65 163.49,13.03 v3(163.62,13.16)
  vias: v2(142.92,10.29) v2(164.13,13.67) v3(142.49,8.26) v3(142.49,7.42) v3(142.49,6.58) v3(143.33,8.26) v3(143.38,7.42) v3(144.27,8.54)
PWR_CHG_PHASE2:
  vias: v2(141.4,10.9) v3(139.87,6.61) v3(140.66,8.31) v3(140.66,7.47) v3(140.71,6.61) v3(141.55,8.31) v3(141.55,7.47) v3(141.55,6.61)
PWR_CHG_PHASE2_R: length 24.2
  TOP w0.406: v2(143.15,12.37) PR4441.2
  TOP w0.508: PR4441.2 v3(142.11,13.36)
  L4 w0.508: v3(142.11,13.36) 142.59,13.36 143.73,14.51 151.48,14.51 152.37,13.62 156.08,13.62 157.4,14.94 159.58,14.94 159.63,14.99 160.45,14.99 160.85,14.58 160.85,14.55 160.9,14.5 v3(160.9,13.85)
  BOTTOM w0.203: v3(160.9,13.85) 160.89,13.84 PU4401.6
PWR_CHG_PROCHOT#: length 14.2
  TOP w0.089: v1(163.77,10.24) 163.77,10.24 163.65,10.24 163.37,10.52 162.89,10.52 161.59,9.22 159.84,9.22 v1(158.74,8.13) 158.46,7.85 v2(158.46,7.44)
  BOTTOM w0.089: v1(158.74,8.13) 159.02,8.41 159.1,8.41 159.29,8.6 PU4401.23 ; v1(163.77,10.24) 165.2,10.24 165.46,10.49 166.02,10.49 166.31,10.2 PQ4416.2 166.31,9.53 166.7,9.14 167.22,9.14 167.26,9.18 168.1,9.18 168.55,9.63 PR4435.2
PWR_CHG_PROCHOT#_R: length 133.1
  TOP w0.254: PQ4402.G 211.42,57.3 v2(210.48,56.37) v1(210.48,55.35)
  L3 w0.254: v1(210.48,55.35) 210.48,54.79 212.37,52.91 213.49,52.91 215.11,51.29 216.68,51.29 217.82,50.14 217.82,42.57 218.82,41.58 219.83,41.58 222.7,38.71 222.7,7.83 220.72,5.84 206.55,5.84 206.22,5.51 v1(205.43,5.51)
  L6 w0.254: v1(205.43,5.51) 205.38,5.57 205.38,6.71 204.64,7.44 203.73,7.44 201.57,9.6 201.57,12.64 199.71,14.5 196.56,14.5 193.39,11.33 193.39,9.63 188.44,4.68 v1(187.29,4.68)
  BOTTOM w0.254: v1(187.29,4.68) 181.02,4.68 177.95,7.75 175.15,7.75 174.76,7.36 173.06,7.36 172.28,8.13 172.28,9.66 171.22,10.72 PR4472.2 170.02,10.49 167.76,10.49 167.48,10.77 167.48,11.22 167.25,11.45 PQ4416.6 166.96,10.95 166.78,10.77 166.49,10.77 166.31,10.95 PQ4416.5
PWR_CHG_PROG: length 4.9
  TOP w0.254: PR4493.1 156.31,8.59 v1(156.89,8.59)
  BOTTOM w0.203: 157.4,9.48 157.4,9.76 157.89,10.25 PU4401.27
  BOTTOM w0.254: 157.4,9.48 157.4,9.1 v2(157.32,9.02) v1(156.89,8.59) 156.71,8.41 PC4441.1 156.33,7.7 PR4410.2
PWR_CHG_SNB: length 2
  TOP w0.305: v2(141.62,4.32) 141.75,4.45 PR4416.2
  TOP w0.635: PC4435.1 PR4416.2
PWR_CHG_UGATE1: length 1.3
  BOTTOM w0.203: 163.49,11.64 162.95,11.64 162.77,11.45 PU4401.11
  vias: v2(163.87,12.12)
PWR_CHG_UGATE2: length 2.9
  TOP w0.508: PR4420.1 160.95,14.96 160.27,14.28 160.17,14.28 160.14,14.25 v3(160.12,14.25)
  BOTTOM w0.203: v3(160.12,14.25) 160.24,14.13 160.24,13.5 160.49,13.25 PU4401.5
  vias: v2(160.73,14.68)
PWR_CHG_VBAT1:
  vias: v2(156.33,13.82)
PWR_CHG_VBATIN:
  vias: v2(128.92,3.97)
PWR_CHG_VBATIN_R: length 37.9
  L4 w0.508: v1(146.48,17.99) 146.32,18.14 139.29,18.14 138.53,17.38 138.53,16.26 137.2,14.94 132.45,14.94 131.79,14.28 131.79,11.36 130.17,9.73 v3(129.08,9.73)
  BOTTOM w0.508: v1(146.48,17.99) 146.98,17.48 147.64,17.48 148.66,18.49 156.87,18.49 158.16,17.2 158.52,17.2 159,16.72 PR4480.2
  vias: v2(129.53,9.07) v3(127.93,9.73) v3(127.88,8.59) v3(128.95,8.59)
PWR_CHG_VDDP: length 22.6
  TOP w0.254: PR4405.1 162.3,4.9 162.17,4.78 v1(162.14,4.78)
  L4 w0.254: v1(162.14,4.78) 162.36,5.01 163.52,5.01 166.82,8.31 166.82,9.96 168.82,11.95 168.82,12.99 168.14,13.67 167.86,13.67 166.9,14.63 v1(166.9,15.67)
  BOTTOM w0.203: 162.78,13.79 162.43,13.79 161.69,13.06 PU4401.8
  BOTTOM w0.254: 162.78,13.79 163.93,14.94 PC4421.1 v2(165.53,14.94) 166.24,14.94 166.9,15.6 v1(166.9,15.67)
PWR_DCBATOUT_1D0V:
  vias: v2(156.28,69.34) v3(153.15,67.84) v3(153.14,67) v3(153.14,66.17) v3(153.13,65.31)
PWR_DCBATOUT_1D35V:
  vias: v2(179.32,51.23) v3(179.8,52.28) v3(180.46,51.64) v3(181.38,51.69) v3(182.24,51.67)
PWR_DCBATOUT_3D3V:
  vias: v2(198.22,44.43)
PWR_DCBATOUT_5V:
  vias: v2(56.33,7.93) v3(54.13,8.21) v3(54.54,7.42) v3(55.01,8.21) v3(55.42,7.42)
PWR_DCBATOUT_VCCGTA:
  vias: v1(51.66,72.01) v1(51.64,71.32) v2(49.7,71.96) v2(50.59,67.8) v2(50.67,68.28) v2(51.23,77.75) v3(49.91,69.07) v3(50.74,69.07) v3(51,67.06) v3(52.01,79.48) v3(51.99,78.56) v3(52.01,76.58) v3(53.08,79.57)
PWR_DCBATOUT_VCCSA:
  vias: v2(88.46,97.87)
PWR_DCBATOUT_VCORE:
  vias: v1(52.34,61.88) v1(52.33,61.18) v2(50.97,56.39) v3(51.25,58.58) v3(52.09,58.55)
PWR_DCBATOUT_VDDQ: length 11.4
  L6 w0.508: v1(58.44,12.4) 57.65,11.61 52.62,11.61 v3(49.45,14.79)
  BOTTOM w0.508: v1(58.44,12.4) 58.26,12.22 PR5103.1
  vias: v2(49.19,13.85) v3(48.58,14.89)
PWR_VCCGT_BOOTA: length 2.8
  TOP w0.305: 49.35,72.55 49.65,72.24 PU4801.5
  TOP w0.508: 49.35,72.55 v2(48.94,72.95) 48.81,73.08 PR4804.2
PWR_VCCGT_BOOTA_RC: length 2.9
  TOP w0.305: v2(47.64,70.67) 47.11,71.2 PC4808.1
  TOP w0.635: PC4808.1 46.58,72.34 PR4804.1
PWR_VCCGT_BOOTB: length 2.6
  TOP w0.254: PU4802.5 51.04,82.63 50.95,82.73
  TOP w0.508: PR4810.2 50.41,83.26 v2(50.46,83.21) 50.95,82.73
PWR_VCCGT_BOOTB_RC: length 2.4
  TOP w0.635: PC4811.1 v2(47.8,81.99) 47.8,83.04 PR4810.1
PWR_VCCGT_BOOTRA: length 2.3
  TOP w0.305: PU4801.7 49.57,71.24
  TOP w0.508: 49.57,71.24 49.47,71.15 v2(49.42,71.15) 49.09,71.15 PC4808.2
PWR_VCCGT_BOOTRB: length 2.9
  TOP w0.254: 50.98,81.63 50.98,81.63 PU4802.7
  TOP w0.305: v2(50.36,80.85) 50.36,81.38 50.16,81.59 PC4811.2
  TOP w0.508: PC4811.2 50.62,81.99 50.98,81.63
PWR_VCCGT_COMP: length 8.2
  TOP w0.254: PC4610.2 37.64,65.66 35.83,63.86 v2(35.83,63.81) 35.83,63.63 36.09,63.38 v1(36.27,63.38)
  BOTTOM w0.203: 36.9,65.76 PU4601.4
  BOTTOM w0.254: PR4626.2 35.93,62.61 36.3,62.98 36.3,63.34 v1(36.27,63.38) 36.27,63.43 36.14,63.56 36.14,64.53 36.14,64.53 36.14,65.1 36.8,65.76 36.9,65.76
PWR_VCCGT_COMP1: length 4.1
  BOTTOM w0.254: PR4626.1 34.51,62.61 33.83,61.93 v2(32.51,61.93) 32.51,61.14 PC4612.1 PC4651.1
PWR_VCCGT_FB: length 4.5
  BOTTOM w0.203: PU4601.5 36.92,66.16
  BOTTOM w0.254: PR4630.2 PR4633.2 35.61,64.09 PR4671.2 35.61,65.68 PR4636.2 36.06,65.68 v2(36.49,66.12) 36.54,66.16 36.92,66.16
PWR_VCCGT_FB1: length 1.8
  BOTTOM w0.381: PR4630.1 34.59,63.27 PC4614.1 33.65,62.99 v2(33.65,62.39)
PWR_VCCGT_FB2: length 7.4
  BOTTOM w0.381: PR4631.1 PR4665.2 31.77,65.54 31.68,65.63 31.68,65.64 31.54,65.78 PC4619.1 ; PR4631.1 32.2,64.49 32.38,64.67 33.67,64.67 PC4618.1 33.85,64.11 PC4615.2 34.59,64.04 PR4633.1 34.74,64.19 PR4671.1 ; PR4631.1 31.54,64.26 31.54,63.83 v2(31.31,63.6)
PWR_VCCGT_FB_RC: length 2
  BOTTOM w0.305: PC4618.2 33.78,65.76 33.27,65.26 v2(32.96,65.26)
  BOTTOM w0.381: PC4618.2 34.67,65.76 PR4636.1
PWR_VCCGT_FCCM#: length 27.1
  TOP w0.254: v2(36.93,68.25) 37.42,68.75 v1(37.51,68.75) ; v1(48.69,84.48) 48.76,84.41 PR4812.2 ; v1(46.6,74.45) 46.73,74.45 46.98,74.21 PR4806.2
  L4 w0.254: v1(48.69,84.48) 48.69,76.61 47.44,75.36 47.44,75.01 46.91,74.48 46.68,74.48 46.65,74.45 v1(46.6,74.45) 46.6,74.42 43.96,71.78 41.35,71.78 40.48,70.92 40.48,69.21 39.52,68.25 38.01,68.25 v1(37.51,68.75)
  BOTTOM w0.203: v1(37.51,68.75) PU4601.11
PWR_VCCGT_FCCM#_RA: length 2.2
  TOP w0.254: PU4801.2 50.03,73.74 49.57,74.21 v2(49.4,74.21) PR4806.1
PWR_VCCGT_FCCM#_RB: length 2.6
  TOP w0.254: PU4802.2 51.2,84.13 50.92,84.41 PR4812.1 50.26,85.04 v2(50.01,85.3)
PWR_VCCGT_IMON: length 6.3
  TOP w0.254: v1(37.28,64.04) 37.26,64.01 37.23,64.01 36.85,63.63 36.85,62.92 PR4608.2 PR4672.2 36.62,61.93 PC4604.2 36.82,61.19 37.64,62 v2(37.64,62.18)
  BOTTOM w0.203: v1(37.28,64.04) 37.23,64.04 36.9,64.37 36.9,64.75 37.12,64.96 PU4601.2
PWR_VCCGT_ISEN1: length 8.6
  BOTTOM w0.203: PU4601.9 37.12,67.76 36.9,67.98 36.9,67.99 36.7,68.19 36.7,69.13 36.57,69.26 36.57,71.4 36.37,71.61 PR4669.2 35.33,71.61 PC4625.1 35.1,71.84 PR4821.1 PR4824.2 35.1,73.33 v2(34.26,74.17)
PWR_VCCGT_ISEN2: length 10.3
  BOTTOM w0.203: PU4601.10 37.19,68.16 37.03,68.33 37.03,69.27 36.9,69.4 36.9,71.68 v2(36.95,71.73) 36.78,71.73 PR4669.1 35.96,72.55 35.96,73.36 PR4635.2 35.91,73.43 PR4823.1 34.36,74.98 PR4822.2 33.37,74.83 PC4626.1
PWR_VCCGT_ISUMN: length 42.4
  TOP w0.203: v1(32.91,71.02) 33.27,71.02 v2(33.45,70.84)
  L6 w0.203: v1(31.03,73.71) 31.03,72.72 32.73,71.02 v1(32.91,71.02) 33.6,71.71 33.7,71.71 33.75,71.76 38.6,71.76 38.65,71.71 38.7,71.71 38.78,71.63 49.19,71.63 50.26,70.56 56.46,70.56 58.24,68.79 v1(58.29,68.79)
  BOTTOM w0.203: v1(31.03,73.71) 31.28,73.46 PR4815.2 31.85,73.61 PC4626.2 ; v1(32.91,71.02) 33.01,71.02 PR4809.2 33.66,71.66 PC4625.2 34.36,71.66 PR4645.2 34.37,70.84 PR4642.2 34.07,70.06 33.78,70.36 PR4647.1 33.5,70.34 33.5,69.67 PC4633.1 33.53,69.46 PR4643.2 34.02,68.72 34.31,69.01 PC4630.2 35.05,69.07 PR4670.2 ; PR4646.2 57.96,67.92 58.29,68.25 v1(58.29,68.79)
PWR_VCCGT_ISUMN_GA: length 42.4
  TOP w0.203: v2(62.4,73.36) 62.12,73.64 v1(62.12,74.04)
  L6 w0.203: v1(31.36,75.16) 31.36,75 32.1,74.27 32.1,72.8 32.61,72.29 v1(33.45,72.29) 33.62,72.47 38.77,72.47 39.02,72.21 50.06,72.21 50.84,73 50.84,73.66 52.7,75.52 55.92,75.52 56.51,76.1 57.27,76.1 57.73,76.56 60.73,76.56 60.93,76.36 60.93,74.59 61.33,74.2 61.97,74.2 v1(62.12,74.04)
  BOTTOM w0.203: v1(31.36,75.16) 31.54,74.98 PR4822.1 ; PR4809.1 32.81,71.66 v1(33.45,72.29) ; PG4809.1 61.7,73.33 61.7,73.84 61.9,74.04 v1(62.12,74.04)
PWR_VCCGT_ISUMN_GB: length 39.4
  TOP w0.254: v1(62.32,81.09) 62,81.41 v2(62,82.71)
  L6 w0.254: v1(33.45,73.59) 33.95,73.59 35.02,74.65 35.02,75.01 35.76,75.75 36.52,75.75 37.97,74.3 40.23,74.3 40.61,73.92 48.15,73.92 51.48,77.24 57.02,77.24 57.32,77.55 60.91,77.55 61.77,78.41 61.77,80.83 62.02,81.09 v1(62.32,81.09)
  BOTTOM w0.254: PR4815.1 32.84,73.59 v1(33.45,73.59) 33.47,73.61 33.85,73.61 34.01,73.45 34.04,73.45 PR4824.1 ; PG4815.1 v1(62.32,81.09)
PWR_VCCGT_ISUMN_P_1: length 2.3
  BOTTOM w0.254: PR4647.2 31.92,70.36 PC4609.2 PC4653.2 PC4628.2
PWR_VCCGT_ISUMN_P_2: length 54.3
  L4 w0.254: v1(56.38,68.61) 56.23,68.46 52.88,68.46 51.61,67.19 51.61,66.8 51.2,66.4 49.83,66.4 49.02,67.21 49.02,73.76 50.46,75.21 50.46,81.18 49.91,81.74 49.45,81.74 49.19,81.49 49.19,76.38 47.95,75.14 47.95,74.63 43.94,70.61 v1(41.27,70.61)
  L6 w0.254: v1(41.27,70.61) 41.24,70.59 39.62,70.59 39.41,70.39 37.89,70.39 37.74,70.54 37.28,70.54 37.23,70.49 35.43,70.49 34.84,69.9 32.15,69.9 31.58,69.33 31.58,69.08 31.44,68.94 v1(31.44,68.89)
  BOTTOM w0.254: PR4646.1 56.48,68.51 v1(56.38,68.61) 56.08,68.91 56.08,69.04 v2(56.05,69.07) ; v1(31.44,68.89) 31.49,68.94 32.56,68.94 PR4641.2
